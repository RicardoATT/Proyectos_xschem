v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1070 -240 -270 160 {flags=graph
y1=-0.95152595
y2=0.95950379
ypos1=0
ypos2=2

subdivy=1
unity=1
x1=-0.9
x2=0.9

subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vout

vin
voutori"
color="4 6 10"
dataset=-1
unitx=1
logx=0
logy=0

divy=12
divx=20
linewidth_mult=1.6}
B 2 -1080 310 -280 710 {flags=graph
y1=-0.9
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.9
x2=0.9
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vin
vout2"
color="7 9"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 160 370 960 770 {flags=graph
y1=-0.9
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.9
x2=0.9
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vout3
vin"
color="6 7"
dataset=-1
unitx=1
logx=0
logy=0
}
N -180 30 -120 30 {
lab=vin}
N -120 30 -120 50 {
lab=vin}
N -230 20 -230 30 {
lab=VDD}
N -20 -40 -20 -20 {
lab=VDD}
N -120 70 -120 110 {
lab=GND}
N -20 80 -20 110 {
lab=#net1}
N -70 110 -70 120 {
lab=GND}
N -180 90 -180 100 {
lab=GND}
N -230 90 -230 100 {
lab=GND}
N -60 -50 -60 -40 {
lab=VDD}
N -70 -110 -60 -110 {
lab=VDD}
N 60 30 60 50 {
lab=vout}
N -120 -160 -120 10 {
lab=vout}
N -120 -160 60 -160 {
lab=vout}
N 60 -160 60 30 {
lab=vout}
N -60 -110 -60 -50 {
lab=VDD}
N -120 110 -70 110 {
lab=GND}
N -20 110 -20 120 {
lab=#net1}
N -20 180 -20 190 {
lab=GND}
N -20 370 -20 390 {
lab=VDD}
N -120 480 -120 520 {
lab=GND}
N -20 490 -20 520 {
lab=#net2}
N -70 520 -70 530 {
lab=GND}
N -60 360 -60 370 {
lab=VDD}
N -70 300 -60 300 {
lab=VDD}
N -60 300 -60 360 {
lab=VDD}
N -120 520 -70 520 {
lab=GND}
N -20 520 -20 530 {
lab=#net2}
N -20 590 -20 600 {
lab=GND}
N -250 440 -220 440 {
lab=vin}
N -160 440 -120 440 {
lab=#net3}
N -120 420 -120 440 {
lab=#net3}
N -150 340 -150 440 {
lab=#net3}
N 60 340 60 440 {
lab=vout2}
N -90 250 -90 340 {
lab=vout2}
N -90 250 60 250 {
lab=vout2}
N 60 250 60 340 {
lab=vout2}
N 60 440 60 450 {
lab=vout2}
N -120 460 -120 480 {
lab=GND}
N 670 -30 670 -10 {
lab=VDD}
N 570 80 570 120 {
lab=GND}
N 670 90 670 120 {
lab=#net4}
N 620 120 620 130 {
lab=GND}
N 630 -40 630 -30 {
lab=VDD}
N 620 -100 630 -100 {
lab=VDD}
N 630 -100 630 -40 {
lab=VDD}
N 570 120 620 120 {
lab=GND}
N 670 120 670 130 {
lab=#net4}
N 670 190 670 200 {
lab=GND}
N 440 40 470 40 {
lab=vin}
N 530 40 570 40 {
lab=#net5}
N 570 20 570 40 {
lab=#net5}
N 540 -60 540 40 {
lab=#net5}
N 750 -60 750 40 {
lab=vout3}
N 600 -150 600 -60 {
lab=vout3}
N 600 -150 750 -150 {
lab=vout3}
N 750 -150 750 -60 {
lab=vout3}
N 750 40 750 50 {
lab=vout3}
N 570 60 570 80 {
lab=GND}
N 530 170 530 250 {
lab=#net5}
N 530 70 530 170 {
lab=#net5}
N 530 70 550 70 {
lab=#net5}
N 550 40 550 70 {
lab=#net5}
N 390 180 470 180 {
lab=#net6}
N 470 170 470 180 {
lab=#net6}
N 430 310 430 330 {
lab=GND}
N 390 310 430 310 {
lab=GND}
N 390 240 390 310 {
lab=GND}
N 430 250 470 250 {
lab=#net7}
N -1410 -10 -1350 -10 {
lab=vin}
N -1350 -10 -1350 10 {
lab=vin}
N -1250 -80 -1250 -60 {
lab=VDD}
N -1350 30 -1350 70 {
lab=GND}
N -1250 40 -1250 70 {
lab=#net8}
N -1300 70 -1300 80 {
lab=GND}
N -1290 -90 -1290 -80 {
lab=VDD}
N -1300 -150 -1290 -150 {
lab=VDD}
N -1170 -10 -1170 10 {
lab=voutori}
N -1350 -200 -1350 -30 {
lab=voutori}
N -1350 -200 -1170 -200 {
lab=voutori}
N -1170 -200 -1170 -10 {
lab=voutori}
N -1290 -150 -1290 -90 {
lab=VDD}
N -1350 70 -1300 70 {
lab=GND}
N -1250 70 -1250 80 {
lab=#net8}
N -1250 140 -1250 150 {
lab=GND}
C {/home/ral298/Documentos/opam/twoatage_symbol.sym} 90 -80 0 0 {name=x1 W1=2.13 W2=9 W3=8.7 W4=9 W5=9.8 W6=8.7 L1=0.3965 L2=0.3965 L3=0.3965 L4=0.9 L5=1.2 L6=0.8}
C {devices/vdd.sym} -20 -40 0 0 {name=l1 lab=VDD}
C {devices/vdd.sym} -230 20 0 0 {name=l2 lab=VDD}
C {devices/vsource.sym} -230 60 0 0 {name=V1 value=\{v1vdd\} savecurrent=false}
C {devices/vsource.sym} -180 60 0 0 {name=V2 value=0 savecurrent=false}
C {devices/gnd.sym} -70 120 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} -180 100 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} -230 100 0 0 {name=l5 lab=GND}
C {devices/vdd.sym} -70 -110 0 0 {name=l7 lab=VDD}
C {devices/code_shown.sym} 120 -120 0 0 {name=s1 only_toplevel=false value="
.dc V2 0.9 -0.9 -0.01
.param v1vdd=0.9
.param v3vss=-0.9
.control
	run
	
	plot v(vout) 
	plot v(vout2) 
	plot v(vin) 
	write pruebas.raw
.endc
.save all
"}
C {devices/lab_pin.sym} 60 40 0 1 {name=p1 sig_type=std_logic lab=vout}
C {sky130_fd_pr/corner.sym} 110 120 0 0 {name=CORNER only_toplevel=true corner=tt}
C {devices/launcher.sym} -140 210 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/pruebas.raw"
}
C {devices/lab_pin.sym} -150 30 1 0 {name=p2 sig_type=std_logic lab=vin}
C {devices/vsource.sym} -20 150 0 0 {name=V3 value=\{v3vss\} savecurrent=false}
C {devices/gnd.sym} -20 190 0 0 {name=l6 lab=GND}
C {/home/ral298/Documentos/opam/twoatage_symbol.sym} 90 330 0 0 {name=x2 W1=2.13 W2=9 W3=8.7 W4=9 W5=9.8 W6=8.7 L1=0.3965 L2=0.3965 L3=0.3965 L4=0.9 L5=1.2 L6=0.8}
C {devices/vdd.sym} -20 370 0 0 {name=l8 lab=VDD}
C {devices/gnd.sym} -70 530 0 0 {name=l10 lab=GND}
C {devices/vdd.sym} -70 300 0 0 {name=l13 lab=VDD}
C {devices/lab_pin.sym} 60 450 0 1 {name=p3 sig_type=std_logic lab=vout2}
C {devices/lab_pin.sym} -250 440 1 0 {name=p4 sig_type=std_logic lab=vin}
C {devices/vsource.sym} -20 560 0 0 {name=V6 value=\{v3vss\} savecurrent=false}
C {devices/gnd.sym} -20 600 0 0 {name=l14 lab=GND}
C {devices/res.sym} -190 440 1 0 {name=R1
value=100k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} -120 340 1 0 {name=R2
value=100k
footprint=1206
device=resistor
m=1}
C {/home/ral298/Documentos/opam/twoatage_symbol.sym} 780 -70 0 0 {name=x3 W1=2.13 W2=9 W3=8.7 W4=9 W5=9.8 W6=8.7 L1=0.3965 L2=0.3965 L3=0.3965 L4=0.9 L5=1.2 L6=0.8}
C {devices/vdd.sym} 670 -30 0 0 {name=l9 lab=VDD}
C {devices/gnd.sym} 620 130 0 0 {name=l11 lab=GND}
C {devices/vdd.sym} 620 -100 0 0 {name=l12 lab=VDD}
C {devices/lab_pin.sym} 750 50 0 1 {name=p5 sig_type=std_logic lab=vout3}
C {devices/lab_pin.sym} 440 40 1 0 {name=p6 sig_type=std_logic lab=vin}
C {devices/vsource.sym} 670 160 0 0 {name=V4 value=\{v3vss\} savecurrent=false}
C {devices/gnd.sym} 670 200 0 0 {name=l15 lab=GND}
C {devices/res.sym} 500 40 1 0 {name=R3
value=100k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 570 -60 1 0 {name=R4
value=100k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 500 170 1 0 {name=R5
value=100k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 500 250 1 0 {name=R6
value=100k
footprint=1206
device=resistor
m=1}
C {devices/vsource.sym} 390 210 0 0 {name=V5 value=0.1 savecurrent=false}
C {devices/vsource.sym} 430 280 0 0 {name=V7 value=-0.2 savecurrent=false}
C {devices/gnd.sym} 430 330 0 0 {name=l16 lab=GND}
C {/home/ral298/Documentos/opam/twoatage_symbol.sym} -1140 -120 0 0 {name=x4 W1=15 W2=94 W3=3 W4=4.5 W5=14 W6=10 L1=0.15 L2=0.15 L3=0.15 L4=0.15 L5=0.15 L6=0.15}
C {devices/vdd.sym} -1250 -80 0 0 {name=l17 lab=VDD}
C {devices/gnd.sym} -1300 80 0 0 {name=l19 lab=GND}
C {devices/vdd.sym} -1300 -150 0 0 {name=l22 lab=VDD}
C {devices/lab_pin.sym} -1170 0 0 1 {name=p7 sig_type=std_logic lab=voutori}
C {devices/lab_pin.sym} -1380 -10 1 0 {name=p8 sig_type=std_logic lab=vin}
C {devices/vsource.sym} -1250 110 0 0 {name=V10 value=\{v3vss\} savecurrent=false}
C {devices/gnd.sym} -1250 150 0 0 {name=l23 lab=GND}
