v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/LIF_neuron_Vohra.sym} -40 -60 0 0 {name=x1}
C {sky130_fd_pr/rram_v0.sym} 10 -200 1 0 {name=R1
model=rram_v0
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/LIF_neuron_Vohra.sym} 450 -60 0 0 {name=x2}
