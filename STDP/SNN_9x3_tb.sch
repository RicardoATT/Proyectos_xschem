v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1160 -1200 -360 -800 {flags=graph
y1=-0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"Vpres1 [V];vpres1\\"
\\"Vpres2 [V];vpres2\\""
color="4 6"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 -1960 -1200 -1160 -800 {flags=graph
y1=-2.4e-06
y2=0.00042
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="10 11 12 13"
node="\\"Isyn11 (A);i(vmeas11)\\"
\\"Isyn12 (A);i(vmeas12)\\"
\\"Isyn21 (A);i(vmeas21)\\"
\\"Isyn22 (A);i(vmeas22)\\""}
B 2 -1960 -800 -1160 -400 {flags=graph
y1=-0.29
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="7 8"
node="\\"Vpos1 [V];vpos1\\"
\\"Vpos2 [V];vpos2\\""}
B 2 -1160 -800 -360 -400 {flags=graph
y1=2.64298
y2=5.16612
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="10 11 12 13"
node="\\"Thickness11 [nm]; 5 n.x11.xr1.n1#ngap -\\"
\\"Thickness12 [nm]; 5 n.x21.xr1.n1#ngap -\\"
\\"Thickness21 [nm]; 5 n.x12.xr1.n1#ngap -\\"
\\"Thickness22 [nm]; 5 n.x22.xr1.n1#ngap -\\""}
B 2 -1160 -400 -360 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 -1960 -400 -1160 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="17 21"
node="\\"Control 1;ctrl1\\"
\\"Control 2;ctrl2\\""}
B 2 -1960 -1600 -1160 -1200 {flags=graph
y1=-3.1e-11
y2=5.8e-08
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16"
node="\\"Ip1 (A);i(vmeas3)\\"
\\"Ip2 (A);i(vmeas4)\\""}
B 2 -1160 -1600 -360 -1200 {flags=graph
y1=-0.028
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="15 16"
node="\\"Vp1 [V];vp1\\"
\\"Vp2 [V];vp2\\""}
B 2 -1960 -2000 -1160 -1600 {flags=graph
y1=-1.15845e-07
y2=1.4252e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0







color="10 11 12 13"
node="\\"Im11 (A);i(vmeas11)\\"
\\"Im12 (A);i(vmeas12)\\"
\\"Im21 (A);i(vmeas21)\\"
\\"Im22 (A);i(vmeas22)\\""}
B 2 -1160 -2000 -360 -1600 {flags=graph
y1=-8.9e-05
y2=0.073
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000200076
x2=0.000251373
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh1
inh2
inh_d"}
N -1920 -3100 -1920 -3080 {
lab=GND}
N -1920 -3180 -1920 -3160 {
lab=vdd_in}
N -1840 -3100 -1840 -3080 {
lab=GND}
N -1840 -3180 -1840 -3160 {
lab=vdd_pre}
N -2980 -470 -2980 -450 {
lab=GND}
N -2980 -630 -2980 -610 {
lab=vdd_pre}
N -3080 -480 -3070 -480 {
lab=vb_pre}
N -3340 -460 -3340 -440 {
lab=GND}
N -3140 -560 -3140 -540 {
lab=vc1}
N -3140 -540 -3080 -540 {
lab=vc1}
N -3140 -590 -3130 -590 {
lab=vdd_in}
N -3130 -620 -3130 -590 {
lab=vdd_in}
N -3140 -620 -3130 -620 {
lab=vdd_in}
N -3220 -590 -3180 -590 {
lab=#net1}
N -3260 -620 -3140 -620 {
lab=vdd_in}
N -3270 -590 -3260 -590 {
lab=vdd_in}
N -3270 -620 -3270 -590 {
lab=vdd_in}
N -3270 -620 -3260 -620 {
lab=vdd_in}
N -3260 -560 -3260 -540 {
lab=#net1}
N -3260 -540 -3200 -540 {
lab=#net1}
N -3200 -590 -3200 -540 {
lab=#net1}
N -3340 -540 -3340 -520 {
lab=#net2}
N -1660 -3100 -1660 -3080 {
lab=GND}
N -1660 -3180 -1660 -3160 {
lab=vdd_delay}
N -2560 -480 -2560 -470 {
lab=GND}
N -2560 -590 -2560 -580 {
lab=vdd_syn1}
N -2730 -670 -2730 -660 {
lab=GND}
N -2500 -520 -2500 -510 {
lab=#net3}
N -2500 -410 -2490 -410 {
lab=GND}
N -2500 -450 -2500 -440 {
lab=#net4}
N -2500 -380 -2500 -370 {
lab=pattern1}
N -2560 -180 -2560 -170 {
lab=vb_pos}
N -2500 -190 -2500 -180 {
lab=#net5}
N -2500 -260 -2500 -250 {
lab=pattern1}
N -2500 60 -2500 70 {
lab=vp1}
N -1920 -2680 -1920 -2660 {
lab=GND}
N -1920 -2760 -1920 -2740 {
lab=uw}
N -1920 -2540 -1920 -2520 {
lab=GND}
N -1920 -2620 -1920 -2600 {
lab=training}
N -2840 -540 -2830 -540 {
lab=vpre1}
N -2570 -80 -2570 -60 {
lab=GND}
N -2430 -80 -2430 -60 {
lab=vdd_pos}
N -1920 -2400 -1920 -2380 {
lab=GND}
N -1920 -2480 -1920 -2460 {
lab=inference}
N -3280 -540 -3260 -540 {
lab=#net1}
N -1920 -2820 -1920 -2800 {
lab=GND}
N -1920 -2900 -1920 -2880 {
lab=ctrl1}
N -2730 -330 -2730 -320 {
lab=GND}
N -2680 -380 -2680 -370 {
lab=vpres1}
N -2790 -400 -2780 -400 {
lab=ctrl1}
N -2730 -500 -2730 -490 {
lab=GND}
N -2780 -540 -2780 -530 {
lab=vpre1}
N -2790 -580 -2790 -570 {
lab=ctrl2}
N -2790 -570 -2780 -570 {
lab=ctrl2}
N -1740 -2820 -1740 -2800 {
lab=GND}
N -1740 -2900 -1740 -2880 {
lab=ctrl2}
N -2790 -420 -2790 -400 {
lab=ctrl1}
N -1760 -2960 -1760 -2940 {
lab=GND}
N -1760 -3040 -1760 -3020 {
lab=vbias}
N -1750 -3100 -1750 -3080 {
lab=GND}
N -1750 -3180 -1750 -3160 {
lab=vdd_pos}
N -1550 -3100 -1550 -3080 {
lab=GND}
N -1550 -3180 -1550 -3160 {
lab=vdd_sw}
N -1470 -3100 -1470 -3080 {
lab=GND}
N -1470 -3180 -1470 -3160 {
lab=vdd_tg}
N -1920 -2960 -1920 -2940 {
lab=GND}
N -1920 -3040 -1920 -3020 {
lab=vb_pre}
N -1840 -2960 -1840 -2940 {
lab=GND}
N -1840 -3040 -1840 -3020 {
lab=vb_pos}
N -2730 -610 -2730 -580 {
lab=vdd_tg}
N -2730 -780 -2730 -750 {
lab=vdd_delay}
N -2730 -450 -2730 -410 {
lab=vdd_sw}
N -2790 -710 -2790 -700 {
lab=vpre1}
N -2670 -710 -2670 -700 {
lab=vpos1}
N -2680 -550 -2680 -540 {
lab=vpres1}
N -2620 -550 -2620 -540 {
lab=vpres1}
N -2500 -550 -2500 -540 {
lab=vpos1}
N -2790 -370 -2780 -370 {
lab=uw}
N -2790 -340 -2780 -340 {
lab=vbias}
N -2980 -990 -2980 -970 {
lab=GND}
N -2980 -1150 -2980 -1130 {
lab=vdd_pre}
N -3080 -1000 -3070 -1000 {
lab=vb_pre}
N -3340 -980 -3340 -960 {
lab=GND}
N -3140 -1080 -3140 -1060 {
lab=vc2}
N -3140 -1060 -3080 -1060 {
lab=vc2}
N -3140 -1110 -3130 -1110 {
lab=vdd_in}
N -3130 -1140 -3130 -1110 {
lab=vdd_in}
N -3140 -1140 -3130 -1140 {
lab=vdd_in}
N -3220 -1110 -3180 -1110 {
lab=#net6}
N -3260 -1140 -3140 -1140 {
lab=vdd_in}
N -3270 -1110 -3260 -1110 {
lab=vdd_in}
N -3270 -1140 -3270 -1110 {
lab=vdd_in}
N -3270 -1140 -3260 -1140 {
lab=vdd_in}
N -3260 -1080 -3260 -1060 {
lab=#net6}
N -3260 -1060 -3200 -1060 {
lab=#net6}
N -3200 -1110 -3200 -1060 {
lab=#net6}
N -3340 -1060 -3340 -1040 {
lab=#net7}
N -2560 -1000 -2560 -990 {
lab=GND}
N -2560 -1110 -2560 -1100 {
lab=vdd_syn1}
N -2730 -1190 -2730 -1180 {
lab=GND}
N -2500 -1040 -2500 -1030 {
lab=#net8}
N -2500 -930 -2490 -930 {
lab=GND}
N -2500 -970 -2500 -960 {
lab=#net9}
N -2500 -900 -2500 -890 {
lab=pattern1}
N -2840 -1060 -2830 -1060 {
lab=vpre2}
N -3280 -1060 -3260 -1060 {
lab=#net6}
N -2730 -850 -2730 -840 {
lab=GND}
N -2680 -900 -2680 -890 {
lab=vpres2}
N -2790 -920 -2780 -920 {
lab=ctrl1}
N -2730 -1020 -2730 -1010 {
lab=GND}
N -2780 -1060 -2780 -1050 {
lab=vpre2}
N -2790 -1100 -2790 -1090 {
lab=ctrl2}
N -2790 -1090 -2780 -1090 {
lab=ctrl2}
N -2790 -940 -2790 -920 {
lab=ctrl1}
N -2730 -1130 -2730 -1100 {
lab=vdd_tg}
N -2730 -1300 -2730 -1270 {
lab=vdd_delay}
N -2730 -970 -2730 -930 {
lab=vdd_sw}
N -2790 -1230 -2790 -1220 {
lab=vpre2}
N -2670 -1230 -2670 -1220 {
lab=vpos2}
N -2680 -1070 -2680 -1060 {
lab=vpres2}
N -2620 -1070 -2620 -1060 {
lab=vpres2}
N -2500 -1070 -2500 -1060 {
lab=vpos2}
N -2790 -890 -2780 -890 {
lab=uw}
N -2790 -860 -2780 -860 {
lab=vbias}
N -1920 -3240 -1920 -3220 {
lab=GND}
N -1920 -3320 -1920 -3300 {
lab=vdd_syn1}
N -1820 -3240 -1820 -3220 {
lab=GND}
N -1820 -3320 -1820 -3300 {
lab=vdd_syn2}
N -2340 -480 -2340 -470 {
lab=GND}
N -2340 -590 -2340 -580 {
lab=vdd_syn2}
N -2280 -520 -2280 -510 {
lab=#net10}
N -2280 -410 -2270 -410 {
lab=GND}
N -2280 -450 -2280 -440 {
lab=#net11}
N -2280 -380 -2280 -370 {
lab=pattern2}
N -2340 -180 -2340 -170 {
lab=vb_pos}
N -2280 -190 -2280 -180 {
lab=#net12}
N -2280 -260 -2280 -250 {
lab=pattern2}
N -2280 60 -2280 70 {
lab=vp2}
N -2350 -80 -2350 -60 {
lab=GND}
N -2210 -80 -2210 -60 {
lab=vdd_pos}
N -2400 -550 -2400 -540 {
lab=vpres1}
N -2280 -550 -2280 -540 {
lab=vpos1}
N -2340 -1000 -2340 -990 {
lab=GND}
N -2340 -1110 -2340 -1100 {
lab=vdd_syn2}
N -2280 -1040 -2280 -1030 {
lab=#net13}
N -2280 -930 -2270 -930 {
lab=GND}
N -2280 -970 -2280 -960 {
lab=#net14}
N -2280 -900 -2280 -890 {
lab=pattern2}
N -2400 -1070 -2400 -1060 {
lab=vpres2}
N -2280 -1070 -2280 -1060 {
lab=vpos2}
N -2550 -930 -2540 -930 {
lab=ctrl_pos}
N -2330 -930 -2320 -930 {
lab=ctrl_pos}
N -2550 -410 -2540 -410 {
lab=ctrl_pos}
N -2330 -410 -2320 -410 {
lab=ctrl_pos}
N -1550 -2820 -1550 -2800 {
lab=GND}
N -1550 -2900 -1550 -2880 {
lab=ctrl_pos}
N -1390 -3100 -1390 -3080 {
lab=GND}
N -1390 -3180 -1390 -3160 {
lab=vdd_inh}
N -3220 -210 -3220 -200 {
lab=vdd_inh}
N -3300 -170 -3290 -170 {
lab=vp1}
N -3300 -130 -3290 -130 {
lab=vp2}
N -2220 -180 -2220 -170 {
lab=inh2}
N -2440 -180 -2440 -170 {
lab=inh1}
N -1370 -2820 -1370 -2800 {
lab=GND}
N -1370 -2900 -1370 -2880 {
lab=vinh}
N -3080 -110 -3080 -100 {
lab=GND}
N -3160 -150 -3140 -150 {
lab=#net15}
N -3080 -200 -3080 -190 {
lab=vdd_delay}
N -3220 -100 -3220 -90 {
lab=GND}
N -3020 -150 -3010 -150 {
lab=inh_d}
N -3220 0 -3210 0 {
lab=inh1}
N -3250 -10 -3250 0 {
lab=GND}
N -3250 40 -3250 50 {
lab=inh_d}
N -3290 0 -3280 0 {
lab=vinh}
N -3030 0 -3020 0 {
lab=inh2}
N -3060 -10 -3060 0 {
lab=GND}
N -3060 40 -3060 50 {
lab=inh_d}
N -3100 0 -3090 0 {
lab=vinh}
N -2980 -1510 -2980 -1490 {
lab=GND}
N -2980 -1670 -2980 -1650 {
lab=vdd_pre}
N -3080 -1520 -3070 -1520 {
lab=vb_pre}
N -3340 -1500 -3340 -1480 {
lab=GND}
N -3140 -1600 -3140 -1580 {
lab=vc1}
N -3140 -1580 -3080 -1580 {
lab=vc1}
N -3140 -1630 -3130 -1630 {
lab=vdd_in}
N -3130 -1660 -3130 -1630 {
lab=vdd_in}
N -3140 -1660 -3130 -1660 {
lab=vdd_in}
N -3220 -1630 -3180 -1630 {
lab=#net16}
N -3260 -1660 -3140 -1660 {
lab=vdd_in}
N -3270 -1630 -3260 -1630 {
lab=vdd_in}
N -3270 -1660 -3270 -1630 {
lab=vdd_in}
N -3270 -1660 -3260 -1660 {
lab=vdd_in}
N -3260 -1600 -3260 -1580 {
lab=#net16}
N -3260 -1580 -3200 -1580 {
lab=#net16}
N -3200 -1630 -3200 -1580 {
lab=#net16}
N -3340 -1580 -3340 -1560 {
lab=#net17}
N -2560 -1520 -2560 -1510 {
lab=GND}
N -2560 -1630 -2560 -1620 {
lab=vdd_syn1}
N -2730 -1710 -2730 -1700 {
lab=GND}
N -2500 -1560 -2500 -1550 {
lab=#net18}
N -2500 -1450 -2490 -1450 {
lab=GND}
N -2500 -1490 -2500 -1480 {
lab=#net19}
N -2500 -1420 -2500 -1410 {
lab=pattern1}
N -2840 -1580 -2830 -1580 {
lab=vpre1}
N -3280 -1580 -3260 -1580 {
lab=#net16}
N -2730 -1370 -2730 -1360 {
lab=GND}
N -2680 -1420 -2680 -1410 {
lab=vpres1}
N -2790 -1440 -2780 -1440 {
lab=ctrl1}
N -2730 -1540 -2730 -1530 {
lab=GND}
N -2780 -1580 -2780 -1570 {
lab=vpre1}
N -2790 -1620 -2790 -1610 {
lab=ctrl2}
N -2790 -1610 -2780 -1610 {
lab=ctrl2}
N -2790 -1460 -2790 -1440 {
lab=ctrl1}
N -2730 -1650 -2730 -1620 {
lab=vdd_tg}
N -2730 -1820 -2730 -1790 {
lab=vdd_delay}
N -2730 -1490 -2730 -1450 {
lab=vdd_sw}
N -2790 -1750 -2790 -1740 {
lab=vpre1}
N -2670 -1750 -2670 -1740 {
lab=vpos1}
N -2680 -1590 -2680 -1580 {
lab=vpres1}
N -2620 -1590 -2620 -1580 {
lab=vpres1}
N -2500 -1590 -2500 -1580 {
lab=vpos1}
N -2790 -1410 -2780 -1410 {
lab=uw}
N -2790 -1380 -2780 -1380 {
lab=vbias}
N -2980 -2030 -2980 -2010 {
lab=GND}
N -2980 -2190 -2980 -2170 {
lab=vdd_pre}
N -3080 -2040 -3070 -2040 {
lab=vb_pre}
N -3340 -2020 -3340 -2000 {
lab=GND}
N -3140 -2120 -3140 -2100 {
lab=vc2}
N -3140 -2100 -3080 -2100 {
lab=vc2}
N -3140 -2150 -3130 -2150 {
lab=vdd_in}
N -3130 -2180 -3130 -2150 {
lab=vdd_in}
N -3140 -2180 -3130 -2180 {
lab=vdd_in}
N -3220 -2150 -3180 -2150 {
lab=#net20}
N -3260 -2180 -3140 -2180 {
lab=vdd_in}
N -3270 -2150 -3260 -2150 {
lab=vdd_in}
N -3270 -2180 -3270 -2150 {
lab=vdd_in}
N -3270 -2180 -3260 -2180 {
lab=vdd_in}
N -3260 -2120 -3260 -2100 {
lab=#net20}
N -3260 -2100 -3200 -2100 {
lab=#net20}
N -3200 -2150 -3200 -2100 {
lab=#net20}
N -3340 -2100 -3340 -2080 {
lab=#net21}
N -2560 -2040 -2560 -2030 {
lab=GND}
N -2560 -2150 -2560 -2140 {
lab=vdd_syn1}
N -2730 -2230 -2730 -2220 {
lab=GND}
N -2500 -2080 -2500 -2070 {
lab=#net22}
N -2500 -1970 -2490 -1970 {
lab=GND}
N -2500 -2010 -2500 -2000 {
lab=#net23}
N -2500 -1940 -2500 -1930 {
lab=pattern1}
N -2840 -2100 -2830 -2100 {
lab=vpre2}
N -3280 -2100 -3260 -2100 {
lab=#net20}
N -2730 -1890 -2730 -1880 {
lab=GND}
N -2680 -1940 -2680 -1930 {
lab=vpres2}
N -2790 -1960 -2780 -1960 {
lab=ctrl1}
N -2730 -2060 -2730 -2050 {
lab=GND}
N -2780 -2100 -2780 -2090 {
lab=vpre2}
N -2790 -2140 -2790 -2130 {
lab=ctrl2}
N -2790 -2130 -2780 -2130 {
lab=ctrl2}
N -2790 -1980 -2790 -1960 {
lab=ctrl1}
N -2730 -2170 -2730 -2140 {
lab=vdd_tg}
N -2730 -2340 -2730 -2310 {
lab=vdd_delay}
N -2730 -2010 -2730 -1970 {
lab=vdd_sw}
N -2790 -2270 -2790 -2260 {
lab=vpre2}
N -2670 -2270 -2670 -2260 {
lab=vpos2}
N -2680 -2110 -2680 -2100 {
lab=vpres2}
N -2620 -2110 -2620 -2100 {
lab=vpres2}
N -2500 -2110 -2500 -2100 {
lab=vpos2}
N -2790 -1930 -2780 -1930 {
lab=uw}
N -2790 -1900 -2780 -1900 {
lab=vbias}
N -2340 -1520 -2340 -1510 {
lab=GND}
N -2340 -1630 -2340 -1620 {
lab=vdd_syn2}
N -2280 -1560 -2280 -1550 {
lab=#net24}
N -2280 -1450 -2270 -1450 {
lab=GND}
N -2280 -1490 -2280 -1480 {
lab=#net25}
N -2280 -1420 -2280 -1410 {
lab=pattern2}
N -2400 -1590 -2400 -1580 {
lab=vpres1}
N -2280 -1590 -2280 -1580 {
lab=vpos1}
N -2340 -2040 -2340 -2030 {
lab=GND}
N -2340 -2150 -2340 -2140 {
lab=vdd_syn2}
N -2280 -2080 -2280 -2070 {
lab=#net26}
N -2280 -1970 -2270 -1970 {
lab=GND}
N -2280 -2010 -2280 -2000 {
lab=#net27}
N -2280 -1940 -2280 -1930 {
lab=pattern2}
N -2400 -2110 -2400 -2100 {
lab=vpres2}
N -2280 -2110 -2280 -2100 {
lab=vpos2}
N -2550 -1970 -2540 -1970 {
lab=ctrl_pos}
N -2330 -1970 -2320 -1970 {
lab=ctrl_pos}
N -2550 -1450 -2540 -1450 {
lab=ctrl_pos}
N -2330 -1450 -2320 -1450 {
lab=ctrl_pos}
N -2980 -2550 -2980 -2530 {
lab=GND}
N -2980 -2710 -2980 -2690 {
lab=vdd_pre}
N -3080 -2560 -3070 -2560 {
lab=vb_pre}
N -3340 -2540 -3340 -2520 {
lab=GND}
N -3140 -2640 -3140 -2620 {
lab=vc1}
N -3140 -2620 -3080 -2620 {
lab=vc1}
N -3140 -2670 -3130 -2670 {
lab=vdd_in}
N -3130 -2700 -3130 -2670 {
lab=vdd_in}
N -3140 -2700 -3130 -2700 {
lab=vdd_in}
N -3220 -2670 -3180 -2670 {
lab=#net28}
N -3260 -2700 -3140 -2700 {
lab=vdd_in}
N -3270 -2670 -3260 -2670 {
lab=vdd_in}
N -3270 -2700 -3270 -2670 {
lab=vdd_in}
N -3270 -2700 -3260 -2700 {
lab=vdd_in}
N -3260 -2640 -3260 -2620 {
lab=#net28}
N -3260 -2620 -3200 -2620 {
lab=#net28}
N -3200 -2670 -3200 -2620 {
lab=#net28}
N -3340 -2620 -3340 -2600 {
lab=#net29}
N -2560 -2560 -2560 -2550 {
lab=GND}
N -2560 -2670 -2560 -2660 {
lab=vdd_syn1}
N -2730 -2750 -2730 -2740 {
lab=GND}
N -2500 -2600 -2500 -2590 {
lab=#net30}
N -2500 -2490 -2490 -2490 {
lab=GND}
N -2500 -2530 -2500 -2520 {
lab=#net31}
N -2500 -2460 -2500 -2450 {
lab=pattern1}
N -2840 -2620 -2830 -2620 {
lab=vpre1}
N -3280 -2620 -3260 -2620 {
lab=#net28}
N -2730 -2410 -2730 -2400 {
lab=GND}
N -2680 -2460 -2680 -2450 {
lab=vpres1}
N -2790 -2480 -2780 -2480 {
lab=ctrl1}
N -2730 -2580 -2730 -2570 {
lab=GND}
N -2780 -2620 -2780 -2610 {
lab=vpre1}
N -2790 -2660 -2790 -2650 {
lab=ctrl2}
N -2790 -2650 -2780 -2650 {
lab=ctrl2}
N -2790 -2500 -2790 -2480 {
lab=ctrl1}
N -2730 -2690 -2730 -2660 {
lab=vdd_tg}
N -2730 -2860 -2730 -2830 {
lab=vdd_delay}
N -2730 -2530 -2730 -2490 {
lab=vdd_sw}
N -2790 -2790 -2790 -2780 {
lab=vpre1}
N -2670 -2790 -2670 -2780 {
lab=vpos1}
N -2680 -2630 -2680 -2620 {
lab=vpres1}
N -2620 -2630 -2620 -2620 {
lab=vpres1}
N -2500 -2630 -2500 -2620 {
lab=vpos1}
N -2790 -2450 -2780 -2450 {
lab=uw}
N -2790 -2420 -2780 -2420 {
lab=vbias}
N -2980 -3070 -2980 -3050 {
lab=GND}
N -2980 -3230 -2980 -3210 {
lab=vdd_pre}
N -3080 -3080 -3070 -3080 {
lab=vb_pre}
N -3340 -3060 -3340 -3040 {
lab=GND}
N -3140 -3160 -3140 -3140 {
lab=vc2}
N -3140 -3140 -3080 -3140 {
lab=vc2}
N -3140 -3190 -3130 -3190 {
lab=vdd_in}
N -3130 -3220 -3130 -3190 {
lab=vdd_in}
N -3140 -3220 -3130 -3220 {
lab=vdd_in}
N -3220 -3190 -3180 -3190 {
lab=#net32}
N -3260 -3220 -3140 -3220 {
lab=vdd_in}
N -3270 -3190 -3260 -3190 {
lab=vdd_in}
N -3270 -3220 -3270 -3190 {
lab=vdd_in}
N -3270 -3220 -3260 -3220 {
lab=vdd_in}
N -3260 -3160 -3260 -3140 {
lab=#net32}
N -3260 -3140 -3200 -3140 {
lab=#net32}
N -3200 -3190 -3200 -3140 {
lab=#net32}
N -3340 -3140 -3340 -3120 {
lab=#net33}
N -2560 -3080 -2560 -3070 {
lab=GND}
N -2560 -3190 -2560 -3180 {
lab=vdd_syn1}
N -2730 -3270 -2730 -3260 {
lab=GND}
N -2500 -3120 -2500 -3110 {
lab=#net34}
N -2500 -3010 -2490 -3010 {
lab=GND}
N -2500 -3050 -2500 -3040 {
lab=#net35}
N -2500 -2980 -2500 -2970 {
lab=pattern1}
N -2840 -3140 -2830 -3140 {
lab=vpre2}
N -3280 -3140 -3260 -3140 {
lab=#net32}
N -2730 -2930 -2730 -2920 {
lab=GND}
N -2680 -2980 -2680 -2970 {
lab=vpres2}
N -2790 -3000 -2780 -3000 {
lab=ctrl1}
N -2730 -3100 -2730 -3090 {
lab=GND}
N -2780 -3140 -2780 -3130 {
lab=vpre2}
N -2790 -3180 -2790 -3170 {
lab=ctrl2}
N -2790 -3170 -2780 -3170 {
lab=ctrl2}
N -2790 -3020 -2790 -3000 {
lab=ctrl1}
N -2730 -3210 -2730 -3180 {
lab=vdd_tg}
N -2730 -3380 -2730 -3350 {
lab=vdd_delay}
N -2730 -3050 -2730 -3010 {
lab=vdd_sw}
N -2790 -3310 -2790 -3300 {
lab=vpre2}
N -2670 -3310 -2670 -3300 {
lab=vpos2}
N -2680 -3150 -2680 -3140 {
lab=vpres2}
N -2620 -3150 -2620 -3140 {
lab=vpres2}
N -2500 -3150 -2500 -3140 {
lab=vpos2}
N -2790 -2970 -2780 -2970 {
lab=uw}
N -2790 -2940 -2780 -2940 {
lab=vbias}
N -2340 -2560 -2340 -2550 {
lab=GND}
N -2340 -2670 -2340 -2660 {
lab=vdd_syn2}
N -2280 -2600 -2280 -2590 {
lab=#net36}
N -2280 -2490 -2270 -2490 {
lab=GND}
N -2280 -2530 -2280 -2520 {
lab=#net37}
N -2280 -2460 -2280 -2450 {
lab=pattern2}
N -2400 -2630 -2400 -2620 {
lab=vpres1}
N -2280 -2630 -2280 -2620 {
lab=vpos1}
N -2340 -3080 -2340 -3070 {
lab=GND}
N -2340 -3190 -2340 -3180 {
lab=vdd_syn2}
N -2280 -3120 -2280 -3110 {
lab=#net38}
N -2280 -3010 -2270 -3010 {
lab=GND}
N -2280 -3050 -2280 -3040 {
lab=#net39}
N -2280 -2980 -2280 -2970 {
lab=pattern2}
N -2400 -3150 -2400 -3140 {
lab=vpres2}
N -2280 -3150 -2280 -3140 {
lab=vpos2}
N -2550 -3010 -2540 -3010 {
lab=ctrl_pos}
N -2330 -3010 -2320 -3010 {
lab=ctrl_pos}
N -2550 -2490 -2540 -2490 {
lab=ctrl_pos}
N -2330 -2490 -2320 -2490 {
lab=ctrl_pos}
N -2980 -3590 -2980 -3570 {
lab=GND}
N -2980 -3750 -2980 -3730 {
lab=vdd_pre}
N -3080 -3600 -3070 -3600 {
lab=vb_pre}
N -3340 -3580 -3340 -3560 {
lab=GND}
N -3140 -3680 -3140 -3660 {
lab=vc2}
N -3140 -3660 -3080 -3660 {
lab=vc2}
N -3140 -3710 -3130 -3710 {
lab=vdd_in}
N -3130 -3740 -3130 -3710 {
lab=vdd_in}
N -3140 -3740 -3130 -3740 {
lab=vdd_in}
N -3220 -3710 -3180 -3710 {
lab=#net40}
N -3260 -3740 -3140 -3740 {
lab=vdd_in}
N -3270 -3710 -3260 -3710 {
lab=vdd_in}
N -3270 -3740 -3270 -3710 {
lab=vdd_in}
N -3270 -3740 -3260 -3740 {
lab=vdd_in}
N -3260 -3680 -3260 -3660 {
lab=#net40}
N -3260 -3660 -3200 -3660 {
lab=#net40}
N -3200 -3710 -3200 -3660 {
lab=#net40}
N -3340 -3660 -3340 -3640 {
lab=#net41}
N -2560 -3600 -2560 -3590 {
lab=GND}
N -2560 -3710 -2560 -3700 {
lab=vdd_syn1}
N -2730 -3790 -2730 -3780 {
lab=GND}
N -2500 -3640 -2500 -3630 {
lab=#net42}
N -2500 -3530 -2490 -3530 {
lab=GND}
N -2500 -3570 -2500 -3560 {
lab=#net43}
N -2500 -3500 -2500 -3490 {
lab=pattern1}
N -2840 -3660 -2830 -3660 {
lab=vpre2}
N -3280 -3660 -3260 -3660 {
lab=#net40}
N -2730 -3450 -2730 -3440 {
lab=GND}
N -2680 -3500 -2680 -3490 {
lab=vpres2}
N -2790 -3520 -2780 -3520 {
lab=ctrl1}
N -2730 -3620 -2730 -3610 {
lab=GND}
N -2780 -3660 -2780 -3650 {
lab=vpre2}
N -2790 -3700 -2790 -3690 {
lab=ctrl2}
N -2790 -3690 -2780 -3690 {
lab=ctrl2}
N -2790 -3540 -2790 -3520 {
lab=ctrl1}
N -2730 -3730 -2730 -3700 {
lab=vdd_tg}
N -2730 -3900 -2730 -3870 {
lab=vdd_delay}
N -2730 -3570 -2730 -3530 {
lab=vdd_sw}
N -2790 -3830 -2790 -3820 {
lab=vpre2}
N -2670 -3830 -2670 -3820 {
lab=vpos2}
N -2680 -3670 -2680 -3660 {
lab=vpres2}
N -2620 -3670 -2620 -3660 {
lab=vpres2}
N -2500 -3670 -2500 -3660 {
lab=vpos2}
N -2790 -3490 -2780 -3490 {
lab=uw}
N -2790 -3460 -2780 -3460 {
lab=vbias}
N -2340 -3600 -2340 -3590 {
lab=GND}
N -2340 -3710 -2340 -3700 {
lab=vdd_syn2}
N -2280 -3640 -2280 -3630 {
lab=#net44}
N -2280 -3530 -2270 -3530 {
lab=GND}
N -2280 -3570 -2280 -3560 {
lab=#net45}
N -2280 -3500 -2280 -3490 {
lab=pattern2}
N -2400 -3670 -2400 -3660 {
lab=vpres2}
N -2280 -3670 -2280 -3660 {
lab=vpos2}
N -2550 -3530 -2540 -3530 {
lab=ctrl_pos}
N -2330 -3530 -2320 -3530 {
lab=ctrl_pos}
N -2980 -4110 -2980 -4090 {
lab=GND}
N -2980 -4270 -2980 -4250 {
lab=vdd_pre}
N -3080 -4120 -3070 -4120 {
lab=vb_pre}
N -3340 -4100 -3340 -4080 {
lab=GND}
N -3140 -4200 -3140 -4180 {
lab=vc1}
N -3140 -4180 -3080 -4180 {
lab=vc1}
N -3140 -4230 -3130 -4230 {
lab=vdd_in}
N -3130 -4260 -3130 -4230 {
lab=vdd_in}
N -3140 -4260 -3130 -4260 {
lab=vdd_in}
N -3220 -4230 -3180 -4230 {
lab=#net46}
N -3260 -4260 -3140 -4260 {
lab=vdd_in}
N -3270 -4230 -3260 -4230 {
lab=vdd_in}
N -3270 -4260 -3270 -4230 {
lab=vdd_in}
N -3270 -4260 -3260 -4260 {
lab=vdd_in}
N -3260 -4200 -3260 -4180 {
lab=#net46}
N -3260 -4180 -3200 -4180 {
lab=#net46}
N -3200 -4230 -3200 -4180 {
lab=#net46}
N -3340 -4180 -3340 -4160 {
lab=#net47}
N -2560 -4120 -2560 -4110 {
lab=GND}
N -2560 -4230 -2560 -4220 {
lab=vdd_syn1}
N -2730 -4310 -2730 -4300 {
lab=GND}
N -2500 -4160 -2500 -4150 {
lab=#net48}
N -2500 -4050 -2490 -4050 {
lab=GND}
N -2500 -4090 -2500 -4080 {
lab=#net49}
N -2500 -4020 -2500 -4010 {
lab=pattern1}
N -2840 -4180 -2830 -4180 {
lab=vpre1}
N -3280 -4180 -3260 -4180 {
lab=#net46}
N -2730 -3970 -2730 -3960 {
lab=GND}
N -2680 -4020 -2680 -4010 {
lab=vpres1}
N -2790 -4040 -2780 -4040 {
lab=ctrl1}
N -2730 -4140 -2730 -4130 {
lab=GND}
N -2780 -4180 -2780 -4170 {
lab=vpre1}
N -2790 -4220 -2790 -4210 {
lab=ctrl2}
N -2790 -4210 -2780 -4210 {
lab=ctrl2}
N -2790 -4060 -2790 -4040 {
lab=ctrl1}
N -2730 -4250 -2730 -4220 {
lab=vdd_tg}
N -2730 -4420 -2730 -4390 {
lab=vdd_delay}
N -2730 -4090 -2730 -4050 {
lab=vdd_sw}
N -2790 -4350 -2790 -4340 {
lab=vpre1}
N -2670 -4350 -2670 -4340 {
lab=vpos1}
N -2680 -4190 -2680 -4180 {
lab=vpres1}
N -2620 -4190 -2620 -4180 {
lab=vpres1}
N -2500 -4190 -2500 -4180 {
lab=vpos1}
N -2790 -4010 -2780 -4010 {
lab=uw}
N -2790 -3980 -2780 -3980 {
lab=vbias}
N -2980 -4630 -2980 -4610 {
lab=GND}
N -2980 -4790 -2980 -4770 {
lab=vdd_pre}
N -3080 -4640 -3070 -4640 {
lab=vb_pre}
N -3340 -4620 -3340 -4600 {
lab=GND}
N -3140 -4720 -3140 -4700 {
lab=vc2}
N -3140 -4700 -3080 -4700 {
lab=vc2}
N -3140 -4750 -3130 -4750 {
lab=vdd_in}
N -3130 -4780 -3130 -4750 {
lab=vdd_in}
N -3140 -4780 -3130 -4780 {
lab=vdd_in}
N -3220 -4750 -3180 -4750 {
lab=#net50}
N -3260 -4780 -3140 -4780 {
lab=vdd_in}
N -3270 -4750 -3260 -4750 {
lab=vdd_in}
N -3270 -4780 -3270 -4750 {
lab=vdd_in}
N -3270 -4780 -3260 -4780 {
lab=vdd_in}
N -3260 -4720 -3260 -4700 {
lab=#net50}
N -3260 -4700 -3200 -4700 {
lab=#net50}
N -3200 -4750 -3200 -4700 {
lab=#net50}
N -3340 -4700 -3340 -4680 {
lab=#net51}
N -2560 -4640 -2560 -4630 {
lab=GND}
N -2560 -4750 -2560 -4740 {
lab=vdd_syn1}
N -2730 -4830 -2730 -4820 {
lab=GND}
N -2500 -4680 -2500 -4670 {
lab=#net52}
N -2500 -4570 -2490 -4570 {
lab=GND}
N -2500 -4610 -2500 -4600 {
lab=#net53}
N -2500 -4540 -2500 -4530 {
lab=pattern1}
N -2840 -4700 -2830 -4700 {
lab=vpre2}
N -3280 -4700 -3260 -4700 {
lab=#net50}
N -2730 -4490 -2730 -4480 {
lab=GND}
N -2680 -4540 -2680 -4530 {
lab=vpres2}
N -2790 -4560 -2780 -4560 {
lab=ctrl1}
N -2730 -4660 -2730 -4650 {
lab=GND}
N -2780 -4700 -2780 -4690 {
lab=vpre2}
N -2790 -4740 -2790 -4730 {
lab=ctrl2}
N -2790 -4730 -2780 -4730 {
lab=ctrl2}
N -2790 -4580 -2790 -4560 {
lab=ctrl1}
N -2730 -4770 -2730 -4740 {
lab=vdd_tg}
N -2730 -4940 -2730 -4910 {
lab=vdd_delay}
N -2730 -4610 -2730 -4570 {
lab=vdd_sw}
N -2790 -4870 -2790 -4860 {
lab=vpre2}
N -2670 -4870 -2670 -4860 {
lab=vpos2}
N -2680 -4710 -2680 -4700 {
lab=vpres2}
N -2620 -4710 -2620 -4700 {
lab=vpres2}
N -2500 -4710 -2500 -4700 {
lab=vpos2}
N -2790 -4530 -2780 -4530 {
lab=uw}
N -2790 -4500 -2780 -4500 {
lab=vbias}
N -2340 -4120 -2340 -4110 {
lab=GND}
N -2340 -4230 -2340 -4220 {
lab=vdd_syn2}
N -2280 -4160 -2280 -4150 {
lab=#net54}
N -2280 -4050 -2270 -4050 {
lab=GND}
N -2280 -4090 -2280 -4080 {
lab=#net55}
N -2280 -4020 -2280 -4010 {
lab=pattern2}
N -2400 -4190 -2400 -4180 {
lab=vpres1}
N -2280 -4190 -2280 -4180 {
lab=vpos1}
N -2340 -4640 -2340 -4630 {
lab=GND}
N -2340 -4750 -2340 -4740 {
lab=vdd_syn2}
N -2280 -4680 -2280 -4670 {
lab=#net56}
N -2280 -4570 -2270 -4570 {
lab=GND}
N -2280 -4610 -2280 -4600 {
lab=#net57}
N -2280 -4540 -2280 -4530 {
lab=pattern2}
N -2400 -4710 -2400 -4700 {
lab=vpres2}
N -2280 -4710 -2280 -4700 {
lab=vpos2}
N -2550 -4570 -2540 -4570 {
lab=ctrl_pos}
N -2330 -4570 -2320 -4570 {
lab=ctrl_pos}
N -2550 -4050 -2540 -4050 {
lab=ctrl_pos}
N -2330 -4050 -2320 -4050 {
lab=ctrl_pos}
N -2120 -480 -2120 -470 {
lab=GND}
N -2120 -590 -2120 -580 {
lab=vdd_syn2}
N -2060 -520 -2060 -510 {
lab=#net58}
N -2060 -410 -2050 -410 {
lab=GND}
N -2060 -450 -2060 -440 {
lab=#net59}
N -2060 -380 -2060 -370 {
lab=pattern2}
N -2120 -180 -2120 -170 {
lab=vb_pos}
N -2060 -190 -2060 -180 {
lab=#net60}
N -2060 -260 -2060 -250 {
lab=pattern2}
N -2060 60 -2060 70 {
lab=vp2}
N -2130 -80 -2130 -60 {
lab=GND}
N -1990 -80 -1990 -60 {
lab=vdd_pos}
N -2180 -550 -2180 -540 {
lab=vpres1}
N -2060 -550 -2060 -540 {
lab=vpos1}
N -2120 -1000 -2120 -990 {
lab=GND}
N -2120 -1110 -2120 -1100 {
lab=vdd_syn2}
N -2060 -1040 -2060 -1030 {
lab=#net61}
N -2060 -930 -2050 -930 {
lab=GND}
N -2060 -970 -2060 -960 {
lab=#net62}
N -2060 -900 -2060 -890 {
lab=pattern2}
N -2180 -1070 -2180 -1060 {
lab=vpres2}
N -2060 -1070 -2060 -1060 {
lab=vpos2}
N -2110 -930 -2100 -930 {
lab=ctrl_pos}
N -2110 -410 -2100 -410 {
lab=ctrl_pos}
N -2000 -180 -2000 -170 {
lab=inh2}
N -2120 -1520 -2120 -1510 {
lab=GND}
N -2120 -1630 -2120 -1620 {
lab=vdd_syn2}
N -2060 -1560 -2060 -1550 {
lab=#net63}
N -2060 -1450 -2050 -1450 {
lab=GND}
N -2060 -1490 -2060 -1480 {
lab=#net64}
N -2060 -1420 -2060 -1410 {
lab=pattern2}
N -2180 -1590 -2180 -1580 {
lab=vpres1}
N -2060 -1590 -2060 -1580 {
lab=vpos1}
N -2120 -2040 -2120 -2030 {
lab=GND}
N -2120 -2150 -2120 -2140 {
lab=vdd_syn2}
N -2060 -2080 -2060 -2070 {
lab=#net65}
N -2060 -1970 -2050 -1970 {
lab=GND}
N -2060 -2010 -2060 -2000 {
lab=#net66}
N -2060 -1940 -2060 -1930 {
lab=pattern2}
N -2180 -2110 -2180 -2100 {
lab=vpres2}
N -2060 -2110 -2060 -2100 {
lab=vpos2}
N -2110 -1970 -2100 -1970 {
lab=ctrl_pos}
N -2110 -1450 -2100 -1450 {
lab=ctrl_pos}
N -2120 -2560 -2120 -2550 {
lab=GND}
N -2120 -2670 -2120 -2660 {
lab=vdd_syn2}
N -2060 -2600 -2060 -2590 {
lab=#net67}
N -2060 -2490 -2050 -2490 {
lab=GND}
N -2060 -2530 -2060 -2520 {
lab=#net68}
N -2060 -2460 -2060 -2450 {
lab=pattern2}
N -2180 -2630 -2180 -2620 {
lab=vpres1}
N -2060 -2630 -2060 -2620 {
lab=vpos1}
N -2120 -3080 -2120 -3070 {
lab=GND}
N -2120 -3190 -2120 -3180 {
lab=vdd_syn2}
N -2060 -3120 -2060 -3110 {
lab=#net69}
N -2060 -3010 -2050 -3010 {
lab=GND}
N -2060 -3050 -2060 -3040 {
lab=#net70}
N -2060 -2980 -2060 -2970 {
lab=pattern2}
N -2180 -3150 -2180 -3140 {
lab=vpres2}
N -2060 -3150 -2060 -3140 {
lab=vpos2}
N -2110 -3010 -2100 -3010 {
lab=ctrl_pos}
N -2110 -2490 -2100 -2490 {
lab=ctrl_pos}
N -2120 -3600 -2120 -3590 {
lab=GND}
N -2120 -3710 -2120 -3700 {
lab=vdd_syn2}
N -2060 -3640 -2060 -3630 {
lab=#net71}
N -2060 -3530 -2050 -3530 {
lab=GND}
N -2060 -3570 -2060 -3560 {
lab=#net72}
N -2060 -3500 -2060 -3490 {
lab=pattern2}
N -2180 -3670 -2180 -3660 {
lab=vpres2}
N -2060 -3670 -2060 -3660 {
lab=vpos2}
N -2110 -3530 -2100 -3530 {
lab=ctrl_pos}
N -2120 -4120 -2120 -4110 {
lab=GND}
N -2120 -4230 -2120 -4220 {
lab=vdd_syn2}
N -2060 -4160 -2060 -4150 {
lab=#net73}
N -2060 -4050 -2050 -4050 {
lab=GND}
N -2060 -4090 -2060 -4080 {
lab=#net74}
N -2060 -4020 -2060 -4010 {
lab=pattern2}
N -2180 -4190 -2180 -4180 {
lab=vpres1}
N -2060 -4190 -2060 -4180 {
lab=vpos1}
N -2120 -4640 -2120 -4630 {
lab=GND}
N -2120 -4750 -2120 -4740 {
lab=vdd_syn2}
N -2060 -4680 -2060 -4670 {
lab=#net75}
N -2060 -4570 -2050 -4570 {
lab=GND}
N -2060 -4610 -2060 -4600 {
lab=#net76}
N -2060 -4540 -2060 -4530 {
lab=pattern2}
N -2180 -4710 -2180 -4700 {
lab=vpres2}
N -2060 -4710 -2060 -4700 {
lab=vpos2}
N -2110 -4570 -2100 -4570 {
lab=ctrl_pos}
N -2110 -4050 -2100 -4050 {
lab=ctrl_pos}
C {devices/vsource.sym} -1920 -3130 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1920 -3080 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1840 -3130 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1840 -3080 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1840 -3180 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2980 -450 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -3080 -480 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -490 0 0 {name=I1 value="PWL(0 0 14.9u 0 15u 3u 99.9u 3u 100u 0)"}
C {devices/gnd.sym} -3340 -440 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -590 0 0 {name=M2
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -590 0 1 {name=M1
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -440 0 0 {name=x9}
C {sky130_fd_pr/corner.sym} -1850 -2270 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1970 -2270 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1720 -2270 0 0 {name=NGSPICE1
only_toplevel=true
value="
.param Lp_delay=7
.param Wp_delay=0.45
.param Ln_delay=7
.param Wn_delay=0.45
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 10n 250u
  write SNN_9x3_tb.raw
.endc
" }
C {devices/launcher.sym} -1410 -2030 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/SNN_9x3_tb.raw tran"
}
C {devices/lab_pin.sym} -3140 -540 0 0 {name=p10 sig_type=std_logic lab=vc1}
C {devices/vsource.sym} -1660 -3130 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} -1660 -3080 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1660 -3180 2 0 {name=p16 sig_type=std_logic lab=vdd_delay}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -360 0 0 {name=x91}
C {devices/gnd.sym} -2560 -470 0 0 {name=l39 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -590 0 0 {name=x90}
C {devices/lab_pin.sym} -2620 -550 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2500 -550 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2730 -660 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2670 -700 3 0 {name=p28 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2790 -700 3 0 {name=p33 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2500 -480 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -410 0 0 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -410 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -2500 -370 2 0 {name=p46 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -380 1 0 {name=p24 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2790 -370 0 0 {name=p53 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2560 -180 0 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2570 -60 0 0 {name=l63 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Postsynaptic_LIF_neuron.sym} -2600 170 1 0 {name=xT}
C {devices/ammeter.sym} -2500 -220 0 0 {name=Vmeas3 savecurrent=true}
C {devices/lab_pin.sym} -2500 -260 2 0 {name=p60 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2500 70 2 0 {name=p61 sig_type=std_logic lab=vp1}
C {devices/vsource.sym} -1920 -2710 0 0 {name=V13 value="PWL(0 1.8 9.9u 1.8 10u 0)"}
C {devices/gnd.sym} -1920 -2660 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1920 -2760 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1920 -2570 0 0 {name=V14 value="PWL(0 0 14.9u 0 15u 1.8 199.9u 1.8 200u 0)"}
C {devices/gnd.sym} -1920 -2520 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1920 -2620 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/lab_pin.sym} -2830 -540 1 0 {name=p69 sig_type=std_logic lab=vpre1}
C {devices/vsource.sym} -1920 -2430 0 0 {name=V15 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1920 -2380 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1920 -2480 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -3310 -540 1 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -2790 -420 2 0 {name=p74 sig_type=std_logic lab=ctrl1}
C {devices/vsource.sym} -1920 -2850 0 0 {name=V11 value="PWL(0 1.8 9.9u 1.8 10u 0)"}
C {devices/gnd.sym} -1920 -2800 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1920 -2900 2 0 {name=p75 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -320 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2680 -550 1 0 {name=p2 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2780 -530 3 0 {name=p5 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2790 -580 2 0 {name=p14 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -490 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} -1740 -2850 0 0 {name=V12 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1740 -2800 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1740 -2900 2 0 {name=p17 sig_type=std_logic lab=ctrl2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -540 0 0 {name=x94}
C {devices/vsource.sym} -1760 -2990 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1760 -2940 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1760 -3040 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -1750 -3130 0 0 {name=V3 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1750 -3080 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1750 -3180 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1550 -3130 0 0 {name=V5 value=1.8}
C {devices/gnd.sym} -1550 -3080 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1550 -3180 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1470 -3130 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1470 -3080 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1470 -3180 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1920 -2990 0 0 {name=V7 value=0.5}
C {devices/gnd.sym} -1920 -2940 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1920 -3040 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1840 -2990 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1840 -2940 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1840 -3040 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2980 -630 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2430 -60 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2560 -590 1 0 {name=p15 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -780 0 0 {name=p18 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -450 0 0 {name=p19 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -610 0 0 {name=p20 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -370 0 0 {name=x95}
C {devices/lab_pin.sym} -2790 -340 0 0 {name=p22 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -1920 -3180 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3200 -620 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2980 -970 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -3080 -1000 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -1010 0 0 {name=I2 value="PWL(0 0 104.9u 0 105u 3u 199.9u 3u 200u 0 204.9u 0 205u 3u)"}
C {devices/gnd.sym} -3340 -960 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -1110 0 0 {name=M3
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -1110 0 1 {name=M4
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -960 0 0 {name=x8}
C {devices/lab_pin.sym} -3140 -1060 0 0 {name=p25 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -880 0 0 {name=x81}
C {devices/gnd.sym} -2560 -990 0 0 {name=l15 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -1110 0 0 {name=x80}
C {devices/lab_pin.sym} -2620 -1070 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2500 -1070 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2730 -1180 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -2670 -1220 3 0 {name=p31 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2790 -1220 3 0 {name=p32 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2500 -1000 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -930 0 0 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -930 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -2500 -890 2 0 {name=p34 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -900 1 0 {name=p35 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2790 -890 0 0 {name=p36 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -1060 1 0 {name=p37 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -3310 -1060 1 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -2790 -940 2 0 {name=p38 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -840 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2680 -1070 1 0 {name=p39 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2780 -1050 3 0 {name=p41 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2790 -1100 2 0 {name=p42 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -1010 0 0 {name=l19 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -1060 0 0 {name=x84}
C {devices/lab_pin.sym} -2980 -1150 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -1110 1 0 {name=p44 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -1300 0 0 {name=p45 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -970 0 0 {name=p47 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -1130 0 0 {name=p48 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -890 0 0 {name=x85}
C {devices/lab_pin.sym} -2790 -860 0 0 {name=p49 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -1140 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/vsource.sym} -1920 -3270 0 0 {name=V10 value="PWL(0 1.8 99.9u 1.8 100u 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1920 -3220 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -1920 -3320 2 0 {name=p51 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} -1820 -3270 0 0 {name=V20 value="PWL(0 1.8 9.9u 1.8 10u 0 104.9u 0 105u 1.8)"}
C {devices/gnd.sym} -1820 -3220 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} -1820 -3320 2 0 {name=p7 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -360 0 0 {name=x92}
C {devices/gnd.sym} -2340 -470 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -2400 -550 1 0 {name=p52 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2280 -550 1 0 {name=p54 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2280 -480 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -410 0 0 {name=M6
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -410 3 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -2280 -370 2 0 {name=p55 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -180 0 0 {name=p56 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2350 -60 0 0 {name=l22 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Postsynaptic_LIF_neuron.sym} -2380 170 1 0 {name=xX}
C {devices/ammeter.sym} -2280 -220 0 0 {name=Vmeas4 savecurrent=true}
C {devices/lab_pin.sym} -2280 -260 2 0 {name=p57 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2280 70 2 0 {name=p58 sig_type=std_logic lab=vp2}
C {devices/lab_pin.sym} -2210 -60 3 0 {name=p62 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2340 -590 1 0 {name=p63 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -880 0 0 {name=x82}
C {devices/gnd.sym} -2340 -990 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -2400 -1070 1 0 {name=p64 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2280 -1070 1 0 {name=p67 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2280 -1000 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -930 0 0 {name=M7
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -930 3 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -2280 -890 2 0 {name=p68 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -1110 1 0 {name=p70 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2550 -930 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -930 0 0 {name=p77 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2550 -410 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -410 0 0 {name=p79 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1550 -2850 0 0 {name=V16 value="PWL(0 0 204.9u 0 205u 1.4)"}
C {devices/gnd.sym} -1550 -2800 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1550 -2900 2 0 {name=p71 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1390 -3130 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -1390 -3080 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -1390 -3180 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -3220 -150 0 0 {name=xOR}
C {devices/gnd.sym} -3220 -90 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -3220 -210 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -3300 -170 0 0 {name=p83 sig_type=std_logic lab=vp1}
C {devices/lab_pin.sym} -3300 -130 0 0 {name=p84 sig_type=std_logic lab=vp2}
C {devices/lab_pin.sym} -2440 -180 0 0 {name=p86 sig_type=std_logic lab=inh1}
C {devices/lab_pin.sym} -2220 -180 0 0 {name=p87 sig_type=std_logic lab=inh2}
C {devices/vsource.sym} -1370 -2850 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -1370 -2800 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -1370 -2900 2 0 {name=p88 sig_type=std_logic lab=vinh}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2900 -30 0 0 {name=xORDelay}
C {devices/gnd.sym} -3080 -100 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -3080 -200 0 0 {name=p92 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -3010 -150 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -3210 0 2 0 {name=p94 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} -3250 20 3 0 {name=M8
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3250 -10 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -3250 50 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -3290 0 0 0 {name=p85 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -3020 0 2 0 {name=p89 sig_type=std_logic lab=inh2}
C {sky130_fd_pr/nfet_01v8.sym} -3060 20 3 0 {name=M9
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3060 -10 2 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -3060 50 2 0 {name=p90 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -3100 0 0 0 {name=p93 sig_type=std_logic lab=vinh}
C {devices/gnd.sym} -2980 -1490 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -3080 -1520 0 0 {name=p95 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -1530 0 0 {name=I3 value="PWL(0 0 14.9u 0 15u 3u 99.9u 3u 100u 0)"}
C {devices/gnd.sym} -3340 -1480 0 0 {name=l37 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -1630 0 0 {name=M10
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -1630 0 1 {name=M12
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -1480 0 0 {name=x7}
C {devices/lab_pin.sym} -3140 -1580 0 0 {name=p96 sig_type=std_logic lab=vc1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -1400 0 0 {name=x71}
C {devices/gnd.sym} -2560 -1510 0 0 {name=l38 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -1630 0 0 {name=x70}
C {devices/lab_pin.sym} -2620 -1590 1 0 {name=p97 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2500 -1590 1 0 {name=p98 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2730 -1700 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -2670 -1740 3 0 {name=p99 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2790 -1740 3 0 {name=p100 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2500 -1520 0 0 {name=Vmeas5 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -1450 0 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -1450 3 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -2500 -1410 2 0 {name=p101 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -1420 1 0 {name=p102 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2790 -1410 0 0 {name=p103 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -1580 1 0 {name=p104 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3310 -1580 1 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -2790 -1460 2 0 {name=p105 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -1360 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -2680 -1590 1 0 {name=p106 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2780 -1570 3 0 {name=p107 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2790 -1620 2 0 {name=p108 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -1530 0 0 {name=l44 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -1580 0 0 {name=x74}
C {devices/lab_pin.sym} -2980 -1670 2 0 {name=p109 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -1630 1 0 {name=p110 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -1820 0 0 {name=p111 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -1490 0 0 {name=p112 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -1650 0 0 {name=p113 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -1410 0 0 {name=x75}
C {devices/lab_pin.sym} -2790 -1380 0 0 {name=p114 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -1660 1 0 {name=p115 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2980 -2010 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -3080 -2040 0 0 {name=p116 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -2050 0 0 {name=I4 value="PWL(0 0 104.9u 0 105u 3u 199.9u 3u 200u 0 204.9u 0 205u 3u)"}
C {devices/gnd.sym} -3340 -2000 0 0 {name=l46 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -2150 0 0 {name=M14
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -2150 0 1 {name=M15
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -2000 0 0 {name=x6}
C {devices/lab_pin.sym} -3140 -2100 0 0 {name=p117 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -1920 0 0 {name=x61}
C {devices/gnd.sym} -2560 -2030 0 0 {name=l47 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -2150 0 0 {name=x60}
C {devices/lab_pin.sym} -2620 -2110 1 0 {name=p118 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2500 -2110 1 0 {name=p119 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2730 -2220 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -2670 -2260 3 0 {name=p120 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2790 -2260 3 0 {name=p121 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2500 -2040 0 0 {name=Vmeas7 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -1970 0 0 {name=M16
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -1970 3 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -2500 -1930 2 0 {name=p122 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -1940 1 0 {name=p123 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2790 -1930 0 0 {name=p124 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -2100 1 0 {name=p125 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -3310 -2100 1 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -2790 -1980 2 0 {name=p126 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -1880 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -2680 -2110 1 0 {name=p127 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2780 -2090 3 0 {name=p128 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2790 -2140 2 0 {name=p129 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -2050 0 0 {name=l51 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -2100 0 0 {name=x64}
C {devices/lab_pin.sym} -2980 -2190 2 0 {name=p130 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -2150 1 0 {name=p131 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -2340 0 0 {name=p132 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -2010 0 0 {name=p133 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -2170 0 0 {name=p134 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -1930 0 0 {name=x65}
C {devices/lab_pin.sym} -2790 -1900 0 0 {name=p135 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -2180 1 0 {name=p136 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -1400 0 0 {name=x72}
C {devices/gnd.sym} -2340 -1510 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -2400 -1590 1 0 {name=p137 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2280 -1590 1 0 {name=p138 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2280 -1520 0 0 {name=Vmeas9 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -1450 0 0 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -1450 3 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -2280 -1410 2 0 {name=p139 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -1630 1 0 {name=p140 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -1920 0 0 {name=x62}
C {devices/gnd.sym} -2340 -2030 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -2400 -2110 1 0 {name=p141 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2280 -2110 1 0 {name=p142 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2280 -2040 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -1970 0 0 {name=M18
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -1970 3 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -2280 -1930 2 0 {name=p143 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -2150 1 0 {name=p144 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2550 -1970 0 0 {name=p145 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -1970 0 0 {name=p146 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2550 -1450 0 0 {name=p147 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -1450 0 0 {name=p148 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -2530 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -3080 -2560 0 0 {name=p149 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -2570 0 0 {name=I5 value="PWL(0 0 14.9u 0 15u 3u 99.9u 3u 100u 0)"}
C {devices/gnd.sym} -3340 -2520 0 0 {name=l57 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -2670 0 0 {name=M19
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -2670 0 1 {name=M20
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -2520 0 0 {name=x5}
C {devices/lab_pin.sym} -3140 -2620 0 0 {name=p150 sig_type=std_logic lab=vc1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -2440 0 0 {name=x51}
C {devices/gnd.sym} -2560 -2550 0 0 {name=l58 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -2670 0 0 {name=x50}
C {devices/lab_pin.sym} -2620 -2630 1 0 {name=p151 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2500 -2630 1 0 {name=p152 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2730 -2740 0 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -2670 -2780 3 0 {name=p153 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2790 -2780 3 0 {name=p154 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2500 -2560 0 0 {name=Vmeas13 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -2490 0 0 {name=M21
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -2490 3 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -2500 -2450 2 0 {name=p155 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -2460 1 0 {name=p156 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2790 -2450 0 0 {name=p157 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -2620 1 0 {name=p158 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3310 -2620 1 0 {name=Vmeas14 savecurrent=true}
C {devices/lab_pin.sym} -2790 -2500 2 0 {name=p159 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -2400 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -2680 -2630 1 0 {name=p160 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2780 -2610 3 0 {name=p161 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2790 -2660 2 0 {name=p162 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -2570 0 0 {name=l62 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -2620 0 0 {name=x54}
C {devices/lab_pin.sym} -2980 -2710 2 0 {name=p163 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -2670 1 0 {name=p164 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -2860 0 0 {name=p165 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -2530 0 0 {name=p166 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -2690 0 0 {name=p167 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -2450 0 0 {name=x55}
C {devices/lab_pin.sym} -2790 -2420 0 0 {name=p168 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -2700 1 0 {name=p169 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2980 -3050 0 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -3080 -3080 0 0 {name=p170 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -3090 0 0 {name=I6 value="PWL(0 0 104.9u 0 105u 3u 199.9u 3u 200u 0 204.9u 0 205u 3u)"}
C {devices/gnd.sym} -3340 -3040 0 0 {name=l65 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -3190 0 0 {name=M22
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -3190 0 1 {name=M23
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -3040 0 0 {name=x4}
C {devices/lab_pin.sym} -3140 -3140 0 0 {name=p171 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -2960 0 0 {name=x41}
C {devices/gnd.sym} -2560 -3070 0 0 {name=l66 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -3190 0 0 {name=x40}
C {devices/lab_pin.sym} -2620 -3150 1 0 {name=p172 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2500 -3150 1 0 {name=p173 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2730 -3260 0 0 {name=l70 lab=GND}
C {devices/lab_pin.sym} -2670 -3300 3 0 {name=p174 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2790 -3300 3 0 {name=p175 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2500 -3080 0 0 {name=Vmeas15 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -3010 0 0 {name=M24
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -3010 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -2500 -2970 2 0 {name=p176 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -2980 1 0 {name=p177 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2790 -2970 0 0 {name=p178 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -3140 1 0 {name=p179 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -3310 -3140 1 0 {name=Vmeas16 savecurrent=true}
C {devices/lab_pin.sym} -2790 -3020 2 0 {name=p180 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -2920 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -2680 -3150 1 0 {name=p181 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2780 -3130 3 0 {name=p182 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2790 -3180 2 0 {name=p183 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -3090 0 0 {name=l74 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -3140 0 0 {name=x44}
C {devices/lab_pin.sym} -2980 -3230 2 0 {name=p184 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -3190 1 0 {name=p185 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -3380 0 0 {name=p186 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -3050 0 0 {name=p187 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -3210 0 0 {name=p188 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -2970 0 0 {name=x45}
C {devices/lab_pin.sym} -2790 -2940 0 0 {name=p189 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -3220 1 0 {name=p190 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -2440 0 0 {name=x52}
C {devices/gnd.sym} -2340 -2550 0 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} -2400 -2630 1 0 {name=p191 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2280 -2630 1 0 {name=p192 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2280 -2560 0 0 {name=Vmeas17 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -2490 0 0 {name=M25
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -2490 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -2280 -2450 2 0 {name=p193 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -2670 1 0 {name=p194 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -2960 0 0 {name=x42}
C {devices/gnd.sym} -2340 -3070 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -2400 -3150 1 0 {name=p195 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2280 -3150 1 0 {name=p196 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2280 -3080 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -3010 0 0 {name=M26
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -3010 3 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -2280 -2970 2 0 {name=p197 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -3190 1 0 {name=p198 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2550 -3010 0 0 {name=p199 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -3010 0 0 {name=p200 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2550 -2490 0 0 {name=p201 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -2490 0 0 {name=p202 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -3570 0 0 {name=l80 lab=GND}
C {devices/lab_pin.sym} -3080 -3600 0 0 {name=p203 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -3610 0 0 {name=I7 value="PWL(0 0 104.9u 0 105u 3u 199.9u 3u 200u 0 204.9u 0 205u 3u)"}
C {devices/gnd.sym} -3340 -3560 0 0 {name=l81 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -3710 0 0 {name=M27
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -3710 0 1 {name=M28
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -3560 0 0 {name=x3}
C {devices/lab_pin.sym} -3140 -3660 0 0 {name=p204 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -3480 0 0 {name=x31}
C {devices/gnd.sym} -2560 -3590 0 0 {name=l82 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -3710 0 0 {name=x30}
C {devices/lab_pin.sym} -2620 -3670 1 0 {name=p205 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2500 -3670 1 0 {name=p206 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2730 -3780 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -2670 -3820 3 0 {name=p207 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2790 -3820 3 0 {name=p208 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2500 -3600 0 0 {name=Vmeas19 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -3530 0 0 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -3530 3 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -2500 -3490 2 0 {name=p209 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -3500 1 0 {name=p210 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2790 -3490 0 0 {name=p211 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -3660 1 0 {name=p212 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -3310 -3660 1 0 {name=Vmeas20 savecurrent=true}
C {devices/lab_pin.sym} -2790 -3540 2 0 {name=p213 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -3440 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -2680 -3670 1 0 {name=p214 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2780 -3650 3 0 {name=p215 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2790 -3700 2 0 {name=p216 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -3610 0 0 {name=l86 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -3660 0 0 {name=x34}
C {devices/lab_pin.sym} -2980 -3750 2 0 {name=p217 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -3710 1 0 {name=p218 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -3900 0 0 {name=p219 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -3570 0 0 {name=p220 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -3730 0 0 {name=p221 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -3490 0 0 {name=x35}
C {devices/lab_pin.sym} -2790 -3460 0 0 {name=p222 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -3740 1 0 {name=p223 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -3480 0 0 {name=x32}
C {devices/gnd.sym} -2340 -3590 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -2400 -3670 1 0 {name=p224 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2280 -3670 1 0 {name=p225 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2280 -3600 0 0 {name=Vmeas23 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -3530 0 0 {name=M30
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -3530 3 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -2280 -3490 2 0 {name=p226 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -3710 1 0 {name=p227 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2550 -3530 0 0 {name=p228 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -3530 0 0 {name=p229 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -4090 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -3080 -4120 0 0 {name=p230 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -4130 0 0 {name=I8 value="PWL(0 0 14.9u 0 15u 3u 99.9u 3u 100u 0)"}
C {devices/gnd.sym} -3340 -4080 0 0 {name=l90 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -4230 0 0 {name=M31
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -4230 0 1 {name=M32
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -4080 0 0 {name=x2}
C {devices/lab_pin.sym} -3140 -4180 0 0 {name=p231 sig_type=std_logic lab=vc1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -4000 0 0 {name=x21}
C {devices/gnd.sym} -2560 -4110 0 0 {name=l91 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -4230 0 0 {name=x20}
C {devices/lab_pin.sym} -2620 -4190 1 0 {name=p232 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2500 -4190 1 0 {name=p233 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2730 -4300 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} -2670 -4340 3 0 {name=p234 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2790 -4340 3 0 {name=p235 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2500 -4120 0 0 {name=Vmeas24 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -4050 0 0 {name=M33
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -4050 3 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -2500 -4010 2 0 {name=p236 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -4020 1 0 {name=p237 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2790 -4010 0 0 {name=p238 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -4180 1 0 {name=p239 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3310 -4180 1 0 {name=Vmeas25 savecurrent=true}
C {devices/lab_pin.sym} -2790 -4060 2 0 {name=p240 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -3960 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} -2680 -4190 1 0 {name=p241 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2780 -4170 3 0 {name=p242 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2790 -4220 2 0 {name=p243 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -4130 0 0 {name=l95 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -4180 0 0 {name=x24}
C {devices/lab_pin.sym} -2980 -4270 2 0 {name=p244 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -4230 1 0 {name=p245 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -4420 0 0 {name=p246 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -4090 0 0 {name=p247 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -4250 0 0 {name=p248 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -4010 0 0 {name=x25}
C {devices/lab_pin.sym} -2790 -3980 0 0 {name=p249 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -4260 1 0 {name=p250 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2980 -4610 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} -3080 -4640 0 0 {name=p251 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3340 -4650 0 0 {name=I9 value="PWL(0 0 104.9u 0 105u 3u 199.9u 3u 200u 0 204.9u 0 205u 3u)"}
C {devices/gnd.sym} -3340 -4600 0 0 {name=l97 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3160 -4750 0 0 {name=M34
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3240 -4750 0 1 {name=M35
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Presynaptic_LIF_neuron.sym} -2780 -4600 0 0 {name=x1}
C {devices/lab_pin.sym} -3140 -4700 0 0 {name=p252 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2500 -4520 0 0 {name=x11}
C {devices/gnd.sym} -2560 -4630 0 0 {name=l98 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2550 -4750 0 0 {name=x10}
C {devices/lab_pin.sym} -2620 -4710 1 0 {name=p253 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2500 -4710 1 0 {name=p254 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2730 -4820 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2670 -4860 3 0 {name=p255 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2790 -4860 3 0 {name=p256 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2500 -4640 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2520 -4570 0 0 {name=M36
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2490 -4570 3 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2500 -4530 2 0 {name=p257 sig_type=std_logic lab=pattern1}
C {devices/lab_pin.sym} -2680 -4540 1 0 {name=p258 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2790 -4530 0 0 {name=p259 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2830 -4700 1 0 {name=p260 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -3310 -4700 1 0 {name=Vmeas27 savecurrent=true}
C {devices/lab_pin.sym} -2790 -4580 2 0 {name=p261 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2730 -4480 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -2680 -4710 1 0 {name=p262 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2780 -4690 3 0 {name=p263 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2790 -4740 2 0 {name=p264 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2730 -4650 0 0 {name=l102 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2730 -4700 0 0 {name=x14}
C {devices/lab_pin.sym} -2980 -4790 2 0 {name=p265 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2560 -4750 1 0 {name=p266 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2730 -4940 0 0 {name=p267 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2730 -4610 0 0 {name=p268 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2730 -4770 0 0 {name=p269 sig_type=std_logic lab=vdd_tg}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2730 -4530 0 0 {name=x15}
C {devices/lab_pin.sym} -2790 -4500 0 0 {name=p270 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -3200 -4780 1 0 {name=p271 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -4000 0 0 {name=x22}
C {devices/gnd.sym} -2340 -4110 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -2400 -4190 1 0 {name=p272 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2280 -4190 1 0 {name=p273 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2280 -4120 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -4050 0 0 {name=M37
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -4050 3 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} -2280 -4010 2 0 {name=p274 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -4230 1 0 {name=p275 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2280 -4520 0 0 {name=x12}
C {devices/gnd.sym} -2340 -4630 0 0 {name=l105 lab=GND}
C {devices/lab_pin.sym} -2400 -4710 1 0 {name=p276 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2280 -4710 1 0 {name=p277 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2280 -4640 0 0 {name=Vmeas29 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2300 -4570 0 0 {name=M38
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2270 -4570 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -2280 -4530 2 0 {name=p278 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2340 -4750 1 0 {name=p279 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2550 -4570 0 0 {name=p280 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -4570 0 0 {name=p281 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2550 -4050 0 0 {name=p282 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2330 -4050 0 0 {name=p283 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -360 0 0 {name=x93}
C {devices/gnd.sym} -2120 -470 0 0 {name=l107 lab=GND}
C {devices/lab_pin.sym} -2180 -550 1 0 {name=p284 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2060 -550 1 0 {name=p285 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2060 -480 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -410 0 0 {name=M39
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -410 3 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} -2060 -370 2 0 {name=p286 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -180 0 0 {name=p287 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2130 -60 0 0 {name=l109 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Postsynaptic_LIF_neuron.sym} -2160 170 1 0 {name=xU}
C {devices/ammeter.sym} -2060 -220 0 0 {name=Vmeas31 savecurrent=true}
C {devices/lab_pin.sym} -2060 -260 2 0 {name=p288 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2060 70 2 0 {name=p289 sig_type=std_logic lab=vp2}
C {devices/lab_pin.sym} -1990 -60 3 0 {name=p290 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2120 -590 1 0 {name=p291 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -880 0 0 {name=x83}
C {devices/gnd.sym} -2120 -990 0 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -2180 -1070 1 0 {name=p292 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2060 -1070 1 0 {name=p293 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2060 -1000 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -930 0 0 {name=M40
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -930 3 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} -2060 -890 2 0 {name=p294 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -1110 1 0 {name=p295 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2110 -930 0 0 {name=p296 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2110 -410 0 0 {name=p297 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2000 -180 0 0 {name=p298 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -1400 0 0 {name=x73}
C {devices/gnd.sym} -2120 -1510 0 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} -2180 -1590 1 0 {name=p299 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2060 -1590 1 0 {name=p300 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2060 -1520 0 0 {name=Vmeas33 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1450 0 0 {name=M41
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1450 3 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -2060 -1410 2 0 {name=p301 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -1630 1 0 {name=p302 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -1920 0 0 {name=x63}
C {devices/gnd.sym} -2120 -2030 0 0 {name=l114 lab=GND}
C {devices/lab_pin.sym} -2180 -2110 1 0 {name=p303 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2060 -2110 1 0 {name=p304 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2060 -2040 0 0 {name=Vmeas34 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1970 0 0 {name=M42
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1970 3 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -2060 -1930 2 0 {name=p305 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -2150 1 0 {name=p306 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2110 -1970 0 0 {name=p307 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2110 -1450 0 0 {name=p308 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -2440 0 0 {name=x53}
C {devices/gnd.sym} -2120 -2550 0 0 {name=l116 lab=GND}
C {devices/lab_pin.sym} -2180 -2630 1 0 {name=p309 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2060 -2630 1 0 {name=p310 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2060 -2560 0 0 {name=Vmeas35 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2490 0 0 {name=M43
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2490 3 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -2060 -2450 2 0 {name=p311 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -2670 1 0 {name=p312 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -2960 0 0 {name=x43}
C {devices/gnd.sym} -2120 -3070 0 0 {name=l118 lab=GND}
C {devices/lab_pin.sym} -2180 -3150 1 0 {name=p313 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2060 -3150 1 0 {name=p314 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2060 -3080 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3010 0 0 {name=M44
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3010 3 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -2060 -2970 2 0 {name=p315 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -3190 1 0 {name=p316 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2110 -3010 0 0 {name=p317 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2110 -2490 0 0 {name=p318 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -3480 0 0 {name=x33}
C {devices/gnd.sym} -2120 -3590 0 0 {name=l120 lab=GND}
C {devices/lab_pin.sym} -2180 -3670 1 0 {name=p319 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2060 -3670 1 0 {name=p320 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2060 -3600 0 0 {name=Vmeas37 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3530 0 0 {name=M45
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3530 3 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -2060 -3490 2 0 {name=p321 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -3710 1 0 {name=p322 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2110 -3530 0 0 {name=p323 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -4000 0 0 {name=x23}
C {devices/gnd.sym} -2120 -4110 0 0 {name=l122 lab=GND}
C {devices/lab_pin.sym} -2180 -4190 1 0 {name=p324 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2060 -4190 1 0 {name=p325 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2060 -4120 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4050 0 0 {name=M46
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4050 3 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -2060 -4010 2 0 {name=p326 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -4230 1 0 {name=p327 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2060 -4520 0 0 {name=x13}
C {devices/gnd.sym} -2120 -4630 0 0 {name=l124 lab=GND}
C {devices/lab_pin.sym} -2180 -4710 1 0 {name=p328 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2060 -4710 1 0 {name=p329 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2060 -4640 0 0 {name=Vmeas39 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4570 0 0 {name=M47
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4570 3 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -2060 -4530 2 0 {name=p330 sig_type=std_logic lab=pattern2}
C {devices/lab_pin.sym} -2120 -4750 1 0 {name=p331 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2110 -4570 0 0 {name=p332 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2110 -4050 0 0 {name=p333 sig_type=std_logic lab=ctrl_pos}
