v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -400 800 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 -800 -800 0 -400 {flags=graph
y1=2.2
y2=5.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S11; 5 n.x11.xr1.n1#ngap -\\"
\\"S21; 5 n.x21.xr1.n1#ngap -\\"
\\"S31; 5 n.x31.xr1.n1#ngap -\\"
\\"S41; 5 n.x41.xr1.n1#ngap -\\"
\\"S51; 5 n.x51.xr1.n1#ngap -\\"
\\"S61; 5 n.x61.xr1.n1#ngap -\\"
\\"S71; 5 n.x71.xr1.n1#ngap -\\"
\\"S81; 5 n.x81.xr1.n1#ngap -\\"
\\"S91; 5 n.x91.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -800 -400 0 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 -1600 -400 -800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="17 18 19"
node="\\"Syn1;vdd_syn1\\"
\\"Syn2;vdd_syn2\\"
\\"Syn3;vdd_syn3\\""}
B 2 -1600 -1600 -800 -1200 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 1840 -1600 2640 -1200 {flags=graph
y1=0.092
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="4 6 7"
node="N0
N1
N2"}
B 2 -800 -1600 0 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 0 -800 800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S12; 5 n.x12.xr1.n1#ngap -\\"
\\"S22; 5 n.x22.xr1.n1#ngap -\\"
\\"S32; 5 n.x32.xr1.n1#ngap -\\"
\\"S42; 5 n.x42.xr1.n1#ngap -\\"
\\"S52; 5 n.x52.xr1.n1#ngap -\\"
\\"S62; 5 n.x62.xr1.n1#ngap -\\"
\\"S72; 5 n.x72.xr1.n1#ngap -\\"
\\"S82; 5 n.x82.xr1.n1#ngap -\\"
\\"S92; 5 n.x92.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -1600 -800 -800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -1600 -1200 -800 -800 {flags=graph
y1=2.372e-06
y2=8.752e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"[A]\\""}
B 2 -800 -1200 0 -800 {flags=graph
y1=-3.5e-07
y2=6.8e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I11; i(Vmeas11)\\"
\\"I21; i(Vmeas21)\\"
\\"I31; i(Vmeas31)\\"
\\"I41; i(Vmeas41)\\"
\\"I51; i(Vmeas51)\\"
\\"I61; i(Vmeas61)\\"
\\"I71; i(Vmeas71)\\"
\\"I81; i(Vmeas81)\\"
\\"I91; i(Vmeas91)\\"
\\"[A]\\""}
B 2 0 -1200 800 -800 {flags=graph
y1=-3.1e-07
y2=7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I12; i(Vmeas12)\\"
\\"I22; i(Vmeas22)\\"
\\"I32; i(Vmeas32)\\"
\\"I42; i(Vmeas42)\\"
\\"I52; i(Vmeas52)\\"
\\"I62; i(Vmeas62)\\"
\\"I72; i(Vmeas72)\\"
\\"I82; i(Vmeas82)\\"
\\"I92; i(Vmeas92)\\"
\\"[A]\\""}
B 2 1040 -1600 1840 -1200 {flags=graph
y1=8.3e-09
y2=1.2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 17"
node="p0
p1
p2"}
B 2 1040 -1200 1840 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1040 -800 1840 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1040 -400 1840 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 1840 -1200 2640 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 1840 -800 2640 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 1840 -400 2640 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 2640 -1200 3440 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 2640 -800 3440 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 2640 -400 3440 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000300062
x2=0.000305002
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
N -1500 -3270 -1500 -3250 {
lab=GND}
N -1500 -3350 -1500 -3330 {
lab=vdd_in}
N -1420 -3270 -1420 -3250 {
lab=GND}
N -1420 -3350 -1420 -3330 {
lab=vdd_pre}
N -2660 -4330 -2660 -4310 {
lab=GND}
N -2660 -4490 -2660 -4470 {
lab=vdd_pre}
N -3040 -4320 -3040 -4300 {
lab=GND}
N -2840 -4420 -2840 -4400 {
lab=vc2}
N -2840 -4450 -2830 -4450 {
lab=vdd_in}
N -2830 -4480 -2830 -4450 {
lab=vdd_in}
N -2840 -4480 -2830 -4480 {
lab=vdd_in}
N -2920 -4450 -2880 -4450 {
lab=#net1}
N -2960 -4480 -2840 -4480 {
lab=vdd_in}
N -2970 -4450 -2960 -4450 {
lab=vdd_in}
N -2970 -4480 -2970 -4450 {
lab=vdd_in}
N -2970 -4480 -2960 -4480 {
lab=vdd_in}
N -2960 -4420 -2960 -4400 {
lab=#net1}
N -2960 -4400 -2900 -4400 {
lab=#net1}
N -2900 -4450 -2900 -4400 {
lab=#net1}
N -3040 -4400 -3040 -4380 {
lab=#net2}
N -1240 -3270 -1240 -3250 {
lab=GND}
N -1240 -3350 -1240 -3330 {
lab=vdd_delay}
N -2240 -4860 -2240 -4850 {
lab=GND}
N -2240 -4970 -2240 -4960 {
lab=vdd_syn1}
N -2410 -4530 -2410 -4520 {
lab=GND}
N -2180 -4780 -2170 -4780 {
lab=GND}
N -2180 -4750 -2180 -4740 {
lab=p0}
N -2180 -260 -2180 -250 {
lab=#net3}
N -2180 -330 -2180 -320 {
lab=p0}
N -2180 -10 -2180 0 {
lab=N0}
N -1500 -2850 -1500 -2830 {
lab=GND}
N -1500 -2930 -1500 -2910 {
lab=uw}
N -1500 -2710 -1500 -2690 {
lab=GND}
N -1500 -2790 -1500 -2770 {
lab=training}
N -2520 -4400 -2510 -4400 {
lab=vpre2}
N -2250 -150 -2250 -130 {
lab=GND}
N -2110 -150 -2110 -130 {
lab=vdd_pos}
N -1500 -2570 -1500 -2550 {
lab=GND}
N -1500 -2650 -1500 -2630 {
lab=inference}
N -2980 -4400 -2960 -4400 {
lab=#net1}
N -1500 -2990 -1500 -2970 {
lab=GND}
N -1500 -3070 -1500 -3050 {
lab=ctrl1}
N -2410 -4190 -2410 -4180 {
lab=GND}
N -2360 -4240 -2360 -4230 {
lab=vpres2}
N -2470 -4260 -2460 -4260 {
lab=ctrl1}
N -2410 -4360 -2410 -4350 {
lab=GND}
N -2460 -4400 -2460 -4390 {
lab=vpre2}
N -2470 -4440 -2470 -4430 {
lab=ctrl2}
N -2470 -4430 -2460 -4430 {
lab=ctrl2}
N -1320 -2990 -1320 -2970 {
lab=GND}
N -1320 -3070 -1320 -3050 {
lab=ctrl2}
N -2470 -4280 -2470 -4260 {
lab=ctrl1}
N -1340 -3130 -1340 -3110 {
lab=GND}
N -1340 -3210 -1340 -3190 {
lab=vbias}
N -1330 -3270 -1330 -3250 {
lab=GND}
N -1330 -3350 -1330 -3330 {
lab=vdd_pos}
N -1130 -3270 -1130 -3250 {
lab=GND}
N -1130 -3350 -1130 -3330 {
lab=vdd_sw}
N -1050 -3270 -1050 -3250 {
lab=GND}
N -1050 -3350 -1050 -3330 {
lab=vdd_tg}
N -1500 -3130 -1500 -3110 {
lab=GND}
N -1500 -3210 -1500 -3190 {
lab=vb_pre}
N -1420 -3130 -1420 -3110 {
lab=GND}
N -1420 -3210 -1420 -3190 {
lab=vb_pos}
N -2410 -4470 -2410 -4440 {
lab=vdd_tg}
N -2410 -4640 -2410 -4610 {
lab=vdd_delay}
N -2410 -4310 -2410 -4270 {
lab=vdd_sw}
N -2470 -4570 -2470 -4560 {
lab=vpre2}
N -2350 -4570 -2350 -4560 {
lab=vpos2}
N -2360 -4410 -2360 -4400 {
lab=vpres2}
N -2300 -4930 -2300 -4920 {
lab=vpres1}
N -2180 -4930 -2180 -4920 {
lab=vpos1}
N -2470 -4230 -2460 -4230 {
lab=uw}
N -2660 -4850 -2660 -4830 {
lab=GND}
N -2660 -5010 -2660 -4990 {
lab=vdd_pre}
N -3040 -4840 -3040 -4820 {
lab=GND}
N -2840 -4940 -2840 -4920 {
lab=vc1}
N -2840 -4970 -2830 -4970 {
lab=vdd_in}
N -2830 -5000 -2830 -4970 {
lab=vdd_in}
N -2840 -5000 -2830 -5000 {
lab=vdd_in}
N -2920 -4970 -2880 -4970 {
lab=#net4}
N -2960 -5000 -2840 -5000 {
lab=vdd_in}
N -2970 -4970 -2960 -4970 {
lab=vdd_in}
N -2970 -5000 -2970 -4970 {
lab=vdd_in}
N -2970 -5000 -2960 -5000 {
lab=vdd_in}
N -2960 -4940 -2960 -4920 {
lab=#net4}
N -2960 -4920 -2900 -4920 {
lab=#net4}
N -2900 -4970 -2900 -4920 {
lab=#net4}
N -3040 -4920 -3040 -4900 {
lab=#net5}
N -2240 -4340 -2240 -4330 {
lab=GND}
N -2240 -4450 -2240 -4440 {
lab=vdd_syn1}
N -2410 -5050 -2410 -5040 {
lab=GND}
N -2180 -4260 -2170 -4260 {
lab=GND}
N -2180 -4230 -2180 -4220 {
lab=p0}
N -2520 -4920 -2510 -4920 {
lab=vpre1}
N -2980 -4920 -2960 -4920 {
lab=#net4}
N -2410 -4710 -2410 -4700 {
lab=GND}
N -2360 -4760 -2360 -4750 {
lab=vpres1}
N -2470 -4780 -2460 -4780 {
lab=ctrl1}
N -2410 -4880 -2410 -4870 {
lab=GND}
N -2460 -4920 -2460 -4910 {
lab=vpre1}
N -2470 -4960 -2470 -4950 {
lab=ctrl2}
N -2470 -4950 -2460 -4950 {
lab=ctrl2}
N -2470 -4800 -2470 -4780 {
lab=ctrl1}
N -2410 -4990 -2410 -4960 {
lab=vdd_tg}
N -2410 -5160 -2410 -5130 {
lab=vdd_delay}
N -2410 -4830 -2410 -4790 {
lab=vdd_sw}
N -2470 -5090 -2470 -5080 {
lab=vpre1}
N -2350 -5090 -2350 -5080 {
lab=vpos1}
N -2360 -4930 -2360 -4920 {
lab=vpres1}
N -2300 -4410 -2300 -4400 {
lab=vpres2}
N -2180 -4410 -2180 -4400 {
lab=vpos2}
N -2470 -4750 -2460 -4750 {
lab=uw}
N -2230 -4260 -2220 -4260 {
lab=ctrl_pos}
N -2230 -4780 -2220 -4780 {
lab=ctrl_pos}
N -1130 -2990 -1130 -2970 {
lab=GND}
N -1130 -3070 -1130 -3050 {
lab=ctrl_pos}
N -970 -3270 -970 -3250 {
lab=GND}
N -970 -3350 -970 -3330 {
lab=vdd_inh}
N -580 -3150 -580 -3140 {
lab=vdd_inh}
N -950 -2990 -950 -2970 {
lab=GND}
N -950 -3070 -950 -3050 {
lab=vinh}
N -580 -3040 -580 -3030 {
lab=GND}
N -520 -3090 -510 -3090 {
lab=inh_d}
N -580 -2940 -570 -2940 {
lab=inh0}
N -610 -2950 -610 -2940 {
lab=GND}
N -610 -2900 -610 -2890 {
lab=inh_d}
N -650 -2940 -640 -2940 {
lab=vinh}
N -580 -2800 -570 -2800 {
lab=inh1}
N -610 -2810 -610 -2800 {
lab=GND}
N -610 -2760 -610 -2750 {
lab=inh_d}
N -650 -2800 -640 -2800 {
lab=vinh}
N -1270 -3130 -1270 -3110 {
lab=GND}
N -1270 -3210 -1270 -3190 {
lab=vlky}
N -2840 -4920 -2760 -4920 {
lab=vc1}
N -2760 -4960 -2750 -4960 {
lab=vlky}
N -2760 -4880 -2750 -4880 {
lab=vb_pre}
N -2760 -4440 -2750 -4440 {
lab=vlky}
N -2840 -4400 -2760 -4400 {
lab=vc2}
N -2760 -4360 -2750 -4360 {
lab=vb_pre}
N -2250 -250 -2250 -240 {
lab=inh0}
N -2220 -250 -2220 -240 {
lab=vb_pos}
N -2140 -250 -2140 -240 {
lab=vlky}
N -1960 -260 -1960 -250 {
lab=#net6}
N -1960 -330 -1960 -320 {
lab=p1}
N -1960 -10 -1960 0 {
lab=N1}
N -2030 -150 -2030 -130 {
lab=GND}
N -1890 -150 -1890 -130 {
lab=vdd_pos}
N -2030 -250 -2030 -240 {
lab=inh1}
N -2000 -250 -2000 -240 {
lab=vb_pos}
N -1920 -250 -1920 -240 {
lab=vlky}
N -1500 -3410 -1500 -3390 {
lab=GND}
N -1500 -3490 -1500 -3470 {
lab=vdd_syn1}
N -1400 -3410 -1400 -3390 {
lab=GND}
N -1400 -3490 -1400 -3470 {
lab=vdd_syn2}
N -2470 -4720 -2460 -4720 {
lab=vbias}
N -2470 -4200 -2460 -4200 {
lab=vbias}
N -1740 -260 -1740 -250 {
lab=#net7}
N -1740 -330 -1740 -320 {
lab=p2}
N -1740 -10 -1740 0 {
lab=N2}
N -1810 -150 -1810 -130 {
lab=GND}
N -1670 -150 -1670 -130 {
lab=vdd_pos}
N -1810 -250 -1810 -240 {
lab=inh2}
N -1780 -250 -1780 -240 {
lab=vb_pos}
N -1700 -250 -1700 -240 {
lab=vlky}
N -2180 -4900 -2180 -4880 {
lab=#net8}
N -2180 -4820 -2180 -4810 {
lab=#net9}
N -2180 -4380 -2180 -4360 {
lab=#net10}
N -2180 -4300 -2180 -4290 {
lab=#net11}
N -2020 -4860 -2020 -4850 {
lab=GND}
N -2020 -4970 -2020 -4960 {
lab=vdd_syn2}
N -1960 -4780 -1950 -4780 {
lab=GND}
N -1960 -4750 -1960 -4740 {
lab=p1}
N -2080 -4930 -2080 -4920 {
lab=vpres1}
N -1960 -4930 -1960 -4920 {
lab=vpos1}
N -2020 -4340 -2020 -4330 {
lab=GND}
N -2020 -4450 -2020 -4440 {
lab=vdd_syn2}
N -1960 -4260 -1950 -4260 {
lab=GND}
N -1960 -4230 -1960 -4220 {
lab=p1}
N -2080 -4410 -2080 -4400 {
lab=vpres2}
N -1960 -4410 -1960 -4400 {
lab=vpos2}
N -2010 -4260 -2000 -4260 {
lab=ctrl_pos}
N -2010 -4780 -2000 -4780 {
lab=ctrl_pos}
N -1960 -4900 -1960 -4880 {
lab=#net12}
N -1960 -4820 -1960 -4810 {
lab=#net13}
N -1960 -4380 -1960 -4360 {
lab=#net14}
N -1960 -4300 -1960 -4290 {
lab=#net15}
N -1800 -4860 -1800 -4850 {
lab=GND}
N -1800 -4970 -1800 -4960 {
lab=vdd_syn3}
N -1740 -4780 -1730 -4780 {
lab=GND}
N -1740 -4750 -1740 -4740 {
lab=p2}
N -1860 -4930 -1860 -4920 {
lab=vpres1}
N -1740 -4930 -1740 -4920 {
lab=vpos1}
N -1800 -4340 -1800 -4330 {
lab=GND}
N -1800 -4450 -1800 -4440 {
lab=vdd_syn3}
N -1740 -4260 -1730 -4260 {
lab=GND}
N -1740 -4230 -1740 -4220 {
lab=p2}
N -1860 -4410 -1860 -4400 {
lab=vpres2}
N -1740 -4410 -1740 -4400 {
lab=vpos2}
N -1790 -4260 -1780 -4260 {
lab=ctrl_pos}
N -1790 -4780 -1780 -4780 {
lab=ctrl_pos}
N -1740 -4900 -1740 -4880 {
lab=#net16}
N -1740 -4820 -1740 -4810 {
lab=#net17}
N -1740 -4380 -1740 -4360 {
lab=#net18}
N -1740 -4300 -1740 -4290 {
lab=#net19}
N -2410 -4010 -2410 -4000 {
lab=GND}
N -2410 -3670 -2410 -3660 {
lab=GND}
N -2360 -3720 -2360 -3710 {
lab=vpres3}
N -2470 -3740 -2460 -3740 {
lab=ctrl1}
N -2410 -3840 -2410 -3830 {
lab=GND}
N -2460 -3880 -2460 -3870 {
lab=vpre3}
N -2470 -3920 -2470 -3910 {
lab=ctrl2}
N -2470 -3910 -2460 -3910 {
lab=ctrl2}
N -2470 -3760 -2470 -3740 {
lab=ctrl1}
N -2410 -3950 -2410 -3920 {
lab=vdd_tg}
N -2410 -4120 -2410 -4090 {
lab=vdd_delay}
N -2410 -3790 -2410 -3750 {
lab=vdd_sw}
N -2470 -4050 -2470 -4040 {
lab=vpre3}
N -2350 -4050 -2350 -4040 {
lab=vpos3}
N -2360 -3890 -2360 -3880 {
lab=vpres3}
N -2470 -3710 -2460 -3710 {
lab=uw}
N -2470 -3680 -2460 -3680 {
lab=vbias}
N -2410 -3490 -2410 -3480 {
lab=GND}
N -2410 -3150 -2410 -3140 {
lab=GND}
N -2360 -3200 -2360 -3190 {
lab=vpres4}
N -2470 -3220 -2460 -3220 {
lab=ctrl1}
N -2410 -3320 -2410 -3310 {
lab=GND}
N -2460 -3360 -2460 -3350 {
lab=vpre4}
N -2470 -3400 -2470 -3390 {
lab=ctrl2}
N -2470 -3390 -2460 -3390 {
lab=ctrl2}
N -2470 -3240 -2470 -3220 {
lab=ctrl1}
N -2410 -3430 -2410 -3400 {
lab=vdd_tg}
N -2410 -3600 -2410 -3570 {
lab=vdd_delay}
N -2410 -3270 -2410 -3230 {
lab=vdd_sw}
N -2470 -3530 -2470 -3520 {
lab=vpre4}
N -2350 -3530 -2350 -3520 {
lab=vpos4}
N -2360 -3370 -2360 -3360 {
lab=vpres4}
N -2470 -3190 -2460 -3190 {
lab=uw}
N -2470 -3160 -2460 -3160 {
lab=vbias}
N -2410 -2970 -2410 -2960 {
lab=GND}
N -2410 -2630 -2410 -2620 {
lab=GND}
N -2360 -2680 -2360 -2670 {
lab=vpres5}
N -2470 -2700 -2460 -2700 {
lab=ctrl1}
N -2410 -2800 -2410 -2790 {
lab=GND}
N -2460 -2840 -2460 -2830 {
lab=vpre5}
N -2470 -2880 -2470 -2870 {
lab=ctrl2}
N -2470 -2870 -2460 -2870 {
lab=ctrl2}
N -2470 -2720 -2470 -2700 {
lab=ctrl1}
N -2410 -2910 -2410 -2880 {
lab=vdd_tg}
N -2410 -3080 -2410 -3050 {
lab=vdd_delay}
N -2410 -2750 -2410 -2710 {
lab=vdd_sw}
N -2470 -3010 -2470 -3000 {
lab=vpre5}
N -2350 -3010 -2350 -3000 {
lab=vpos5}
N -2360 -2850 -2360 -2840 {
lab=vpres5}
N -2470 -2670 -2460 -2670 {
lab=uw}
N -2470 -2640 -2460 -2640 {
lab=vbias}
N -2410 -2450 -2410 -2440 {
lab=GND}
N -2410 -2110 -2410 -2100 {
lab=GND}
N -2360 -2160 -2360 -2150 {
lab=vpres6}
N -2470 -2180 -2460 -2180 {
lab=ctrl1}
N -2410 -2280 -2410 -2270 {
lab=GND}
N -2460 -2320 -2460 -2310 {
lab=vpre6}
N -2470 -2360 -2470 -2350 {
lab=ctrl2}
N -2470 -2350 -2460 -2350 {
lab=ctrl2}
N -2470 -2200 -2470 -2180 {
lab=ctrl1}
N -2410 -2390 -2410 -2360 {
lab=vdd_tg}
N -2410 -2560 -2410 -2530 {
lab=vdd_delay}
N -2410 -2230 -2410 -2190 {
lab=vdd_sw}
N -2470 -2490 -2470 -2480 {
lab=vpre6}
N -2350 -2490 -2350 -2480 {
lab=vpos6}
N -2360 -2330 -2360 -2320 {
lab=vpres6}
N -2470 -2150 -2460 -2150 {
lab=uw}
N -2470 -2120 -2460 -2120 {
lab=vbias}
N -2410 -1930 -2410 -1920 {
lab=GND}
N -2410 -1590 -2410 -1580 {
lab=GND}
N -2360 -1640 -2360 -1630 {
lab=vpres7}
N -2470 -1660 -2460 -1660 {
lab=ctrl1}
N -2410 -1760 -2410 -1750 {
lab=GND}
N -2460 -1800 -2460 -1790 {
lab=vpre7}
N -2470 -1840 -2470 -1830 {
lab=ctrl2}
N -2470 -1830 -2460 -1830 {
lab=ctrl2}
N -2470 -1680 -2470 -1660 {
lab=ctrl1}
N -2410 -1870 -2410 -1840 {
lab=vdd_tg}
N -2410 -2040 -2410 -2010 {
lab=vdd_delay}
N -2410 -1710 -2410 -1670 {
lab=vdd_sw}
N -2470 -1970 -2470 -1960 {
lab=vpre7}
N -2350 -1970 -2350 -1960 {
lab=vpos7}
N -2360 -1810 -2360 -1800 {
lab=vpres7}
N -2470 -1630 -2460 -1630 {
lab=uw}
N -2470 -1600 -2460 -1600 {
lab=vbias}
N -2410 -1410 -2410 -1400 {
lab=GND}
N -2410 -1070 -2410 -1060 {
lab=GND}
N -2360 -1120 -2360 -1110 {
lab=vpres8}
N -2470 -1140 -2460 -1140 {
lab=ctrl1}
N -2410 -1240 -2410 -1230 {
lab=GND}
N -2460 -1280 -2460 -1270 {
lab=vpre8}
N -2470 -1320 -2470 -1310 {
lab=ctrl2}
N -2470 -1310 -2460 -1310 {
lab=ctrl2}
N -2470 -1160 -2470 -1140 {
lab=ctrl1}
N -2410 -1350 -2410 -1320 {
lab=vdd_tg}
N -2410 -1520 -2410 -1490 {
lab=vdd_delay}
N -2410 -1190 -2410 -1150 {
lab=vdd_sw}
N -2470 -1450 -2470 -1440 {
lab=vpre8}
N -2350 -1450 -2350 -1440 {
lab=vpos8}
N -2360 -1290 -2360 -1280 {
lab=vpres8}
N -2470 -1110 -2460 -1110 {
lab=uw}
N -2470 -1080 -2460 -1080 {
lab=vbias}
N -2410 -890 -2410 -880 {
lab=GND}
N -2410 -550 -2410 -540 {
lab=GND}
N -2360 -600 -2360 -590 {
lab=vpres9}
N -2470 -620 -2460 -620 {
lab=ctrl1}
N -2410 -720 -2410 -710 {
lab=GND}
N -2460 -760 -2460 -750 {
lab=vpre9}
N -2470 -800 -2470 -790 {
lab=ctrl2}
N -2470 -790 -2460 -790 {
lab=ctrl2}
N -2470 -640 -2470 -620 {
lab=ctrl1}
N -2410 -830 -2410 -800 {
lab=vdd_tg}
N -2410 -1000 -2410 -970 {
lab=vdd_delay}
N -2410 -670 -2410 -630 {
lab=vdd_sw}
N -2470 -930 -2470 -920 {
lab=vpre9}
N -2350 -930 -2350 -920 {
lab=vpos9}
N -2360 -770 -2360 -760 {
lab=vpres9}
N -2470 -590 -2460 -590 {
lab=uw}
N -2470 -560 -2460 -560 {
lab=vbias}
N -2240 -3820 -2240 -3810 {
lab=GND}
N -2240 -3930 -2240 -3920 {
lab=vdd_syn1}
N -2180 -3740 -2170 -3740 {
lab=GND}
N -2180 -3710 -2180 -3700 {
lab=p0}
N -2300 -3890 -2300 -3880 {
lab=vpres3}
N -2180 -3890 -2180 -3880 {
lab=vpos3}
N -2230 -3740 -2220 -3740 {
lab=ctrl_pos}
N -2180 -3860 -2180 -3840 {
lab=#net20}
N -2180 -3780 -2180 -3770 {
lab=#net21}
N -2020 -3820 -2020 -3810 {
lab=GND}
N -2020 -3930 -2020 -3920 {
lab=vdd_syn2}
N -1960 -3740 -1950 -3740 {
lab=GND}
N -1960 -3710 -1960 -3700 {
lab=p1}
N -2080 -3890 -2080 -3880 {
lab=vpres3}
N -1960 -3890 -1960 -3880 {
lab=vpos3}
N -2010 -3740 -2000 -3740 {
lab=ctrl_pos}
N -1960 -3860 -1960 -3840 {
lab=#net22}
N -1960 -3780 -1960 -3770 {
lab=#net23}
N -1800 -3820 -1800 -3810 {
lab=GND}
N -1800 -3930 -1800 -3920 {
lab=vdd_syn3}
N -1740 -3740 -1730 -3740 {
lab=GND}
N -1740 -3710 -1740 -3700 {
lab=p2}
N -1860 -3890 -1860 -3880 {
lab=vpres3}
N -1740 -3890 -1740 -3880 {
lab=vpos3}
N -1790 -3740 -1780 -3740 {
lab=ctrl_pos}
N -1740 -3860 -1740 -3840 {
lab=#net24}
N -1740 -3780 -1740 -3770 {
lab=#net25}
N -2240 -3300 -2240 -3290 {
lab=GND}
N -2240 -3410 -2240 -3400 {
lab=vdd_syn1}
N -2180 -3220 -2170 -3220 {
lab=GND}
N -2180 -3190 -2180 -3180 {
lab=p0}
N -2300 -3370 -2300 -3360 {
lab=vpres4}
N -2180 -3370 -2180 -3360 {
lab=vpos4}
N -2230 -3220 -2220 -3220 {
lab=ctrl_pos}
N -2180 -3340 -2180 -3320 {
lab=#net26}
N -2180 -3260 -2180 -3250 {
lab=#net27}
N -2020 -3300 -2020 -3290 {
lab=GND}
N -2020 -3410 -2020 -3400 {
lab=vdd_syn2}
N -1960 -3220 -1950 -3220 {
lab=GND}
N -1960 -3190 -1960 -3180 {
lab=p1}
N -2080 -3370 -2080 -3360 {
lab=vpres4}
N -1960 -3370 -1960 -3360 {
lab=vpos4}
N -2010 -3220 -2000 -3220 {
lab=ctrl_pos}
N -1960 -3340 -1960 -3320 {
lab=#net28}
N -1960 -3260 -1960 -3250 {
lab=#net29}
N -1800 -3300 -1800 -3290 {
lab=GND}
N -1800 -3410 -1800 -3400 {
lab=vdd_syn3}
N -1740 -3220 -1730 -3220 {
lab=GND}
N -1740 -3190 -1740 -3180 {
lab=p2}
N -1860 -3370 -1860 -3360 {
lab=vpres4}
N -1740 -3370 -1740 -3360 {
lab=vpos4}
N -1790 -3220 -1780 -3220 {
lab=ctrl_pos}
N -1740 -3340 -1740 -3320 {
lab=#net30}
N -1740 -3260 -1740 -3250 {
lab=#net31}
N -2240 -2780 -2240 -2770 {
lab=GND}
N -2240 -2890 -2240 -2880 {
lab=vdd_syn1}
N -2180 -2700 -2170 -2700 {
lab=GND}
N -2180 -2670 -2180 -2660 {
lab=p0}
N -2300 -2850 -2300 -2840 {
lab=vpres5}
N -2180 -2850 -2180 -2840 {
lab=vpos5}
N -2230 -2700 -2220 -2700 {
lab=ctrl_pos}
N -2180 -2820 -2180 -2800 {
lab=#net32}
N -2180 -2740 -2180 -2730 {
lab=#net33}
N -2020 -2780 -2020 -2770 {
lab=GND}
N -2020 -2890 -2020 -2880 {
lab=vdd_syn2}
N -1960 -2700 -1950 -2700 {
lab=GND}
N -1960 -2670 -1960 -2660 {
lab=p1}
N -2080 -2850 -2080 -2840 {
lab=vpres5}
N -1960 -2850 -1960 -2840 {
lab=vpos5}
N -2010 -2700 -2000 -2700 {
lab=ctrl_pos}
N -1960 -2820 -1960 -2800 {
lab=#net34}
N -1960 -2740 -1960 -2730 {
lab=#net35}
N -1800 -2780 -1800 -2770 {
lab=GND}
N -1800 -2890 -1800 -2880 {
lab=vdd_syn3}
N -1740 -2700 -1730 -2700 {
lab=GND}
N -1740 -2670 -1740 -2660 {
lab=p2}
N -1860 -2850 -1860 -2840 {
lab=vpres5}
N -1740 -2850 -1740 -2840 {
lab=vpos5}
N -1790 -2700 -1780 -2700 {
lab=ctrl_pos}
N -1740 -2820 -1740 -2800 {
lab=#net36}
N -1740 -2740 -1740 -2730 {
lab=#net37}
N -2240 -2260 -2240 -2250 {
lab=GND}
N -2240 -2370 -2240 -2360 {
lab=vdd_syn1}
N -2180 -2180 -2170 -2180 {
lab=GND}
N -2180 -2150 -2180 -2140 {
lab=p0}
N -2300 -2330 -2300 -2320 {
lab=vpres6}
N -2180 -2330 -2180 -2320 {
lab=vpos6}
N -2230 -2180 -2220 -2180 {
lab=ctrl_pos}
N -2180 -2300 -2180 -2280 {
lab=#net38}
N -2180 -2220 -2180 -2210 {
lab=#net39}
N -2020 -2260 -2020 -2250 {
lab=GND}
N -2020 -2370 -2020 -2360 {
lab=vdd_syn2}
N -1960 -2180 -1950 -2180 {
lab=GND}
N -1960 -2150 -1960 -2140 {
lab=p1}
N -2080 -2330 -2080 -2320 {
lab=vpres6}
N -1960 -2330 -1960 -2320 {
lab=vpos6}
N -2010 -2180 -2000 -2180 {
lab=ctrl_pos}
N -1960 -2300 -1960 -2280 {
lab=#net40}
N -1960 -2220 -1960 -2210 {
lab=#net41}
N -1800 -2260 -1800 -2250 {
lab=GND}
N -1800 -2370 -1800 -2360 {
lab=vdd_syn3}
N -1740 -2180 -1730 -2180 {
lab=GND}
N -1740 -2150 -1740 -2140 {
lab=p2}
N -1860 -2330 -1860 -2320 {
lab=vpres6}
N -1740 -2330 -1740 -2320 {
lab=vpos6}
N -1790 -2180 -1780 -2180 {
lab=ctrl_pos}
N -1740 -2300 -1740 -2280 {
lab=#net42}
N -1740 -2220 -1740 -2210 {
lab=#net43}
N -2240 -1740 -2240 -1730 {
lab=GND}
N -2240 -1850 -2240 -1840 {
lab=vdd_syn1}
N -2180 -1660 -2170 -1660 {
lab=GND}
N -2180 -1630 -2180 -1620 {
lab=p0}
N -2300 -1810 -2300 -1800 {
lab=vpres7}
N -2180 -1810 -2180 -1800 {
lab=vpos7}
N -2230 -1660 -2220 -1660 {
lab=ctrl_pos}
N -2180 -1780 -2180 -1760 {
lab=#net44}
N -2180 -1700 -2180 -1690 {
lab=#net45}
N -2020 -1740 -2020 -1730 {
lab=GND}
N -2020 -1850 -2020 -1840 {
lab=vdd_syn2}
N -1960 -1660 -1950 -1660 {
lab=GND}
N -1960 -1630 -1960 -1620 {
lab=p1}
N -2080 -1810 -2080 -1800 {
lab=vpres7}
N -1960 -1810 -1960 -1800 {
lab=vpos7}
N -2010 -1660 -2000 -1660 {
lab=ctrl_pos}
N -1960 -1780 -1960 -1760 {
lab=#net46}
N -1960 -1700 -1960 -1690 {
lab=#net47}
N -1800 -1740 -1800 -1730 {
lab=GND}
N -1800 -1850 -1800 -1840 {
lab=vdd_syn3}
N -1740 -1660 -1730 -1660 {
lab=GND}
N -1740 -1630 -1740 -1620 {
lab=p2}
N -1860 -1810 -1860 -1800 {
lab=vpres7}
N -1740 -1810 -1740 -1800 {
lab=vpos7}
N -1790 -1660 -1780 -1660 {
lab=ctrl_pos}
N -1740 -1780 -1740 -1760 {
lab=#net48}
N -1740 -1700 -1740 -1690 {
lab=#net49}
N -2240 -1220 -2240 -1210 {
lab=GND}
N -2240 -1330 -2240 -1320 {
lab=vdd_syn1}
N -2180 -1140 -2170 -1140 {
lab=GND}
N -2180 -1110 -2180 -1100 {
lab=p0}
N -2300 -1290 -2300 -1280 {
lab=vpres8}
N -2180 -1290 -2180 -1280 {
lab=vpos8}
N -2230 -1140 -2220 -1140 {
lab=ctrl_pos}
N -2180 -1260 -2180 -1240 {
lab=#net50}
N -2180 -1180 -2180 -1170 {
lab=#net51}
N -2020 -1220 -2020 -1210 {
lab=GND}
N -2020 -1330 -2020 -1320 {
lab=vdd_syn2}
N -1960 -1140 -1950 -1140 {
lab=GND}
N -1960 -1110 -1960 -1100 {
lab=p1}
N -2080 -1290 -2080 -1280 {
lab=vpres8}
N -1960 -1290 -1960 -1280 {
lab=vpos8}
N -2010 -1140 -2000 -1140 {
lab=ctrl_pos}
N -1960 -1260 -1960 -1240 {
lab=#net52}
N -1960 -1180 -1960 -1170 {
lab=#net53}
N -1800 -1220 -1800 -1210 {
lab=GND}
N -1800 -1330 -1800 -1320 {
lab=vdd_syn3}
N -1740 -1140 -1730 -1140 {
lab=GND}
N -1740 -1110 -1740 -1100 {
lab=p2}
N -1860 -1290 -1860 -1280 {
lab=vpres8}
N -1740 -1290 -1740 -1280 {
lab=vpos8}
N -1790 -1140 -1780 -1140 {
lab=ctrl_pos}
N -1740 -1260 -1740 -1240 {
lab=#net54}
N -1740 -1180 -1740 -1170 {
lab=#net55}
N -2240 -700 -2240 -690 {
lab=GND}
N -2240 -810 -2240 -800 {
lab=vdd_syn1}
N -2180 -620 -2170 -620 {
lab=GND}
N -2180 -590 -2180 -580 {
lab=p0}
N -2300 -770 -2300 -760 {
lab=vpres9}
N -2180 -770 -2180 -760 {
lab=vpos9}
N -2230 -620 -2220 -620 {
lab=ctrl_pos}
N -2180 -740 -2180 -720 {
lab=#net56}
N -2180 -660 -2180 -650 {
lab=#net57}
N -2020 -700 -2020 -690 {
lab=GND}
N -2020 -810 -2020 -800 {
lab=vdd_syn2}
N -1960 -620 -1950 -620 {
lab=GND}
N -1960 -590 -1960 -580 {
lab=p1}
N -2080 -770 -2080 -760 {
lab=vpres9}
N -1960 -770 -1960 -760 {
lab=vpos9}
N -2010 -620 -2000 -620 {
lab=ctrl_pos}
N -1960 -740 -1960 -720 {
lab=#net58}
N -1960 -660 -1960 -650 {
lab=#net59}
N -1800 -700 -1800 -690 {
lab=GND}
N -1800 -810 -1800 -800 {
lab=vdd_syn3}
N -1740 -620 -1730 -620 {
lab=GND}
N -1740 -590 -1740 -580 {
lab=p2}
N -1860 -770 -1860 -760 {
lab=vpres9}
N -1740 -770 -1740 -760 {
lab=vpos9}
N -1790 -620 -1780 -620 {
lab=ctrl_pos}
N -1740 -740 -1740 -720 {
lab=#net60}
N -1740 -660 -1740 -650 {
lab=#net61}
N -2660 -3290 -2660 -3270 {
lab=GND}
N -2660 -3450 -2660 -3430 {
lab=vdd_pre}
N -3040 -3280 -3040 -3260 {
lab=GND}
N -2840 -3380 -2840 -3360 {
lab=vc4}
N -2840 -3410 -2830 -3410 {
lab=vdd_in}
N -2830 -3440 -2830 -3410 {
lab=vdd_in}
N -2840 -3440 -2830 -3440 {
lab=vdd_in}
N -2920 -3410 -2880 -3410 {
lab=#net62}
N -2960 -3440 -2840 -3440 {
lab=vdd_in}
N -2970 -3410 -2960 -3410 {
lab=vdd_in}
N -2970 -3440 -2970 -3410 {
lab=vdd_in}
N -2970 -3440 -2960 -3440 {
lab=vdd_in}
N -2960 -3380 -2960 -3360 {
lab=#net62}
N -2960 -3360 -2900 -3360 {
lab=#net62}
N -2900 -3410 -2900 -3360 {
lab=#net62}
N -3040 -3360 -3040 -3340 {
lab=#net63}
N -2520 -3360 -2510 -3360 {
lab=vpre4}
N -2980 -3360 -2960 -3360 {
lab=#net62}
N -2660 -3810 -2660 -3790 {
lab=GND}
N -2660 -3970 -2660 -3950 {
lab=vdd_pre}
N -3040 -3800 -3040 -3780 {
lab=GND}
N -2840 -3900 -2840 -3880 {
lab=vc3}
N -2840 -3930 -2830 -3930 {
lab=vdd_in}
N -2830 -3960 -2830 -3930 {
lab=vdd_in}
N -2840 -3960 -2830 -3960 {
lab=vdd_in}
N -2920 -3930 -2880 -3930 {
lab=#net64}
N -2960 -3960 -2840 -3960 {
lab=vdd_in}
N -2970 -3930 -2960 -3930 {
lab=vdd_in}
N -2970 -3960 -2970 -3930 {
lab=vdd_in}
N -2970 -3960 -2960 -3960 {
lab=vdd_in}
N -2960 -3900 -2960 -3880 {
lab=#net64}
N -2960 -3880 -2900 -3880 {
lab=#net64}
N -2900 -3930 -2900 -3880 {
lab=#net64}
N -3040 -3880 -3040 -3860 {
lab=#net65}
N -2520 -3880 -2510 -3880 {
lab=vpre3}
N -2980 -3880 -2960 -3880 {
lab=#net64}
N -2840 -3880 -2760 -3880 {
lab=vc3}
N -2760 -3920 -2750 -3920 {
lab=vlky}
N -2760 -3840 -2750 -3840 {
lab=vb_pre}
N -2760 -3400 -2750 -3400 {
lab=vlky}
N -2840 -3360 -2760 -3360 {
lab=vc4}
N -2760 -3320 -2750 -3320 {
lab=vb_pre}
N -2660 -2250 -2660 -2230 {
lab=GND}
N -2660 -2410 -2660 -2390 {
lab=vdd_pre}
N -3040 -2240 -3040 -2220 {
lab=GND}
N -2840 -2340 -2840 -2320 {
lab=vc6}
N -2840 -2370 -2830 -2370 {
lab=vdd_in}
N -2830 -2400 -2830 -2370 {
lab=vdd_in}
N -2840 -2400 -2830 -2400 {
lab=vdd_in}
N -2920 -2370 -2880 -2370 {
lab=#net66}
N -2960 -2400 -2840 -2400 {
lab=vdd_in}
N -2970 -2370 -2960 -2370 {
lab=vdd_in}
N -2970 -2400 -2970 -2370 {
lab=vdd_in}
N -2970 -2400 -2960 -2400 {
lab=vdd_in}
N -2960 -2340 -2960 -2320 {
lab=#net66}
N -2960 -2320 -2900 -2320 {
lab=#net66}
N -2900 -2370 -2900 -2320 {
lab=#net66}
N -3040 -2320 -3040 -2300 {
lab=#net67}
N -2520 -2320 -2510 -2320 {
lab=vpre6}
N -2980 -2320 -2960 -2320 {
lab=#net66}
N -2660 -2770 -2660 -2750 {
lab=GND}
N -2660 -2930 -2660 -2910 {
lab=vdd_pre}
N -3040 -2760 -3040 -2740 {
lab=GND}
N -2840 -2860 -2840 -2840 {
lab=vc5}
N -2840 -2890 -2830 -2890 {
lab=vdd_in}
N -2830 -2920 -2830 -2890 {
lab=vdd_in}
N -2840 -2920 -2830 -2920 {
lab=vdd_in}
N -2920 -2890 -2880 -2890 {
lab=#net68}
N -2960 -2920 -2840 -2920 {
lab=vdd_in}
N -2970 -2890 -2960 -2890 {
lab=vdd_in}
N -2970 -2920 -2970 -2890 {
lab=vdd_in}
N -2970 -2920 -2960 -2920 {
lab=vdd_in}
N -2960 -2860 -2960 -2840 {
lab=#net68}
N -2960 -2840 -2900 -2840 {
lab=#net68}
N -2900 -2890 -2900 -2840 {
lab=#net68}
N -3040 -2840 -3040 -2820 {
lab=#net69}
N -2520 -2840 -2510 -2840 {
lab=vpre5}
N -2980 -2840 -2960 -2840 {
lab=#net68}
N -2840 -2840 -2760 -2840 {
lab=vc5}
N -2760 -2880 -2750 -2880 {
lab=vlky}
N -2760 -2800 -2750 -2800 {
lab=vb_pre}
N -2760 -2360 -2750 -2360 {
lab=vlky}
N -2840 -2320 -2760 -2320 {
lab=vc6}
N -2760 -2280 -2750 -2280 {
lab=vb_pre}
N -2660 -1210 -2660 -1190 {
lab=GND}
N -2660 -1370 -2660 -1350 {
lab=vdd_pre}
N -3040 -1200 -3040 -1180 {
lab=GND}
N -2840 -1300 -2840 -1280 {
lab=vc8}
N -2840 -1330 -2830 -1330 {
lab=vdd_in}
N -2830 -1360 -2830 -1330 {
lab=vdd_in}
N -2840 -1360 -2830 -1360 {
lab=vdd_in}
N -2920 -1330 -2880 -1330 {
lab=#net70}
N -2960 -1360 -2840 -1360 {
lab=vdd_in}
N -2970 -1330 -2960 -1330 {
lab=vdd_in}
N -2970 -1360 -2970 -1330 {
lab=vdd_in}
N -2970 -1360 -2960 -1360 {
lab=vdd_in}
N -2960 -1300 -2960 -1280 {
lab=#net70}
N -2960 -1280 -2900 -1280 {
lab=#net70}
N -2900 -1330 -2900 -1280 {
lab=#net70}
N -3040 -1280 -3040 -1260 {
lab=#net71}
N -2520 -1280 -2510 -1280 {
lab=vpre8}
N -2980 -1280 -2960 -1280 {
lab=#net70}
N -2660 -1730 -2660 -1710 {
lab=GND}
N -2660 -1890 -2660 -1870 {
lab=vdd_pre}
N -3040 -1720 -3040 -1700 {
lab=GND}
N -2840 -1820 -2840 -1800 {
lab=vc7}
N -2840 -1850 -2830 -1850 {
lab=vdd_in}
N -2830 -1880 -2830 -1850 {
lab=vdd_in}
N -2840 -1880 -2830 -1880 {
lab=vdd_in}
N -2920 -1850 -2880 -1850 {
lab=#net72}
N -2960 -1880 -2840 -1880 {
lab=vdd_in}
N -2970 -1850 -2960 -1850 {
lab=vdd_in}
N -2970 -1880 -2970 -1850 {
lab=vdd_in}
N -2970 -1880 -2960 -1880 {
lab=vdd_in}
N -2960 -1820 -2960 -1800 {
lab=#net72}
N -2960 -1800 -2900 -1800 {
lab=#net72}
N -2900 -1850 -2900 -1800 {
lab=#net72}
N -3040 -1800 -3040 -1780 {
lab=#net73}
N -2520 -1800 -2510 -1800 {
lab=vpre7}
N -2980 -1800 -2960 -1800 {
lab=#net72}
N -2840 -1800 -2760 -1800 {
lab=vc7}
N -2760 -1840 -2750 -1840 {
lab=vlky}
N -2760 -1760 -2750 -1760 {
lab=vb_pre}
N -2760 -1320 -2750 -1320 {
lab=vlky}
N -2840 -1280 -2760 -1280 {
lab=vc8}
N -2760 -1240 -2750 -1240 {
lab=vb_pre}
N -2660 -690 -2660 -670 {
lab=GND}
N -2660 -850 -2660 -830 {
lab=vdd_pre}
N -3040 -680 -3040 -660 {
lab=GND}
N -2840 -780 -2840 -760 {
lab=vc9}
N -2840 -810 -2830 -810 {
lab=vdd_in}
N -2830 -840 -2830 -810 {
lab=vdd_in}
N -2840 -840 -2830 -840 {
lab=vdd_in}
N -2920 -810 -2880 -810 {
lab=#net74}
N -2960 -840 -2840 -840 {
lab=vdd_in}
N -2970 -810 -2960 -810 {
lab=vdd_in}
N -2970 -840 -2970 -810 {
lab=vdd_in}
N -2970 -840 -2960 -840 {
lab=vdd_in}
N -2960 -780 -2960 -760 {
lab=#net74}
N -2960 -760 -2900 -760 {
lab=#net74}
N -2900 -810 -2900 -760 {
lab=#net74}
N -3040 -760 -3040 -740 {
lab=#net75}
N -2520 -760 -2510 -760 {
lab=vpre9}
N -2980 -760 -2960 -760 {
lab=#net74}
N -2760 -800 -2750 -800 {
lab=vlky}
N -2840 -760 -2760 -760 {
lab=vc9}
N -2760 -720 -2750 -720 {
lab=vb_pre}
N -660 -3060 -650 -3060 {
lab=N0}
N -660 -3090 -650 -3090 {
lab=N1}
N -660 -3120 -650 -3120 {
lab=N2}
N -1300 -3410 -1300 -3390 {
lab=GND}
N -1300 -3490 -1300 -3470 {
lab=vdd_syn3}
N -580 -2660 -570 -2660 {
lab=inh2}
N -610 -2670 -610 -2660 {
lab=GND}
N -610 -2620 -610 -2610 {
lab=inh_d}
N -650 -2660 -640 -2660 {
lab=vinh}
C {devices/vsource.sym} -1500 -3300 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1500 -3250 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1420 -3300 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1420 -3250 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1420 -3350 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2660 -4310 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2760 -4360 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -4350 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 284.999u 0 285u 5u 289.999u 5u 290u 0 304.999u 0 305u 5u)"}
C {devices/gnd.sym} -3040 -4300 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -4450 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -4450 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -1410 -2480 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1530 -2480 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1280 -2480 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param Lp_delay=3.5
.param Wp_delay=0.45
.param Ln_delay=3.5
.param Wn_delay=0.45
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 1n 310u
  write SNN_9x3_tb.raw
.endc
" }
C {devices/launcher.sym} 900 -645 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/SNN_9x3_tb.raw tran"
}
C {devices/lab_pin.sym} -2840 -4400 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} -1240 -3300 0 0 {name=V4 value="PWL(0 1.8 284.9u 1.8 285u 0)"}
C {devices/gnd.sym} -1240 -3250 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1240 -3350 2 0 {name=p16 sig_type=std_logic lab=vdd_delay}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -4740 0 0 {name=x10}
C {devices/gnd.sym} -2240 -4850 0 0 {name=l39 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -4450 0 0 {name=x121}
C {devices/lab_pin.sym} -2300 -4930 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2180 -4930 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2410 -4520 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2350 -4560 3 0 {name=p28 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2470 -4560 3 0 {name=p33 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2180 -4850 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -4780 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -4780 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -2180 -4740 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2470 -4230 0 0 {name=p53 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2220 -250 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2250 -130 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -2180 -290 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -2180 -330 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 0 2 0 {name=p61 sig_type=std_logic lab=N0}
C {devices/vsource.sym} -1500 -2880 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1500 -2830 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1500 -2930 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1500 -2740 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 199.9u 1.8 280u 0)"}
C {devices/gnd.sym} -1500 -2690 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1500 -2790 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} -1500 -2600 0 0 {name=V15 value="PWL(0 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1500 -2550 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1500 -2650 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -3010 -4400 1 0 {name=Vmeas102 savecurrent=true}
C {devices/lab_pin.sym} -2470 -4280 2 0 {name=p74 sig_type=std_logic lab=ctrl1}
C {devices/vsource.sym} -1500 -3020 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1500 -2970 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1500 -3070 2 0 {name=p75 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -4180 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2470 -4440 2 0 {name=p14 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -4350 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} -1320 -3020 0 0 {name=V12 value="PWL(0 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1320 -2970 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1320 -3070 2 0 {name=p17 sig_type=std_logic lab=ctrl2}
C {devices/vsource.sym} -1340 -3160 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1340 -3110 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1340 -3210 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -1330 -3300 0 0 {name=V3 value="PWL(0 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1330 -3250 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1330 -3350 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1130 -3300 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1130 -3250 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1130 -3350 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1050 -3300 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1050 -3250 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1050 -3350 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1500 -3160 0 0 {name=V7 value=0.5}
C {devices/gnd.sym} -1500 -3110 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1500 -3210 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1420 -3160 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1420 -3110 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1420 -3210 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2660 -4490 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2110 -130 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2240 -4970 1 0 {name=p15 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2410 -4640 0 0 {name=p18 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -4310 0 0 {name=p19 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -4470 0 0 {name=p20 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -1500 -3350 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2900 -4480 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -4830 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2760 -4880 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -4870 0 0 {name=I1 value="PWL(0 0 39.9u 0 40u 5u 279.9u 5u 280u 0 284.999u 0 285u 5u)"}
C {devices/gnd.sym} -3040 -4820 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -4970 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -4970 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -4920 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -4220 0 0 {name=x20}
C {devices/gnd.sym} -2240 -4330 0 0 {name=l15 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -4970 0 0 {name=x111}
C {devices/lab_pin.sym} -2300 -4410 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2180 -4410 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2410 -5040 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -2350 -5080 3 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2470 -5080 3 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2180 -4330 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -4260 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -4260 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -2180 -4220 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2360 -4760 1 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2470 -4750 0 0 {name=p36 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2510 -4920 3 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3010 -4920 1 0 {name=Vmeas101 savecurrent=true}
C {devices/lab_pin.sym} -2470 -4800 2 0 {name=p38 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -4700 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2360 -4930 1 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2460 -4910 3 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2470 -4960 2 0 {name=p42 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -4870 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2660 -5010 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2240 -4450 1 0 {name=p44 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2410 -5160 0 0 {name=p45 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -4830 0 0 {name=p47 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -4990 0 0 {name=p48 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2900 -5000 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2230 -4260 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2230 -4780 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1130 -3020 0 0 {name=V16 value="PWL(0 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1130 -2970 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1130 -3070 2 0 {name=p71 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -970 -3300 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -970 -3250 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -970 -3350 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} -580 -3030 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -580 -3150 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -660 -3120 0 0 {name=p83 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} -660 -3090 0 0 {name=p84 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -2250 -250 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} -950 -3020 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -950 -2970 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -950 -3070 2 0 {name=p88 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -510 -3090 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -570 -2940 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} -610 -2920 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -610 -2950 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -610 -2890 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -650 -2940 0 0 {name=p85 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -570 -2800 2 0 {name=p89 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} -610 -2780 3 0 {name=M201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -610 -2810 2 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -610 -2750 2 0 {name=p90 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -650 -2800 0 0 {name=p93 sig_type=std_logic lab=vinh}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -4400 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -4920 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -2180 -150 1 0 {name=x0}
C {devices/vsource.sym} -1270 -3160 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -1270 -3110 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -1270 -3210 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -4960 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -4440 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2140 -250 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2000 -250 1 0 {name=p57 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2030 -130 0 0 {name=l22 lab=GND}
C {devices/ammeter.sym} -1960 -290 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -1960 -330 2 0 {name=p58 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 0 2 0 {name=p62 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -1890 -130 3 0 {name=p86 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2030 -250 1 0 {name=p98 sig_type=std_logic lab=inh1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1960 -150 1 0 {name=x1}
C {devices/lab_pin.sym} -1920 -250 1 0 {name=p99 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -1500 -3440 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1500 -3390 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -1500 -3490 2 0 {name=p7 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} -1400 -3440 0 0 {name=V20 value="PWL(0 1.8 39.9u 1.8 40u 0 119.9u 0 120u 1.8 199.9u 1.8 200u 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1400 -3390 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} -1400 -3490 2 0 {name=p51 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -4750 0 0 {name=x113}
C {devices/lab_pin.sym} -2470 -4200 0 0 {name=p49 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -4230 0 0 {name=x123}
C {devices/lab_pin.sym} -2470 -4720 0 0 {name=p100 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -4920 0 0 {name=x112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -4400 0 0 {name=x122}
C {devices/lab_pin.sym} -1780 -250 1 0 {name=p22 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -130 0 0 {name=l30 lab=GND}
C {devices/ammeter.sym} -1740 -290 0 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -1740 -330 2 0 {name=p92 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 0 2 0 {name=p101 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} -1670 -130 3 0 {name=p102 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1810 -250 1 0 {name=p103 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1740 -150 1 0 {name=x2}
C {devices/lab_pin.sym} -1700 -250 1 0 {name=p104 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -4740 0 0 {name=x11}
C {devices/gnd.sym} -2020 -4850 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -2080 -4930 1 0 {name=p52 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1960 -4930 1 0 {name=p54 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1960 -4850 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -4780 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -4780 3 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -1960 -4740 2 0 {name=p55 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2020 -4970 1 0 {name=p63 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -4220 0 0 {name=x21}
C {devices/gnd.sym} -2020 -4330 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -2080 -4410 1 0 {name=p64 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1960 -4410 1 0 {name=p67 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1960 -4330 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -4260 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -4260 3 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -1960 -4220 2 0 {name=p68 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -4260 0 0 {name=p77 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2010 -4780 0 0 {name=p79 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -4740 0 0 {name=x12}
C {devices/gnd.sym} -1800 -4850 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -1860 -4930 1 0 {name=p147 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1740 -4930 1 0 {name=p148 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1740 -4850 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4780 0 0 {name=M12
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4780 3 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -1740 -4740 2 0 {name=p149 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1800 -4970 1 0 {name=p150 sig_type=std_logic lab=vdd_syn3}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -4220 0 0 {name=x22}
C {devices/gnd.sym} -1800 -4330 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -1860 -4410 1 0 {name=p151 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1740 -4410 1 0 {name=p152 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1740 -4330 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4260 0 0 {name=M22
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4260 3 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -1740 -4220 2 0 {name=p153 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -4260 0 0 {name=p155 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1790 -4780 0 0 {name=p156 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -3930 0 0 {name=x107}
C {devices/gnd.sym} -2410 -4000 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -2350 -4040 3 0 {name=p227 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -2470 -4040 3 0 {name=p228 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2470 -3710 0 0 {name=p230 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -3760 2 0 {name=p231 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -3660 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -2360 -3890 1 0 {name=p232 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2470 -3920 2 0 {name=p234 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -3830 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -2410 -4120 0 0 {name=p235 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -3790 0 0 {name=p236 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -3950 0 0 {name=p237 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -3680 0 0 {name=p238 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -3710 0 0 {name=x133}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -3880 0 0 {name=x108}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -3410 0 0 {name=x141}
C {devices/gnd.sym} -2410 -3480 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -2350 -3520 3 0 {name=p239 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -2360 -3200 1 0 {name=p241 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2470 -3190 0 0 {name=p242 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -3240 2 0 {name=p243 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -3140 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -2360 -3370 1 0 {name=p244 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2460 -3350 3 0 {name=p245 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2470 -3400 2 0 {name=p246 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -3310 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -2410 -3600 0 0 {name=p247 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -3270 0 0 {name=p248 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -3430 0 0 {name=p249 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -3160 0 0 {name=p250 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -3190 0 0 {name=x143}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -3360 0 0 {name=x142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -2890 0 0 {name=x151}
C {devices/gnd.sym} -2410 -2960 0 0 {name=l90 lab=GND}
C {devices/lab_pin.sym} -2350 -3000 3 0 {name=p251 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2470 -2670 0 0 {name=p254 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -2720 2 0 {name=p255 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -2620 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} -2460 -2830 3 0 {name=p257 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2470 -2880 2 0 {name=p258 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -2790 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} -2410 -3080 0 0 {name=p259 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -2750 0 0 {name=p260 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -2910 0 0 {name=p261 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -2640 0 0 {name=p262 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -2670 0 0 {name=x153}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -2840 0 0 {name=x152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -2370 0 0 {name=x161}
C {devices/gnd.sym} -2410 -2440 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -2350 -2480 3 0 {name=p263 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -2360 -2160 1 0 {name=p265 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2470 -2150 0 0 {name=p266 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -2200 2 0 {name=p267 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -2100 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} -2460 -2310 3 0 {name=p269 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2470 -2360 2 0 {name=p270 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -2270 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -2410 -2560 0 0 {name=p271 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -2230 0 0 {name=p272 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -2390 0 0 {name=p273 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -2120 0 0 {name=p274 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -2150 0 0 {name=x163}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -2320 0 0 {name=x162}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -1850 0 0 {name=x171}
C {devices/gnd.sym} -2410 -1920 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} -2350 -1960 3 0 {name=p275 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -2360 -1640 1 0 {name=p277 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2470 -1630 0 0 {name=p278 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -1680 2 0 {name=p279 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -1580 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} -2460 -1790 3 0 {name=p281 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2470 -1840 2 0 {name=p282 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -1750 0 0 {name=l98 lab=GND}
C {devices/lab_pin.sym} -2410 -2040 0 0 {name=p283 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -1710 0 0 {name=p284 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -1870 0 0 {name=p285 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -1600 0 0 {name=p286 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -1630 0 0 {name=x173}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -1800 0 0 {name=x172}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -1330 0 0 {name=x181}
C {devices/gnd.sym} -2410 -1400 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2350 -1440 3 0 {name=p287 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2470 -1440 3 0 {name=p288 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2360 -1120 1 0 {name=p289 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2470 -1110 0 0 {name=p290 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -1160 2 0 {name=p291 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -1060 0 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2470 -1320 2 0 {name=p294 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -1230 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -2410 -1520 0 0 {name=p295 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -1190 0 0 {name=p296 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -1350 0 0 {name=p297 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -1080 0 0 {name=p298 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -1110 0 0 {name=x183}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -1280 0 0 {name=x182}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -810 0 0 {name=x191}
C {devices/gnd.sym} -2410 -880 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} -2350 -920 3 0 {name=p299 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -2470 -920 3 0 {name=p300 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2470 -590 0 0 {name=p302 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -640 2 0 {name=p303 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -540 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -2470 -800 2 0 {name=p306 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -710 0 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} -2410 -1000 0 0 {name=p307 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -670 0 0 {name=p308 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -830 0 0 {name=p309 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -560 0 0 {name=p310 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -590 0 0 {name=x193}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -760 0 0 {name=x192}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -3700 0 0 {name=x30}
C {devices/gnd.sym} -2240 -3810 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -2180 -3810 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -3740 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -3740 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -2180 -3700 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -3930 1 0 {name=p314 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -3740 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -3700 0 0 {name=x31}
C {devices/gnd.sym} -2020 -3810 0 0 {name=l107 lab=GND}
C {devices/ammeter.sym} -1960 -3810 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -3740 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -3740 3 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} -1960 -3700 2 0 {name=p318 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -3740 0 0 {name=p320 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -3700 0 0 {name=x32}
C {devices/gnd.sym} -1800 -3810 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -1740 -3810 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3740 0 0 {name=M32
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3740 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1740 -3700 2 0 {name=p323 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -3740 0 0 {name=p325 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -3180 0 0 {name=x40}
C {devices/gnd.sym} -2240 -3290 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -2300 -3370 1 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -2180 -3290 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -3220 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -3220 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -2180 -3180 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -3410 1 0 {name=p364 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -3220 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -3180 0 0 {name=x41}
C {devices/gnd.sym} -2020 -3290 0 0 {name=l127 lab=GND}
C {devices/ammeter.sym} -1960 -3290 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -3220 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -3220 3 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -1960 -3180 2 0 {name=p368 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -3220 0 0 {name=p370 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -3180 0 0 {name=x42}
C {devices/gnd.sym} -1800 -3290 0 0 {name=l129 lab=GND}
C {devices/ammeter.sym} -1740 -3290 0 0 {name=Vmeas42 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3220 0 0 {name=M42
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3220 3 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -1740 -3180 2 0 {name=p373 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -3220 0 0 {name=p375 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -2660 0 0 {name=x50}
C {devices/gnd.sym} -2240 -2770 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -2300 -2850 1 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2180 -2770 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -2700 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -2700 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -2180 -2660 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -2890 1 0 {name=p414 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -2700 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -2660 0 0 {name=x51}
C {devices/gnd.sym} -2020 -2770 0 0 {name=l147 lab=GND}
C {devices/ammeter.sym} -1960 -2770 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -2700 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -2700 3 0 {name=l148 lab=GND}
C {devices/lab_pin.sym} -1960 -2660 2 0 {name=p418 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -2700 0 0 {name=p420 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -2660 0 0 {name=x52}
C {devices/gnd.sym} -1800 -2770 0 0 {name=l149 lab=GND}
C {devices/ammeter.sym} -1740 -2770 0 0 {name=Vmeas52 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2700 0 0 {name=M52
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2700 3 0 {name=l150 lab=GND}
C {devices/lab_pin.sym} -1740 -2660 2 0 {name=p423 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -2700 0 0 {name=p425 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -2140 0 0 {name=x60}
C {devices/gnd.sym} -2240 -2250 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -2180 -2250 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -2180 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -2180 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -2180 -2140 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -2370 1 0 {name=p464 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -2180 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -2140 0 0 {name=x61}
C {devices/gnd.sym} -2020 -2250 0 0 {name=l167 lab=GND}
C {devices/ammeter.sym} -1960 -2250 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -2180 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -2180 3 0 {name=l168 lab=GND}
C {devices/lab_pin.sym} -1960 -2140 2 0 {name=p468 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -2180 0 0 {name=p470 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -2140 0 0 {name=x62}
C {devices/gnd.sym} -1800 -2250 0 0 {name=l169 lab=GND}
C {devices/ammeter.sym} -1740 -2250 0 0 {name=Vmeas62 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2180 0 0 {name=M62
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2180 3 0 {name=l170 lab=GND}
C {devices/lab_pin.sym} -1740 -2140 2 0 {name=p473 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -2180 0 0 {name=p475 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -1620 0 0 {name=x70}
C {devices/gnd.sym} -2240 -1730 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -2180 -1730 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -1660 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -1660 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -2180 -1620 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -1850 1 0 {name=p514 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -1660 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -1620 0 0 {name=x71}
C {devices/gnd.sym} -2020 -1730 0 0 {name=l187 lab=GND}
C {devices/ammeter.sym} -1960 -1730 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -1660 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -1660 3 0 {name=l188 lab=GND}
C {devices/lab_pin.sym} -1960 -1620 2 0 {name=p518 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -1660 0 0 {name=p520 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -1620 0 0 {name=x72}
C {devices/gnd.sym} -1800 -1730 0 0 {name=l189 lab=GND}
C {devices/ammeter.sym} -1740 -1730 0 0 {name=Vmeas72 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1660 0 0 {name=M72
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1660 3 0 {name=l190 lab=GND}
C {devices/lab_pin.sym} -1740 -1620 2 0 {name=p523 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -1660 0 0 {name=p525 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -1100 0 0 {name=x80}
C {devices/gnd.sym} -2240 -1210 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -2180 -1210 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -1140 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -1140 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -2180 -1100 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -1330 1 0 {name=p564 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -1140 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -1100 0 0 {name=x81}
C {devices/gnd.sym} -2020 -1210 0 0 {name=l207 lab=GND}
C {devices/ammeter.sym} -1960 -1210 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -1140 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -1140 3 0 {name=l208 lab=GND}
C {devices/lab_pin.sym} -1960 -1100 2 0 {name=p568 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -1140 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -1100 0 0 {name=x82}
C {devices/gnd.sym} -1800 -1210 0 0 {name=l209 lab=GND}
C {devices/ammeter.sym} -1740 -1210 0 0 {name=Vmeas82 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1140 0 0 {name=M82
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1140 3 0 {name=l210 lab=GND}
C {devices/lab_pin.sym} -1740 -1100 2 0 {name=p573 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -1140 0 0 {name=p575 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2180 -580 0 0 {name=x90}
C {devices/gnd.sym} -2240 -690 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -2300 -770 1 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2180 -770 1 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -2180 -690 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -620 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -620 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -2180 -580 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -810 1 0 {name=p614 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -620 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1960 -580 0 0 {name=x91}
C {devices/gnd.sym} -2020 -690 0 0 {name=l227 lab=GND}
C {devices/ammeter.sym} -1960 -690 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -620 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -620 3 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -1960 -580 2 0 {name=p618 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -620 0 0 {name=p620 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1740 -580 0 0 {name=x92}
C {devices/gnd.sym} -1800 -690 0 0 {name=l229 lab=GND}
C {devices/ammeter.sym} -1740 -690 0 0 {name=Vmeas92 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -620 0 0 {name=M92
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -620 3 0 {name=l230 lab=GND}
C {devices/lab_pin.sym} -1740 -580 2 0 {name=p623 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1790 -620 0 0 {name=p625 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2660 -3270 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -2760 -3320 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -3310 0 0 {name=I4 value="PWL(0 0 199.9u 0 200u 5u 279.9u 5u 280u 0 289.999u 0 290u 5u 294.999u 5u 295u 0 299.999u 0 300u 5u 304.999u 5u 305u 0)"}
C {devices/gnd.sym} -3040 -3260 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -3410 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -3410 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -3360 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -3010 -3360 1 0 {name=Vmeas104 savecurrent=true}
C {devices/lab_pin.sym} -2660 -3450 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -3440 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -3790 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -2760 -3840 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -3830 0 0 {name=I3 value="PWL(0 0 39.9u 0 40u 5u 279.9u 5u 280u 0 284.999u 0 285u 5u)"}
C {devices/gnd.sym} -3040 -3780 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -3930 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -3930 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -3880 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -3010 -3880 1 0 {name=Vmeas103 savecurrent=true}
C {devices/lab_pin.sym} -2660 -3970 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -3960 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -3360 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -3880 0 0 {name=x130}
C {devices/lab_pin.sym} -2760 -3920 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -3400 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -2230 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -2760 -2280 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -2270 0 0 {name=I6 value="PWL(0 0 199.9u 0 200u 5u 279.9u 5u 280u 0 289.999u 0 290u 5u 294.999u 5u 295u 0 299.999u 0 300u 5u 304.999u 5u 305u 0)"}
C {devices/gnd.sym} -3040 -2220 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -2370 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -2370 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -2320 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -3010 -2320 1 0 {name=Vmeas106 savecurrent=true}
C {devices/lab_pin.sym} -2660 -2410 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -2400 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -2750 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -2760 -2800 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -2790 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 284.999u 0 285u 5u 289.999u 5u 290u 0 294.999u 0 295u 5u 299.999u 5u 300u 0 304.999u 0 305u 5u)"}
C {devices/gnd.sym} -3040 -2740 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -2890 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -2890 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -2840 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -3010 -2840 1 0 {name=Vmeas105 savecurrent=true}
C {devices/lab_pin.sym} -2660 -2930 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -2920 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -2320 0 0 {name=x160}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -2840 0 0 {name=x150}
C {devices/lab_pin.sym} -2760 -2880 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -2360 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -1190 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -2760 -1240 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -1230 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 199.9u 0 200u 5u 279.9u 5u 280u 0 284.999u 0 285u 5u 294.999u 5u 295u 0 299.999u 0 300u 5u)"}
C {devices/gnd.sym} -3040 -1180 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -1330 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -1330 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -1280 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -3010 -1280 1 0 {name=Vmeas108 savecurrent=true}
C {devices/lab_pin.sym} -2660 -1370 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -1360 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -1710 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -2760 -1760 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -1750 0 0 {name=I7 value="PWL(0 0 119.9u 0 120u 5u 279.9u 5u 280u 0 289.999u 0 290u 5u 304.999u 5u 305u 0)"}
C {devices/gnd.sym} -3040 -1700 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -1850 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -1850 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -1800 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -3010 -1800 1 0 {name=Vmeas107 savecurrent=true}
C {devices/lab_pin.sym} -2660 -1890 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -1880 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -1280 0 0 {name=x180}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -1800 0 0 {name=x170}
C {devices/lab_pin.sym} -2760 -1840 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -1320 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -670 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -2760 -720 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -710 0 0 {name=I9 value="PWL(0 0 119.9u 0 120u 5u 279.9u 5u 280u 0 289.999u 0 290u 5u 304.999u 5u 305u 0)"}
C {devices/gnd.sym} -3040 -660 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -810 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -810 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -760 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -3010 -760 1 0 {name=Vmeas109 savecurrent=true}
C {devices/lab_pin.sym} -2660 -850 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -840 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2660 -760 0 0 {name=x190}
C {devices/lab_pin.sym} -2760 -800 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_3.sym} -350 -2980 0 0 {name=x3}
C {devices/lab_pin.sym} -660 -3060 0 0 {name=p105 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} -2360 -4410 1 0 {name=p2 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2360 -4240 1 0 {name=p24 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2510 -4400 3 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2460 -4390 3 0 {name=p69 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2510 -3880 3 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2460 -3870 3 0 {name=p107 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2300 -3890 1 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2360 -3720 1 0 {name=p109 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2510 -760 3 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2460 -750 3 0 {name=p111 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2360 -770 1 0 {name=p112 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2360 -600 1 0 {name=p113 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2360 -1290 1 0 {name=p114 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2300 -1290 1 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2460 -1270 3 0 {name=p116 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2510 -1280 3 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2360 -1810 1 0 {name=p118 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2300 -1810 1 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2510 -1800 3 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2470 -1960 3 0 {name=p121 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2360 -2330 1 0 {name=p122 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2300 -2330 1 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2510 -2320 3 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2470 -2480 3 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2360 -2850 1 0 {name=p126 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2360 -2680 1 0 {name=p127 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2510 -2840 3 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2470 -3000 3 0 {name=p129 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2510 -3360 3 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2470 -3520 3 0 {name=p131 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1960 -770 1 0 {name=p132 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -1740 -770 1 0 {name=p133 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -2080 -770 1 0 {name=p134 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1860 -770 1 0 {name=p135 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2020 -810 1 0 {name=p136 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -1800 -810 1 0 {name=p137 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -2020 -4450 1 0 {name=p70 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -3930 1 0 {name=p138 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -3410 1 0 {name=p139 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -2890 1 0 {name=p140 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -2370 1 0 {name=p141 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -1850 1 0 {name=p142 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -2020 -1330 1 0 {name=p143 sig_type=std_logic lab=vdd_syn2}
C {devices/lab_pin.sym} -1800 -1330 1 0 {name=p144 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -1850 1 0 {name=p145 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -2370 1 0 {name=p146 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -2890 1 0 {name=p154 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -3410 1 0 {name=p157 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -3930 1 0 {name=p158 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -1800 -4450 1 0 {name=p159 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -2180 -1290 1 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1960 -1290 1 0 {name=p161 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1740 -1290 1 0 {name=p162 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2080 -1290 1 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1860 -1290 1 0 {name=p164 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2180 -1810 1 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1960 -1810 1 0 {name=p166 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1740 -1810 1 0 {name=p167 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -2080 -1810 1 0 {name=p168 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1860 -1810 1 0 {name=p169 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2180 -2330 1 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1960 -2330 1 0 {name=p171 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1740 -2330 1 0 {name=p172 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -2080 -2330 1 0 {name=p173 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1860 -2330 1 0 {name=p174 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2080 -2850 1 0 {name=p175 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1860 -2850 1 0 {name=p176 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2180 -2850 1 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1960 -2850 1 0 {name=p178 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1740 -2850 1 0 {name=p179 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2180 -3370 1 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1960 -3370 1 0 {name=p181 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1740 -3370 1 0 {name=p182 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -2080 -3370 1 0 {name=p183 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1860 -3370 1 0 {name=p184 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2180 -3890 1 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -1960 -3890 1 0 {name=p186 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -1740 -3890 1 0 {name=p187 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -2080 -3890 1 0 {name=p188 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1860 -3890 1 0 {name=p189 sig_type=std_logic lab=vpres3}
C {devices/vsource.sym} -1300 -3440 0 0 {name=V21 value="PWL(0 1.8 39.9u 1.8 40u 0 199.9u 0 200u 1.8 279.9u 1.8 280u 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1300 -3390 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -1300 -3490 2 0 {name=p190 sig_type=std_logic lab=vdd_syn3}
C {devices/lab_pin.sym} -570 -2660 2 0 {name=p191 sig_type=std_logic lab=inh2}
C {sky130_fd_pr/nfet_01v8.sym} -610 -2640 3 0 {name=M202
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -610 -2670 2 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -610 -2610 2 0 {name=p192 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -650 -2660 0 0 {name=p193 sig_type=std_logic lab=vinh}
C {devices/launcher.sym} 910 -725 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
