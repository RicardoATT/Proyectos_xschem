v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 800 -1200 1600 -800 {flags=graph
y1=-0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="\\"Vpres1 [V];vpre1\\"
\\"Vpres2 [V];vpre2\\""
color="4 6"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 0 -1200 800 -800 {flags=graph
y1=-4.4e-06
y2=7.7e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="10 11 12 13"
node="\\"Isyn11 (A);i(vmeas11)\\"
\\"Isyn12 (A);i(vmeas12)\\"
\\"Isyn21 (A);i(vmeas21)\\"
\\"Isyn22 (A);i(vmeas22)\\""}
B 2 0 -800 800 -400 {flags=graph
y1=-0.008
y2=2.502
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="7 8"
node="\\"Vpos1 [V];vpos1\\"
\\"Vpos2 [V];vpos2\\""}
B 2 800 -800 1600 -400 {flags=graph
y1=1.4
y2=5.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="10 11 12 13"
node="\\"Thickness11 [nm]; 5 n.x11.xr1.n1#ngap -\\"
\\"Thickness12 [nm]; 5 n.x21.xr1.n1#ngap -\\"
\\"Thickness21 [nm]; 5 n.x12.xr1.n1#ngap -\\"
\\"Thickness22 [nm]; 5 n.x22.xr1.n1#ngap -\\""}
B 2 800 -400 1600 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 0 -400 800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="17 21"
node="\\"Control 1;ctrl1\\"
\\"Control 2;ctrl2\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-1.2e-07
y2=3.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16"
node="\\"Ip1 (A);i(vmeas3)\\"
\\"Ip2 (A);i(vmeas4)\\""}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-0.22
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="15 16"
node="\\"Vp1 [V];vp1\\"
\\"Vp2 [V];vp2\\""}
B 2 0 -2000 800 -1600 {flags=graph
y1=-1.15845e-07
y2=1.4252e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0







color="10 11 12 13"
node="\\"Im11 (A);i(vmeas11)\\"
\\"Im12 (A);i(vmeas12)\\"
\\"Im21 (A);i(vmeas21)\\"
\\"Im22 (A);i(vmeas22)\\""}
B 2 800 -2000 1600 -1600 {flags=graph
y1=-8.9e-05
y2=0.073
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh1
inh2
inh_d"}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000219051
x2=0.00022009
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="15 16"
node="pattern1
pattern2"}
N -3670 -980 -3670 -960 {
lab=GND}
N -3670 -1060 -3670 -1040 {
lab=vdd_in}
N -3590 -980 -3590 -960 {
lab=GND}
N -3590 -1060 -3590 -1040 {
lab=vdd_pre}
N -2600 -470 -2600 -450 {
lab=GND}
N -2600 -630 -2600 -610 {
lab=vdd_pre}
N -2980 -460 -2980 -440 {
lab=GND}
N -2780 -560 -2780 -540 {
lab=vc1}
N -2780 -590 -2770 -590 {
lab=vdd_in}
N -2770 -620 -2770 -590 {
lab=vdd_in}
N -2780 -620 -2770 -620 {
lab=vdd_in}
N -2860 -590 -2820 -590 {
lab=#net1}
N -2900 -620 -2780 -620 {
lab=vdd_in}
N -2910 -590 -2900 -590 {
lab=vdd_in}
N -2910 -620 -2910 -590 {
lab=vdd_in}
N -2910 -620 -2900 -620 {
lab=vdd_in}
N -2900 -560 -2900 -540 {
lab=#net1}
N -2900 -540 -2840 -540 {
lab=#net1}
N -2840 -590 -2840 -540 {
lab=#net1}
N -2980 -540 -2980 -520 {
lab=#net2}
N -3410 -980 -3410 -960 {
lab=GND}
N -3410 -1060 -3410 -1040 {
lab=vdd_delay}
N -2180 -1000 -2180 -990 {
lab=GND}
N -2180 -1110 -2180 -1100 {
lab=vdd_syn1}
N -2350 -670 -2350 -660 {
lab=GND}
N -2120 -920 -2110 -920 {
lab=GND}
N -2120 -890 -2120 -880 {
lab=p0}
N -2120 3600 -2120 3610 {
lab=#net3}
N -2120 3530 -2120 3540 {
lab=p0}
N -2120 3850 -2120 3860 {
lab=N0}
N -3670 -560 -3670 -540 {
lab=GND}
N -3670 -640 -3670 -620 {
lab=uw}
N -3670 -420 -3670 -400 {
lab=GND}
N -3670 -500 -3670 -480 {
lab=training}
N -2460 -540 -2450 -540 {
lab=vpre1}
N -2190 3710 -2190 3730 {
lab=GND}
N -2050 3710 -2050 3730 {
lab=vdd_pos}
N -3670 -280 -3670 -260 {
lab=GND}
N -3670 -360 -3670 -340 {
lab=inference}
N -2920 -540 -2900 -540 {
lab=#net1}
N -3670 -700 -3670 -680 {
lab=GND}
N -3670 -780 -3670 -760 {
lab=ctrl1}
N -2350 -330 -2350 -320 {
lab=GND}
N -2300 -380 -2300 -370 {
lab=vpres1}
N -2410 -400 -2400 -400 {
lab=ctrl1}
N -2350 -500 -2350 -490 {
lab=GND}
N -2400 -540 -2400 -530 {
lab=vpre1}
N -2410 -580 -2410 -570 {
lab=ctrl2}
N -2410 -570 -2400 -570 {
lab=ctrl2}
N -3490 -700 -3490 -680 {
lab=GND}
N -3490 -780 -3490 -760 {
lab=ctrl2}
N -2410 -420 -2410 -400 {
lab=ctrl1}
N -3510 -840 -3510 -820 {
lab=GND}
N -3510 -920 -3510 -900 {
lab=vbias}
N -3500 -980 -3500 -960 {
lab=GND}
N -3500 -1060 -3500 -1040 {
lab=vdd_pos}
N -3300 -980 -3300 -960 {
lab=GND}
N -3300 -1060 -3300 -1040 {
lab=vdd_sw}
N -3220 -980 -3220 -960 {
lab=GND}
N -3220 -1060 -3220 -1040 {
lab=vdd_tg}
N -3670 -840 -3670 -820 {
lab=GND}
N -3670 -920 -3670 -900 {
lab=vb_pre}
N -3590 -840 -3590 -820 {
lab=GND}
N -3590 -920 -3590 -900 {
lab=vb_pos}
N -2350 -610 -2350 -580 {
lab=vdd_tg}
N -2350 -780 -2350 -750 {
lab=vdd_delay}
N -2350 -450 -2350 -410 {
lab=vdd_sw}
N -2410 -710 -2410 -700 {
lab=vpre1}
N -2290 -710 -2290 -700 {
lab=vpos1}
N -2300 -550 -2300 -540 {
lab=vpres1}
N -2240 -1070 -2240 -1060 {
lab=vpres1}
N -2120 -1070 -2120 -1060 {
lab=vpos1}
N -2410 -370 -2400 -370 {
lab=uw}
N -2600 -990 -2600 -970 {
lab=GND}
N -2600 -1150 -2600 -1130 {
lab=vdd_pre}
N -2980 -980 -2980 -960 {
lab=GND}
N -2780 -1080 -2780 -1060 {
lab=vc2}
N -2780 -1110 -2770 -1110 {
lab=vdd_in}
N -2770 -1140 -2770 -1110 {
lab=vdd_in}
N -2780 -1140 -2770 -1140 {
lab=vdd_in}
N -2860 -1110 -2820 -1110 {
lab=#net4}
N -2900 -1140 -2780 -1140 {
lab=vdd_in}
N -2910 -1110 -2900 -1110 {
lab=vdd_in}
N -2910 -1140 -2910 -1110 {
lab=vdd_in}
N -2910 -1140 -2900 -1140 {
lab=vdd_in}
N -2900 -1080 -2900 -1060 {
lab=#net4}
N -2900 -1060 -2840 -1060 {
lab=#net4}
N -2840 -1110 -2840 -1060 {
lab=#net4}
N -2980 -1060 -2980 -1040 {
lab=#net5}
N -2180 -480 -2180 -470 {
lab=GND}
N -2180 -590 -2180 -580 {
lab=vdd_syn1}
N -2350 -1190 -2350 -1180 {
lab=GND}
N -2120 -400 -2110 -400 {
lab=GND}
N -2120 -370 -2120 -360 {
lab=p0}
N -2460 -1060 -2450 -1060 {
lab=vpre2}
N -2920 -1060 -2900 -1060 {
lab=#net4}
N -2350 -850 -2350 -840 {
lab=GND}
N -2300 -900 -2300 -890 {
lab=vpres2}
N -2410 -920 -2400 -920 {
lab=ctrl1}
N -2350 -1020 -2350 -1010 {
lab=GND}
N -2400 -1060 -2400 -1050 {
lab=vpre2}
N -2410 -1100 -2410 -1090 {
lab=ctrl2}
N -2410 -1090 -2400 -1090 {
lab=ctrl2}
N -2410 -940 -2410 -920 {
lab=ctrl1}
N -2350 -1130 -2350 -1100 {
lab=vdd_tg}
N -2350 -1300 -2350 -1270 {
lab=vdd_delay}
N -2350 -970 -2350 -930 {
lab=vdd_sw}
N -2410 -1230 -2410 -1220 {
lab=vpre2}
N -2290 -1230 -2290 -1220 {
lab=vpos2}
N -2300 -1070 -2300 -1060 {
lab=vpres2}
N -2240 -550 -2240 -540 {
lab=vpres2}
N -2120 -550 -2120 -540 {
lab=vpos2}
N -2410 -890 -2400 -890 {
lab=uw}
N -2170 -400 -2160 -400 {
lab=ctrl_pos}
N -2170 -920 -2160 -920 {
lab=ctrl_pos}
N -3300 -700 -3300 -680 {
lab=GND}
N -3300 -780 -3300 -760 {
lab=ctrl_pos}
N -3140 -980 -3140 -960 {
lab=GND}
N -3140 -1060 -3140 -1040 {
lab=vdd_inh}
N -4160 255 -4160 265 {
lab=vdd_inh}
N -4240 295 -4230 295 {
lab=N2}
N -4240 335 -4230 335 {
lab=N1}
N -3120 -700 -3120 -680 {
lab=GND}
N -3120 -780 -3120 -760 {
lab=vinh}
N -4160 365 -4160 375 {
lab=GND}
N -4100 315 -4090 315 {
lab=inh_d}
N -4160 465 -4150 465 {
lab=inh1}
N -4190 455 -4190 465 {
lab=GND}
N -4190 505 -4190 515 {
lab=inh_d}
N -4230 465 -4220 465 {
lab=vinh}
N -3970 465 -3960 465 {
lab=inh2}
N -4000 455 -4000 465 {
lab=GND}
N -4000 505 -4000 515 {
lab=inh_d}
N -4040 465 -4030 465 {
lab=vinh}
N -3440 -840 -3440 -820 {
lab=GND}
N -3440 -920 -3440 -900 {
lab=vlky}
N -2780 -1060 -2700 -1060 {
lab=vc2}
N -2700 -1100 -2690 -1100 {
lab=vlky}
N -2700 -1020 -2690 -1020 {
lab=vb_pre}
N -2700 -580 -2690 -580 {
lab=vlky}
N -2780 -540 -2700 -540 {
lab=vc1}
N -2700 -500 -2690 -500 {
lab=vb_pre}
N -2190 3610 -2190 3620 {
lab=inh1}
N -2160 3610 -2160 3620 {
lab=vb_pos}
N -2080 3610 -2080 3620 {
lab=vlky}
N -1900 3600 -1900 3610 {
lab=#net6}
N -1900 3530 -1900 3540 {
lab=p1}
N -1900 3850 -1900 3860 {
lab=N1}
N -1970 3710 -1970 3730 {
lab=GND}
N -1830 3710 -1830 3730 {
lab=vdd_pos}
N -1970 3610 -1970 3620 {
lab=inh2}
N -1940 3610 -1940 3620 {
lab=vb_pos}
N -1860 3610 -1860 3620 {
lab=vlky}
N -3670 -1120 -3670 -1100 {
lab=GND}
N -3670 -1200 -3670 -1180 {
lab=vdd_syn1}
N -3490 -1120 -3490 -1100 {
lab=GND}
N -3490 -1200 -3490 -1180 {
lab=vdd_syn2}
N -2410 -860 -2400 -860 {
lab=vbias}
N -2410 -340 -2400 -340 {
lab=vbias}
N -1680 3600 -1680 3610 {
lab=#net7}
N -1680 3530 -1680 3540 {
lab=p2}
N -1680 3850 -1680 3860 {
lab=N2}
N -1750 3710 -1750 3730 {
lab=GND}
N -1610 3710 -1610 3730 {
lab=vdd_pos}
N -1750 3610 -1750 3620 {
lab=inh1}
N -1720 3610 -1720 3620 {
lab=vb_pos}
N -1640 3610 -1640 3620 {
lab=vlky}
N -1460 3600 -1460 3610 {
lab=#net8}
N -1460 3530 -1460 3540 {
lab=p3}
N -1460 3850 -1460 3860 {
lab=N3}
N -1530 3710 -1530 3730 {
lab=GND}
N -1390 3710 -1390 3730 {
lab=vdd_pos}
N -1530 3610 -1530 3620 {
lab=inh2}
N -1500 3610 -1500 3620 {
lab=vb_pos}
N -1420 3610 -1420 3620 {
lab=vlky}
N -1240 3600 -1240 3610 {
lab=#net9}
N -1240 3530 -1240 3540 {
lab=p4}
N -1240 3850 -1240 3860 {
lab=N4}
N -1310 3710 -1310 3730 {
lab=GND}
N -1170 3710 -1170 3730 {
lab=vdd_pos}
N -1310 3610 -1310 3620 {
lab=inh2}
N -1280 3610 -1280 3620 {
lab=vb_pos}
N -1200 3610 -1200 3620 {
lab=vlky}
N -1020 3600 -1020 3610 {
lab=#net10}
N -1020 3530 -1020 3540 {
lab=p5}
N -1020 3850 -1020 3860 {
lab=N5}
N -1090 3710 -1090 3730 {
lab=GND}
N -950 3710 -950 3730 {
lab=vdd_pos}
N -1090 3610 -1090 3620 {
lab=inh1}
N -1060 3610 -1060 3620 {
lab=vb_pos}
N -980 3610 -980 3620 {
lab=vlky}
N -800 3600 -800 3610 {
lab=#net11}
N -800 3530 -800 3540 {
lab=p6}
N -800 3850 -800 3860 {
lab=N6}
N -870 3710 -870 3730 {
lab=GND}
N -730 3710 -730 3730 {
lab=vdd_pos}
N -870 3610 -870 3620 {
lab=inh2}
N -840 3610 -840 3620 {
lab=vb_pos}
N -760 3610 -760 3620 {
lab=vlky}
N -580 3600 -580 3610 {
lab=#net12}
N -580 3530 -580 3540 {
lab=p7}
N -580 3850 -580 3860 {
lab=N7}
N -650 3710 -650 3730 {
lab=GND}
N -510 3710 -510 3730 {
lab=vdd_pos}
N -650 3610 -650 3620 {
lab=inh1}
N -620 3610 -620 3620 {
lab=vb_pos}
N -540 3610 -540 3620 {
lab=vlky}
N -360 3600 -360 3610 {
lab=#net13}
N -360 3530 -360 3540 {
lab=p8}
N -360 3850 -360 3860 {
lab=N8}
N -430 3710 -430 3730 {
lab=GND}
N -290 3710 -290 3730 {
lab=vdd_pos}
N -430 3610 -430 3620 {
lab=inh2}
N -400 3610 -400 3620 {
lab=vb_pos}
N -320 3610 -320 3620 {
lab=vlky}
N -140 3600 -140 3610 {
lab=#net14}
N -140 3530 -140 3540 {
lab=p9}
N -140 3850 -140 3860 {
lab=N9}
N -210 3710 -210 3730 {
lab=GND}
N -70 3710 -70 3730 {
lab=vdd_pos}
N -210 3610 -210 3620 {
lab=inh2}
N -180 3610 -180 3620 {
lab=vb_pos}
N -100 3610 -100 3620 {
lab=vlky}
N -2120 -1040 -2120 -1020 {
lab=#net15}
N -2120 -960 -2120 -950 {
lab=#net16}
N -2120 -520 -2120 -500 {
lab=#net17}
N -2120 -440 -2120 -430 {
lab=#net18}
N -1960 -1000 -1960 -990 {
lab=GND}
N -1960 -1110 -1960 -1100 {
lab=vdd_syn1}
N -1900 -920 -1890 -920 {
lab=GND}
N -1900 -890 -1900 -880 {
lab=p1}
N -2020 -1070 -2020 -1060 {
lab=vpres1}
N -1900 -1070 -1900 -1060 {
lab=vpos1}
N -1960 -480 -1960 -470 {
lab=GND}
N -1960 -590 -1960 -580 {
lab=vdd_syn1}
N -1900 -400 -1890 -400 {
lab=GND}
N -1900 -370 -1900 -360 {
lab=p1}
N -2020 -550 -2020 -540 {
lab=vpres2}
N -1900 -550 -1900 -540 {
lab=vpos2}
N -1950 -400 -1940 -400 {
lab=ctrl_pos}
N -1950 -920 -1940 -920 {
lab=ctrl_pos}
N -1900 -1040 -1900 -1020 {
lab=#net19}
N -1900 -960 -1900 -950 {
lab=#net20}
N -1900 -520 -1900 -500 {
lab=#net21}
N -1900 -440 -1900 -430 {
lab=#net22}
N -1740 -1000 -1740 -990 {
lab=GND}
N -1740 -1110 -1740 -1100 {
lab=vdd_syn1}
N -1680 -920 -1670 -920 {
lab=GND}
N -1680 -890 -1680 -880 {
lab=p2}
N -1800 -1070 -1800 -1060 {
lab=vpres1}
N -1680 -1070 -1680 -1060 {
lab=vpos1}
N -1740 -480 -1740 -470 {
lab=GND}
N -1740 -590 -1740 -580 {
lab=vdd_syn1}
N -1680 -400 -1670 -400 {
lab=GND}
N -1680 -370 -1680 -360 {
lab=p2}
N -1800 -550 -1800 -540 {
lab=vpres2}
N -1680 -550 -1680 -540 {
lab=vpos2}
N -1730 -400 -1720 -400 {
lab=ctrl_pos}
N -1730 -920 -1720 -920 {
lab=ctrl_pos}
N -1680 -1040 -1680 -1020 {
lab=#net23}
N -1680 -960 -1680 -950 {
lab=#net24}
N -1680 -520 -1680 -500 {
lab=#net25}
N -1680 -440 -1680 -430 {
lab=#net26}
N -1520 -1000 -1520 -990 {
lab=GND}
N -1520 -1110 -1520 -1100 {
lab=vdd_syn1}
N -1460 -920 -1450 -920 {
lab=GND}
N -1460 -890 -1460 -880 {
lab=p3}
N -1580 -1070 -1580 -1060 {
lab=vpres1}
N -1460 -1070 -1460 -1060 {
lab=vpos1}
N -1520 -480 -1520 -470 {
lab=GND}
N -1520 -590 -1520 -580 {
lab=vdd_syn1}
N -1460 -400 -1450 -400 {
lab=GND}
N -1460 -370 -1460 -360 {
lab=p3}
N -1580 -550 -1580 -540 {
lab=vpres2}
N -1460 -550 -1460 -540 {
lab=vpos2}
N -1510 -400 -1500 -400 {
lab=ctrl_pos}
N -1510 -920 -1500 -920 {
lab=ctrl_pos}
N -1460 -1040 -1460 -1020 {
lab=#net27}
N -1460 -960 -1460 -950 {
lab=#net28}
N -1460 -520 -1460 -500 {
lab=#net29}
N -1460 -440 -1460 -430 {
lab=#net30}
N -1300 -1000 -1300 -990 {
lab=GND}
N -1300 -1110 -1300 -1100 {
lab=vdd_syn1}
N -1240 -920 -1230 -920 {
lab=GND}
N -1240 -890 -1240 -880 {
lab=p4}
N -1360 -1070 -1360 -1060 {
lab=vpres1}
N -1240 -1070 -1240 -1060 {
lab=vpos1}
N -1300 -480 -1300 -470 {
lab=GND}
N -1300 -590 -1300 -580 {
lab=vdd_syn1}
N -1240 -400 -1230 -400 {
lab=GND}
N -1240 -370 -1240 -360 {
lab=p4}
N -1360 -550 -1360 -540 {
lab=vpres2}
N -1240 -550 -1240 -540 {
lab=vpos2}
N -1290 -400 -1280 -400 {
lab=ctrl_pos}
N -1290 -920 -1280 -920 {
lab=ctrl_pos}
N -1240 -1040 -1240 -1020 {
lab=#net31}
N -1240 -960 -1240 -950 {
lab=#net32}
N -1240 -520 -1240 -500 {
lab=#net33}
N -1240 -440 -1240 -430 {
lab=#net34}
N -1080 -1000 -1080 -990 {
lab=GND}
N -1080 -1110 -1080 -1100 {
lab=vdd_syn1}
N -1020 -920 -1010 -920 {
lab=GND}
N -1020 -890 -1020 -880 {
lab=p5}
N -1140 -1070 -1140 -1060 {
lab=vpres1}
N -1020 -1070 -1020 -1060 {
lab=vpos1}
N -1080 -480 -1080 -470 {
lab=GND}
N -1080 -590 -1080 -580 {
lab=vdd_syn1}
N -1020 -400 -1010 -400 {
lab=GND}
N -1020 -370 -1020 -360 {
lab=p5}
N -1140 -550 -1140 -540 {
lab=vpres2}
N -1020 -550 -1020 -540 {
lab=vpos2}
N -1070 -400 -1060 -400 {
lab=ctrl_pos}
N -1070 -920 -1060 -920 {
lab=ctrl_pos}
N -1020 -1040 -1020 -1020 {
lab=#net35}
N -1020 -960 -1020 -950 {
lab=#net36}
N -1020 -520 -1020 -500 {
lab=#net37}
N -1020 -440 -1020 -430 {
lab=#net38}
N -860 -1000 -860 -990 {
lab=GND}
N -860 -1110 -860 -1100 {
lab=vdd_syn1}
N -800 -920 -790 -920 {
lab=GND}
N -800 -890 -800 -880 {
lab=p6}
N -920 -1070 -920 -1060 {
lab=vpres1}
N -800 -1070 -800 -1060 {
lab=vpos1}
N -860 -480 -860 -470 {
lab=GND}
N -860 -590 -860 -580 {
lab=vdd_syn1}
N -800 -400 -790 -400 {
lab=GND}
N -800 -370 -800 -360 {
lab=p6}
N -920 -550 -920 -540 {
lab=vpres2}
N -800 -550 -800 -540 {
lab=vpos2}
N -850 -400 -840 -400 {
lab=ctrl_pos}
N -850 -920 -840 -920 {
lab=ctrl_pos}
N -800 -1040 -800 -1020 {
lab=#net39}
N -800 -960 -800 -950 {
lab=#net40}
N -800 -520 -800 -500 {
lab=#net41}
N -800 -440 -800 -430 {
lab=#net42}
N -640 -1000 -640 -990 {
lab=GND}
N -640 -1110 -640 -1100 {
lab=vdd_syn1}
N -580 -920 -570 -920 {
lab=GND}
N -580 -890 -580 -880 {
lab=p7}
N -700 -1070 -700 -1060 {
lab=vpres1}
N -580 -1070 -580 -1060 {
lab=vpos1}
N -640 -480 -640 -470 {
lab=GND}
N -640 -590 -640 -580 {
lab=vdd_syn1}
N -580 -400 -570 -400 {
lab=GND}
N -580 -370 -580 -360 {
lab=p7}
N -700 -550 -700 -540 {
lab=vpres2}
N -580 -550 -580 -540 {
lab=vpos2}
N -630 -400 -620 -400 {
lab=ctrl_pos}
N -630 -920 -620 -920 {
lab=ctrl_pos}
N -580 -1040 -580 -1020 {
lab=#net43}
N -580 -960 -580 -950 {
lab=#net44}
N -580 -520 -580 -500 {
lab=#net45}
N -580 -440 -580 -430 {
lab=#net46}
N -420 -1000 -420 -990 {
lab=GND}
N -420 -1110 -420 -1100 {
lab=vdd_syn1}
N -360 -920 -350 -920 {
lab=GND}
N -360 -890 -360 -880 {
lab=p8}
N -480 -1070 -480 -1060 {
lab=vpres1}
N -360 -1070 -360 -1060 {
lab=vpos1}
N -420 -480 -420 -470 {
lab=GND}
N -420 -590 -420 -580 {
lab=vdd_syn1}
N -360 -400 -350 -400 {
lab=GND}
N -360 -370 -360 -360 {
lab=p8}
N -480 -550 -480 -540 {
lab=vpres2}
N -360 -550 -360 -540 {
lab=vpos2}
N -410 -400 -400 -400 {
lab=ctrl_pos}
N -410 -920 -400 -920 {
lab=ctrl_pos}
N -360 -1040 -360 -1020 {
lab=#net47}
N -360 -960 -360 -950 {
lab=#net48}
N -360 -520 -360 -500 {
lab=#net49}
N -360 -440 -360 -430 {
lab=#net50}
N -200 -1000 -200 -990 {
lab=GND}
N -200 -1110 -200 -1100 {
lab=vdd_syn1}
N -140 -920 -130 -920 {
lab=GND}
N -140 -890 -140 -880 {
lab=p9}
N -260 -1070 -260 -1060 {
lab=vpres1}
N -140 -1070 -140 -1060 {
lab=vpos1}
N -200 -480 -200 -470 {
lab=GND}
N -200 -590 -200 -580 {
lab=vdd_syn1}
N -140 -400 -130 -400 {
lab=GND}
N -140 -370 -140 -360 {
lab=p9}
N -260 -550 -260 -540 {
lab=vpres2}
N -140 -550 -140 -540 {
lab=vpos2}
N -190 -400 -180 -400 {
lab=ctrl_pos}
N -190 -920 -180 -920 {
lab=ctrl_pos}
N -140 -1040 -140 -1020 {
lab=#net51}
N -140 -960 -140 -950 {
lab=#net52}
N -140 -520 -140 -500 {
lab=#net53}
N -140 -440 -140 -430 {
lab=#net54}
N -2350 -150 -2350 -140 {
lab=GND}
N -2350 190 -2350 200 {
lab=GND}
N -2300 140 -2300 150 {
lab=vpres1}
N -2410 120 -2400 120 {
lab=ctrl1}
N -2350 20 -2350 30 {
lab=GND}
N -2400 -20 -2400 -10 {
lab=vpre1}
N -2410 -60 -2410 -50 {
lab=ctrl2}
N -2410 -50 -2400 -50 {
lab=ctrl2}
N -2410 100 -2410 120 {
lab=ctrl1}
N -2350 -90 -2350 -60 {
lab=vdd_tg}
N -2350 -260 -2350 -230 {
lab=vdd_delay}
N -2350 70 -2350 110 {
lab=vdd_sw}
N -2410 -190 -2410 -180 {
lab=vpre1}
N -2290 -190 -2290 -180 {
lab=vpos1}
N -2300 -30 -2300 -20 {
lab=vpres1}
N -2410 150 -2400 150 {
lab=uw}
N -2410 180 -2400 180 {
lab=vbias}
N -2350 370 -2350 380 {
lab=GND}
N -2350 710 -2350 720 {
lab=GND}
N -2300 660 -2300 670 {
lab=vpres1}
N -2410 640 -2400 640 {
lab=ctrl1}
N -2350 540 -2350 550 {
lab=GND}
N -2400 500 -2400 510 {
lab=vpre1}
N -2410 460 -2410 470 {
lab=ctrl2}
N -2410 470 -2400 470 {
lab=ctrl2}
N -2410 620 -2410 640 {
lab=ctrl1}
N -2350 430 -2350 460 {
lab=vdd_tg}
N -2350 260 -2350 290 {
lab=vdd_delay}
N -2350 590 -2350 630 {
lab=vdd_sw}
N -2410 330 -2410 340 {
lab=vpre1}
N -2290 330 -2290 340 {
lab=vpos1}
N -2300 490 -2300 500 {
lab=vpres1}
N -2410 670 -2400 670 {
lab=uw}
N -2410 700 -2400 700 {
lab=vbias}
N -2350 890 -2350 900 {
lab=GND}
N -2350 1230 -2350 1240 {
lab=GND}
N -2300 1180 -2300 1190 {
lab=vpres1}
N -2410 1160 -2400 1160 {
lab=ctrl1}
N -2350 1060 -2350 1070 {
lab=GND}
N -2400 1020 -2400 1030 {
lab=vpre1}
N -2410 980 -2410 990 {
lab=ctrl2}
N -2410 990 -2400 990 {
lab=ctrl2}
N -2410 1140 -2410 1160 {
lab=ctrl1}
N -2350 950 -2350 980 {
lab=vdd_tg}
N -2350 780 -2350 810 {
lab=vdd_delay}
N -2350 1110 -2350 1150 {
lab=vdd_sw}
N -2410 850 -2410 860 {
lab=vpre1}
N -2290 850 -2290 860 {
lab=vpos1}
N -2300 1010 -2300 1020 {
lab=vpres1}
N -2410 1190 -2400 1190 {
lab=uw}
N -2410 1220 -2400 1220 {
lab=vbias}
N -2350 1410 -2350 1420 {
lab=GND}
N -2350 1750 -2350 1760 {
lab=GND}
N -2300 1700 -2300 1710 {
lab=vpres1}
N -2410 1680 -2400 1680 {
lab=ctrl1}
N -2350 1580 -2350 1590 {
lab=GND}
N -2400 1540 -2400 1550 {
lab=vpre1}
N -2410 1500 -2410 1510 {
lab=ctrl2}
N -2410 1510 -2400 1510 {
lab=ctrl2}
N -2410 1660 -2410 1680 {
lab=ctrl1}
N -2350 1470 -2350 1500 {
lab=vdd_tg}
N -2350 1300 -2350 1330 {
lab=vdd_delay}
N -2350 1630 -2350 1670 {
lab=vdd_sw}
N -2410 1370 -2410 1380 {
lab=vpre1}
N -2290 1370 -2290 1380 {
lab=vpos1}
N -2300 1530 -2300 1540 {
lab=vpres1}
N -2410 1710 -2400 1710 {
lab=uw}
N -2410 1740 -2400 1740 {
lab=vbias}
N -2350 1930 -2350 1940 {
lab=GND}
N -2350 2270 -2350 2280 {
lab=GND}
N -2300 2220 -2300 2230 {
lab=vpres1}
N -2410 2200 -2400 2200 {
lab=ctrl1}
N -2350 2100 -2350 2110 {
lab=GND}
N -2400 2060 -2400 2070 {
lab=vpre1}
N -2410 2020 -2410 2030 {
lab=ctrl2}
N -2410 2030 -2400 2030 {
lab=ctrl2}
N -2410 2180 -2410 2200 {
lab=ctrl1}
N -2350 1990 -2350 2020 {
lab=vdd_tg}
N -2350 1820 -2350 1850 {
lab=vdd_delay}
N -2350 2150 -2350 2190 {
lab=vdd_sw}
N -2410 1890 -2410 1900 {
lab=vpre1}
N -2290 1890 -2290 1900 {
lab=vpos1}
N -2300 2050 -2300 2060 {
lab=vpres1}
N -2410 2230 -2400 2230 {
lab=uw}
N -2410 2260 -2400 2260 {
lab=vbias}
N -2350 2450 -2350 2460 {
lab=GND}
N -2350 2790 -2350 2800 {
lab=GND}
N -2300 2740 -2300 2750 {
lab=vpres1}
N -2410 2720 -2400 2720 {
lab=ctrl1}
N -2350 2620 -2350 2630 {
lab=GND}
N -2400 2580 -2400 2590 {
lab=vpre1}
N -2410 2540 -2410 2550 {
lab=ctrl2}
N -2410 2550 -2400 2550 {
lab=ctrl2}
N -2410 2700 -2410 2720 {
lab=ctrl1}
N -2350 2510 -2350 2540 {
lab=vdd_tg}
N -2350 2340 -2350 2370 {
lab=vdd_delay}
N -2350 2670 -2350 2710 {
lab=vdd_sw}
N -2410 2410 -2410 2420 {
lab=vpre1}
N -2290 2410 -2290 2420 {
lab=vpos1}
N -2300 2570 -2300 2580 {
lab=vpres1}
N -2410 2750 -2400 2750 {
lab=uw}
N -2410 2780 -2400 2780 {
lab=vbias}
N -2350 2970 -2350 2980 {
lab=GND}
N -2350 3310 -2350 3320 {
lab=GND}
N -2300 3260 -2300 3270 {
lab=vpres1}
N -2410 3240 -2400 3240 {
lab=ctrl1}
N -2350 3140 -2350 3150 {
lab=GND}
N -2400 3100 -2400 3110 {
lab=vpre1}
N -2410 3060 -2410 3070 {
lab=ctrl2}
N -2410 3070 -2400 3070 {
lab=ctrl2}
N -2410 3220 -2410 3240 {
lab=ctrl1}
N -2350 3030 -2350 3060 {
lab=vdd_tg}
N -2350 2860 -2350 2890 {
lab=vdd_delay}
N -2350 3190 -2350 3230 {
lab=vdd_sw}
N -2410 2930 -2410 2940 {
lab=vpre1}
N -2290 2930 -2290 2940 {
lab=vpos1}
N -2300 3090 -2300 3100 {
lab=vpres1}
N -2410 3270 -2400 3270 {
lab=uw}
N -2410 3300 -2400 3300 {
lab=vbias}
N -2180 40 -2180 50 {
lab=GND}
N -2180 -70 -2180 -60 {
lab=vdd_syn1}
N -2120 120 -2110 120 {
lab=GND}
N -2120 150 -2120 160 {
lab=p0}
N -2240 -30 -2240 -20 {
lab=vpres2}
N -2120 -30 -2120 -20 {
lab=vpos2}
N -2170 120 -2160 120 {
lab=ctrl_pos}
N -2120 0 -2120 20 {
lab=#net55}
N -2120 80 -2120 90 {
lab=#net56}
N -1960 40 -1960 50 {
lab=GND}
N -1960 -70 -1960 -60 {
lab=vdd_syn1}
N -1900 120 -1890 120 {
lab=GND}
N -1900 150 -1900 160 {
lab=p1}
N -2020 -30 -2020 -20 {
lab=vpres2}
N -1900 -30 -1900 -20 {
lab=vpos2}
N -1950 120 -1940 120 {
lab=ctrl_pos}
N -1900 0 -1900 20 {
lab=#net57}
N -1900 80 -1900 90 {
lab=#net58}
N -1740 40 -1740 50 {
lab=GND}
N -1740 -70 -1740 -60 {
lab=vdd_syn1}
N -1680 120 -1670 120 {
lab=GND}
N -1680 150 -1680 160 {
lab=p2}
N -1800 -30 -1800 -20 {
lab=vpres2}
N -1680 -30 -1680 -20 {
lab=vpos2}
N -1730 120 -1720 120 {
lab=ctrl_pos}
N -1680 0 -1680 20 {
lab=#net59}
N -1680 80 -1680 90 {
lab=#net60}
N -1520 40 -1520 50 {
lab=GND}
N -1520 -70 -1520 -60 {
lab=vdd_syn1}
N -1460 120 -1450 120 {
lab=GND}
N -1460 150 -1460 160 {
lab=p3}
N -1580 -30 -1580 -20 {
lab=vpres2}
N -1460 -30 -1460 -20 {
lab=vpos2}
N -1510 120 -1500 120 {
lab=ctrl_pos}
N -1460 0 -1460 20 {
lab=#net61}
N -1460 80 -1460 90 {
lab=#net62}
N -1300 40 -1300 50 {
lab=GND}
N -1300 -70 -1300 -60 {
lab=vdd_syn1}
N -1240 120 -1230 120 {
lab=GND}
N -1240 150 -1240 160 {
lab=p4}
N -1360 -30 -1360 -20 {
lab=vpres2}
N -1240 -30 -1240 -20 {
lab=vpos2}
N -1290 120 -1280 120 {
lab=ctrl_pos}
N -1240 0 -1240 20 {
lab=#net63}
N -1240 80 -1240 90 {
lab=#net64}
N -1080 40 -1080 50 {
lab=GND}
N -1080 -70 -1080 -60 {
lab=vdd_syn1}
N -1020 120 -1010 120 {
lab=GND}
N -1020 150 -1020 160 {
lab=p5}
N -1140 -30 -1140 -20 {
lab=vpres2}
N -1020 -30 -1020 -20 {
lab=vpos2}
N -1070 120 -1060 120 {
lab=ctrl_pos}
N -1020 0 -1020 20 {
lab=#net65}
N -1020 80 -1020 90 {
lab=#net66}
N -860 40 -860 50 {
lab=GND}
N -860 -70 -860 -60 {
lab=vdd_syn1}
N -800 120 -790 120 {
lab=GND}
N -800 150 -800 160 {
lab=p6}
N -920 -30 -920 -20 {
lab=vpres2}
N -800 -30 -800 -20 {
lab=vpos2}
N -850 120 -840 120 {
lab=ctrl_pos}
N -800 0 -800 20 {
lab=#net67}
N -800 80 -800 90 {
lab=#net68}
N -640 40 -640 50 {
lab=GND}
N -640 -70 -640 -60 {
lab=vdd_syn1}
N -580 120 -570 120 {
lab=GND}
N -580 150 -580 160 {
lab=p7}
N -700 -30 -700 -20 {
lab=vpres2}
N -580 -30 -580 -20 {
lab=vpos2}
N -630 120 -620 120 {
lab=ctrl_pos}
N -580 0 -580 20 {
lab=#net69}
N -580 80 -580 90 {
lab=#net70}
N -420 40 -420 50 {
lab=GND}
N -420 -70 -420 -60 {
lab=vdd_syn1}
N -360 120 -350 120 {
lab=GND}
N -360 150 -360 160 {
lab=p8}
N -480 -30 -480 -20 {
lab=vpres2}
N -360 -30 -360 -20 {
lab=vpos2}
N -410 120 -400 120 {
lab=ctrl_pos}
N -360 0 -360 20 {
lab=#net71}
N -360 80 -360 90 {
lab=#net72}
N -200 40 -200 50 {
lab=GND}
N -200 -70 -200 -60 {
lab=vdd_syn1}
N -140 120 -130 120 {
lab=GND}
N -140 150 -140 160 {
lab=p9}
N -260 -30 -260 -20 {
lab=vpres2}
N -140 -30 -140 -20 {
lab=vpos2}
N -190 120 -180 120 {
lab=ctrl_pos}
N -140 0 -140 20 {
lab=#net73}
N -140 80 -140 90 {
lab=#net74}
N -2180 560 -2180 570 {
lab=GND}
N -2180 450 -2180 460 {
lab=vdd_syn1}
N -2120 640 -2110 640 {
lab=GND}
N -2120 670 -2120 680 {
lab=p0}
N -2240 490 -2240 500 {
lab=vpres2}
N -2120 490 -2120 500 {
lab=vpos2}
N -2170 640 -2160 640 {
lab=ctrl_pos}
N -2120 520 -2120 540 {
lab=#net75}
N -2120 600 -2120 610 {
lab=#net76}
N -1960 560 -1960 570 {
lab=GND}
N -1960 450 -1960 460 {
lab=vdd_syn1}
N -1900 640 -1890 640 {
lab=GND}
N -1900 670 -1900 680 {
lab=p1}
N -2020 490 -2020 500 {
lab=vpres2}
N -1900 490 -1900 500 {
lab=vpos2}
N -1950 640 -1940 640 {
lab=ctrl_pos}
N -1900 520 -1900 540 {
lab=#net77}
N -1900 600 -1900 610 {
lab=#net78}
N -1740 560 -1740 570 {
lab=GND}
N -1740 450 -1740 460 {
lab=vdd_syn1}
N -1680 640 -1670 640 {
lab=GND}
N -1680 670 -1680 680 {
lab=p2}
N -1800 490 -1800 500 {
lab=vpres2}
N -1680 490 -1680 500 {
lab=vpos2}
N -1730 640 -1720 640 {
lab=ctrl_pos}
N -1680 520 -1680 540 {
lab=#net79}
N -1680 600 -1680 610 {
lab=#net80}
N -1520 560 -1520 570 {
lab=GND}
N -1520 450 -1520 460 {
lab=vdd_syn1}
N -1460 640 -1450 640 {
lab=GND}
N -1460 670 -1460 680 {
lab=p3}
N -1580 490 -1580 500 {
lab=vpres2}
N -1460 490 -1460 500 {
lab=vpos2}
N -1510 640 -1500 640 {
lab=ctrl_pos}
N -1460 520 -1460 540 {
lab=#net81}
N -1460 600 -1460 610 {
lab=#net82}
N -1300 560 -1300 570 {
lab=GND}
N -1300 450 -1300 460 {
lab=vdd_syn1}
N -1240 640 -1230 640 {
lab=GND}
N -1240 670 -1240 680 {
lab=p4}
N -1360 490 -1360 500 {
lab=vpres2}
N -1240 490 -1240 500 {
lab=vpos2}
N -1290 640 -1280 640 {
lab=ctrl_pos}
N -1240 520 -1240 540 {
lab=#net83}
N -1240 600 -1240 610 {
lab=#net84}
N -1080 560 -1080 570 {
lab=GND}
N -1080 450 -1080 460 {
lab=vdd_syn1}
N -1020 640 -1010 640 {
lab=GND}
N -1020 670 -1020 680 {
lab=p5}
N -1140 490 -1140 500 {
lab=vpres2}
N -1020 490 -1020 500 {
lab=vpos2}
N -1070 640 -1060 640 {
lab=ctrl_pos}
N -1020 520 -1020 540 {
lab=#net85}
N -1020 600 -1020 610 {
lab=#net86}
N -860 560 -860 570 {
lab=GND}
N -860 450 -860 460 {
lab=vdd_syn1}
N -800 640 -790 640 {
lab=GND}
N -800 670 -800 680 {
lab=p6}
N -920 490 -920 500 {
lab=vpres2}
N -800 490 -800 500 {
lab=vpos2}
N -850 640 -840 640 {
lab=ctrl_pos}
N -800 520 -800 540 {
lab=#net87}
N -800 600 -800 610 {
lab=#net88}
N -640 560 -640 570 {
lab=GND}
N -640 450 -640 460 {
lab=vdd_syn1}
N -580 640 -570 640 {
lab=GND}
N -580 670 -580 680 {
lab=p7}
N -700 490 -700 500 {
lab=vpres2}
N -580 490 -580 500 {
lab=vpos2}
N -630 640 -620 640 {
lab=ctrl_pos}
N -580 520 -580 540 {
lab=#net89}
N -580 600 -580 610 {
lab=#net90}
N -420 560 -420 570 {
lab=GND}
N -420 450 -420 460 {
lab=vdd_syn1}
N -360 640 -350 640 {
lab=GND}
N -360 670 -360 680 {
lab=p8}
N -480 490 -480 500 {
lab=vpres2}
N -360 490 -360 500 {
lab=vpos2}
N -410 640 -400 640 {
lab=ctrl_pos}
N -360 520 -360 540 {
lab=#net91}
N -360 600 -360 610 {
lab=#net92}
N -200 560 -200 570 {
lab=GND}
N -200 450 -200 460 {
lab=vdd_syn1}
N -140 640 -130 640 {
lab=GND}
N -140 670 -140 680 {
lab=p9}
N -260 490 -260 500 {
lab=vpres2}
N -140 490 -140 500 {
lab=vpos2}
N -190 640 -180 640 {
lab=ctrl_pos}
N -140 520 -140 540 {
lab=#net93}
N -140 600 -140 610 {
lab=#net94}
N -2180 1080 -2180 1090 {
lab=GND}
N -2180 970 -2180 980 {
lab=vdd_syn1}
N -2120 1160 -2110 1160 {
lab=GND}
N -2120 1190 -2120 1200 {
lab=p0}
N -2240 1010 -2240 1020 {
lab=vpres2}
N -2120 1010 -2120 1020 {
lab=vpos2}
N -2170 1160 -2160 1160 {
lab=ctrl_pos}
N -2120 1040 -2120 1060 {
lab=#net95}
N -2120 1120 -2120 1130 {
lab=#net96}
N -1960 1080 -1960 1090 {
lab=GND}
N -1960 970 -1960 980 {
lab=vdd_syn1}
N -1900 1160 -1890 1160 {
lab=GND}
N -1900 1190 -1900 1200 {
lab=p1}
N -2020 1010 -2020 1020 {
lab=vpres2}
N -1900 1010 -1900 1020 {
lab=vpos2}
N -1950 1160 -1940 1160 {
lab=ctrl_pos}
N -1900 1040 -1900 1060 {
lab=#net97}
N -1900 1120 -1900 1130 {
lab=#net98}
N -1740 1080 -1740 1090 {
lab=GND}
N -1740 970 -1740 980 {
lab=vdd_syn1}
N -1680 1160 -1670 1160 {
lab=GND}
N -1680 1190 -1680 1200 {
lab=p2}
N -1800 1010 -1800 1020 {
lab=vpres2}
N -1680 1010 -1680 1020 {
lab=vpos2}
N -1730 1160 -1720 1160 {
lab=ctrl_pos}
N -1680 1040 -1680 1060 {
lab=#net99}
N -1680 1120 -1680 1130 {
lab=#net100}
N -1520 1080 -1520 1090 {
lab=GND}
N -1520 970 -1520 980 {
lab=vdd_syn1}
N -1460 1160 -1450 1160 {
lab=GND}
N -1460 1190 -1460 1200 {
lab=p3}
N -1580 1010 -1580 1020 {
lab=vpres2}
N -1460 1010 -1460 1020 {
lab=vpos2}
N -1510 1160 -1500 1160 {
lab=ctrl_pos}
N -1460 1040 -1460 1060 {
lab=#net101}
N -1460 1120 -1460 1130 {
lab=#net102}
N -1300 1080 -1300 1090 {
lab=GND}
N -1300 970 -1300 980 {
lab=vdd_syn1}
N -1240 1160 -1230 1160 {
lab=GND}
N -1240 1190 -1240 1200 {
lab=p4}
N -1360 1010 -1360 1020 {
lab=vpres2}
N -1240 1010 -1240 1020 {
lab=vpos2}
N -1290 1160 -1280 1160 {
lab=ctrl_pos}
N -1240 1040 -1240 1060 {
lab=#net103}
N -1240 1120 -1240 1130 {
lab=#net104}
N -1080 1080 -1080 1090 {
lab=GND}
N -1080 970 -1080 980 {
lab=vdd_syn1}
N -1020 1160 -1010 1160 {
lab=GND}
N -1020 1190 -1020 1200 {
lab=p5}
N -1140 1010 -1140 1020 {
lab=vpres2}
N -1020 1010 -1020 1020 {
lab=vpos2}
N -1070 1160 -1060 1160 {
lab=ctrl_pos}
N -1020 1040 -1020 1060 {
lab=#net105}
N -1020 1120 -1020 1130 {
lab=#net106}
N -860 1080 -860 1090 {
lab=GND}
N -860 970 -860 980 {
lab=vdd_syn1}
N -800 1160 -790 1160 {
lab=GND}
N -800 1190 -800 1200 {
lab=p6}
N -920 1010 -920 1020 {
lab=vpres2}
N -800 1010 -800 1020 {
lab=vpos2}
N -850 1160 -840 1160 {
lab=ctrl_pos}
N -800 1040 -800 1060 {
lab=#net107}
N -800 1120 -800 1130 {
lab=#net108}
N -640 1080 -640 1090 {
lab=GND}
N -640 970 -640 980 {
lab=vdd_syn1}
N -580 1160 -570 1160 {
lab=GND}
N -580 1190 -580 1200 {
lab=p7}
N -700 1010 -700 1020 {
lab=vpres2}
N -580 1010 -580 1020 {
lab=vpos2}
N -630 1160 -620 1160 {
lab=ctrl_pos}
N -580 1040 -580 1060 {
lab=#net109}
N -580 1120 -580 1130 {
lab=#net110}
N -420 1080 -420 1090 {
lab=GND}
N -420 970 -420 980 {
lab=vdd_syn1}
N -360 1160 -350 1160 {
lab=GND}
N -360 1190 -360 1200 {
lab=p8}
N -480 1010 -480 1020 {
lab=vpres2}
N -360 1010 -360 1020 {
lab=vpos2}
N -410 1160 -400 1160 {
lab=ctrl_pos}
N -360 1040 -360 1060 {
lab=#net111}
N -360 1120 -360 1130 {
lab=#net112}
N -200 1080 -200 1090 {
lab=GND}
N -200 970 -200 980 {
lab=vdd_syn1}
N -140 1160 -130 1160 {
lab=GND}
N -140 1190 -140 1200 {
lab=p9}
N -260 1010 -260 1020 {
lab=vpres2}
N -140 1010 -140 1020 {
lab=vpos2}
N -190 1160 -180 1160 {
lab=ctrl_pos}
N -140 1040 -140 1060 {
lab=#net113}
N -140 1120 -140 1130 {
lab=#net114}
N -2180 1600 -2180 1610 {
lab=GND}
N -2180 1490 -2180 1500 {
lab=vdd_syn1}
N -2120 1680 -2110 1680 {
lab=GND}
N -2120 1710 -2120 1720 {
lab=p0}
N -2240 1530 -2240 1540 {
lab=vpres2}
N -2120 1530 -2120 1540 {
lab=vpos2}
N -2170 1680 -2160 1680 {
lab=ctrl_pos}
N -2120 1560 -2120 1580 {
lab=#net115}
N -2120 1640 -2120 1650 {
lab=#net116}
N -1960 1600 -1960 1610 {
lab=GND}
N -1960 1490 -1960 1500 {
lab=vdd_syn1}
N -1900 1680 -1890 1680 {
lab=GND}
N -1900 1710 -1900 1720 {
lab=p1}
N -2020 1530 -2020 1540 {
lab=vpres2}
N -1900 1530 -1900 1540 {
lab=vpos2}
N -1950 1680 -1940 1680 {
lab=ctrl_pos}
N -1900 1560 -1900 1580 {
lab=#net117}
N -1900 1640 -1900 1650 {
lab=#net118}
N -1740 1600 -1740 1610 {
lab=GND}
N -1740 1490 -1740 1500 {
lab=vdd_syn1}
N -1680 1680 -1670 1680 {
lab=GND}
N -1680 1710 -1680 1720 {
lab=p2}
N -1800 1530 -1800 1540 {
lab=vpres2}
N -1680 1530 -1680 1540 {
lab=vpos2}
N -1730 1680 -1720 1680 {
lab=ctrl_pos}
N -1680 1560 -1680 1580 {
lab=#net119}
N -1680 1640 -1680 1650 {
lab=#net120}
N -1520 1600 -1520 1610 {
lab=GND}
N -1520 1490 -1520 1500 {
lab=vdd_syn1}
N -1460 1680 -1450 1680 {
lab=GND}
N -1460 1710 -1460 1720 {
lab=p3}
N -1580 1530 -1580 1540 {
lab=vpres2}
N -1460 1530 -1460 1540 {
lab=vpos2}
N -1510 1680 -1500 1680 {
lab=ctrl_pos}
N -1460 1560 -1460 1580 {
lab=#net121}
N -1460 1640 -1460 1650 {
lab=#net122}
N -1300 1600 -1300 1610 {
lab=GND}
N -1300 1490 -1300 1500 {
lab=vdd_syn1}
N -1240 1680 -1230 1680 {
lab=GND}
N -1240 1710 -1240 1720 {
lab=p4}
N -1360 1530 -1360 1540 {
lab=vpres2}
N -1240 1530 -1240 1540 {
lab=vpos2}
N -1290 1680 -1280 1680 {
lab=ctrl_pos}
N -1240 1560 -1240 1580 {
lab=#net123}
N -1240 1640 -1240 1650 {
lab=#net124}
N -1080 1600 -1080 1610 {
lab=GND}
N -1080 1490 -1080 1500 {
lab=vdd_syn1}
N -1020 1680 -1010 1680 {
lab=GND}
N -1020 1710 -1020 1720 {
lab=p5}
N -1140 1530 -1140 1540 {
lab=vpres2}
N -1020 1530 -1020 1540 {
lab=vpos2}
N -1070 1680 -1060 1680 {
lab=ctrl_pos}
N -1020 1560 -1020 1580 {
lab=#net125}
N -1020 1640 -1020 1650 {
lab=#net126}
N -860 1600 -860 1610 {
lab=GND}
N -860 1490 -860 1500 {
lab=vdd_syn1}
N -800 1680 -790 1680 {
lab=GND}
N -800 1710 -800 1720 {
lab=p6}
N -920 1530 -920 1540 {
lab=vpres2}
N -800 1530 -800 1540 {
lab=vpos2}
N -850 1680 -840 1680 {
lab=ctrl_pos}
N -800 1560 -800 1580 {
lab=#net127}
N -800 1640 -800 1650 {
lab=#net128}
N -640 1600 -640 1610 {
lab=GND}
N -640 1490 -640 1500 {
lab=vdd_syn1}
N -580 1680 -570 1680 {
lab=GND}
N -580 1710 -580 1720 {
lab=p7}
N -700 1530 -700 1540 {
lab=vpres2}
N -580 1530 -580 1540 {
lab=vpos2}
N -630 1680 -620 1680 {
lab=ctrl_pos}
N -580 1560 -580 1580 {
lab=#net129}
N -580 1640 -580 1650 {
lab=#net130}
N -420 1600 -420 1610 {
lab=GND}
N -420 1490 -420 1500 {
lab=vdd_syn1}
N -360 1680 -350 1680 {
lab=GND}
N -360 1710 -360 1720 {
lab=p8}
N -480 1530 -480 1540 {
lab=vpres2}
N -360 1530 -360 1540 {
lab=vpos2}
N -410 1680 -400 1680 {
lab=ctrl_pos}
N -360 1560 -360 1580 {
lab=#net131}
N -360 1640 -360 1650 {
lab=#net132}
N -200 1600 -200 1610 {
lab=GND}
N -200 1490 -200 1500 {
lab=vdd_syn1}
N -140 1680 -130 1680 {
lab=GND}
N -140 1710 -140 1720 {
lab=p9}
N -260 1530 -260 1540 {
lab=vpres2}
N -140 1530 -140 1540 {
lab=vpos2}
N -190 1680 -180 1680 {
lab=ctrl_pos}
N -140 1560 -140 1580 {
lab=#net133}
N -140 1640 -140 1650 {
lab=#net134}
N -2180 2120 -2180 2130 {
lab=GND}
N -2180 2010 -2180 2020 {
lab=vdd_syn1}
N -2120 2200 -2110 2200 {
lab=GND}
N -2120 2230 -2120 2240 {
lab=p0}
N -2240 2050 -2240 2060 {
lab=vpres2}
N -2120 2050 -2120 2060 {
lab=vpos2}
N -2170 2200 -2160 2200 {
lab=ctrl_pos}
N -2120 2080 -2120 2100 {
lab=#net135}
N -2120 2160 -2120 2170 {
lab=#net136}
N -1960 2120 -1960 2130 {
lab=GND}
N -1960 2010 -1960 2020 {
lab=vdd_syn1}
N -1900 2200 -1890 2200 {
lab=GND}
N -1900 2230 -1900 2240 {
lab=p1}
N -2020 2050 -2020 2060 {
lab=vpres2}
N -1900 2050 -1900 2060 {
lab=vpos2}
N -1950 2200 -1940 2200 {
lab=ctrl_pos}
N -1900 2080 -1900 2100 {
lab=#net137}
N -1900 2160 -1900 2170 {
lab=#net138}
N -1740 2120 -1740 2130 {
lab=GND}
N -1740 2010 -1740 2020 {
lab=vdd_syn1}
N -1680 2200 -1670 2200 {
lab=GND}
N -1680 2230 -1680 2240 {
lab=p2}
N -1800 2050 -1800 2060 {
lab=vpres2}
N -1680 2050 -1680 2060 {
lab=vpos2}
N -1730 2200 -1720 2200 {
lab=ctrl_pos}
N -1680 2080 -1680 2100 {
lab=#net139}
N -1680 2160 -1680 2170 {
lab=#net140}
N -1520 2120 -1520 2130 {
lab=GND}
N -1520 2010 -1520 2020 {
lab=vdd_syn1}
N -1460 2200 -1450 2200 {
lab=GND}
N -1460 2230 -1460 2240 {
lab=p3}
N -1580 2050 -1580 2060 {
lab=vpres2}
N -1460 2050 -1460 2060 {
lab=vpos2}
N -1510 2200 -1500 2200 {
lab=ctrl_pos}
N -1460 2080 -1460 2100 {
lab=#net141}
N -1460 2160 -1460 2170 {
lab=#net142}
N -1300 2120 -1300 2130 {
lab=GND}
N -1300 2010 -1300 2020 {
lab=vdd_syn1}
N -1240 2200 -1230 2200 {
lab=GND}
N -1240 2230 -1240 2240 {
lab=p4}
N -1360 2050 -1360 2060 {
lab=vpres2}
N -1240 2050 -1240 2060 {
lab=vpos2}
N -1290 2200 -1280 2200 {
lab=ctrl_pos}
N -1240 2080 -1240 2100 {
lab=#net143}
N -1240 2160 -1240 2170 {
lab=#net144}
N -1080 2120 -1080 2130 {
lab=GND}
N -1080 2010 -1080 2020 {
lab=vdd_syn1}
N -1020 2200 -1010 2200 {
lab=GND}
N -1020 2230 -1020 2240 {
lab=p5}
N -1140 2050 -1140 2060 {
lab=vpres2}
N -1020 2050 -1020 2060 {
lab=vpos2}
N -1070 2200 -1060 2200 {
lab=ctrl_pos}
N -1020 2080 -1020 2100 {
lab=#net145}
N -1020 2160 -1020 2170 {
lab=#net146}
N -860 2120 -860 2130 {
lab=GND}
N -860 2010 -860 2020 {
lab=vdd_syn1}
N -800 2200 -790 2200 {
lab=GND}
N -800 2230 -800 2240 {
lab=p6}
N -920 2050 -920 2060 {
lab=vpres2}
N -800 2050 -800 2060 {
lab=vpos2}
N -850 2200 -840 2200 {
lab=ctrl_pos}
N -800 2080 -800 2100 {
lab=#net147}
N -800 2160 -800 2170 {
lab=#net148}
N -640 2120 -640 2130 {
lab=GND}
N -640 2010 -640 2020 {
lab=vdd_syn1}
N -580 2200 -570 2200 {
lab=GND}
N -580 2230 -580 2240 {
lab=p7}
N -700 2050 -700 2060 {
lab=vpres2}
N -580 2050 -580 2060 {
lab=vpos2}
N -630 2200 -620 2200 {
lab=ctrl_pos}
N -580 2080 -580 2100 {
lab=#net149}
N -580 2160 -580 2170 {
lab=#net150}
N -420 2120 -420 2130 {
lab=GND}
N -420 2010 -420 2020 {
lab=vdd_syn1}
N -360 2200 -350 2200 {
lab=GND}
N -360 2230 -360 2240 {
lab=p8}
N -480 2050 -480 2060 {
lab=vpres2}
N -360 2050 -360 2060 {
lab=vpos2}
N -410 2200 -400 2200 {
lab=ctrl_pos}
N -360 2080 -360 2100 {
lab=#net151}
N -360 2160 -360 2170 {
lab=#net152}
N -200 2120 -200 2130 {
lab=GND}
N -200 2010 -200 2020 {
lab=vdd_syn1}
N -140 2200 -130 2200 {
lab=GND}
N -140 2230 -140 2240 {
lab=p9}
N -260 2050 -260 2060 {
lab=vpres2}
N -140 2050 -140 2060 {
lab=vpos2}
N -190 2200 -180 2200 {
lab=ctrl_pos}
N -140 2080 -140 2100 {
lab=#net153}
N -140 2160 -140 2170 {
lab=#net154}
N -2180 2640 -2180 2650 {
lab=GND}
N -2180 2530 -2180 2540 {
lab=vdd_syn1}
N -2120 2720 -2110 2720 {
lab=GND}
N -2120 2750 -2120 2760 {
lab=p0}
N -2240 2570 -2240 2580 {
lab=vpres2}
N -2120 2570 -2120 2580 {
lab=vpos2}
N -2170 2720 -2160 2720 {
lab=ctrl_pos}
N -2120 2600 -2120 2620 {
lab=#net155}
N -2120 2680 -2120 2690 {
lab=#net156}
N -1960 2640 -1960 2650 {
lab=GND}
N -1960 2530 -1960 2540 {
lab=vdd_syn1}
N -1900 2720 -1890 2720 {
lab=GND}
N -1900 2750 -1900 2760 {
lab=p1}
N -2020 2570 -2020 2580 {
lab=vpres2}
N -1900 2570 -1900 2580 {
lab=vpos2}
N -1950 2720 -1940 2720 {
lab=ctrl_pos}
N -1900 2600 -1900 2620 {
lab=#net157}
N -1900 2680 -1900 2690 {
lab=#net158}
N -1740 2640 -1740 2650 {
lab=GND}
N -1740 2530 -1740 2540 {
lab=vdd_syn1}
N -1680 2720 -1670 2720 {
lab=GND}
N -1680 2750 -1680 2760 {
lab=p2}
N -1800 2570 -1800 2580 {
lab=vpres2}
N -1680 2570 -1680 2580 {
lab=vpos2}
N -1730 2720 -1720 2720 {
lab=ctrl_pos}
N -1680 2600 -1680 2620 {
lab=#net159}
N -1680 2680 -1680 2690 {
lab=#net160}
N -1520 2640 -1520 2650 {
lab=GND}
N -1520 2530 -1520 2540 {
lab=vdd_syn1}
N -1460 2720 -1450 2720 {
lab=GND}
N -1460 2750 -1460 2760 {
lab=p3}
N -1580 2570 -1580 2580 {
lab=vpres2}
N -1460 2570 -1460 2580 {
lab=vpos2}
N -1510 2720 -1500 2720 {
lab=ctrl_pos}
N -1460 2600 -1460 2620 {
lab=#net161}
N -1460 2680 -1460 2690 {
lab=#net162}
N -1300 2640 -1300 2650 {
lab=GND}
N -1300 2530 -1300 2540 {
lab=vdd_syn1}
N -1240 2720 -1230 2720 {
lab=GND}
N -1240 2750 -1240 2760 {
lab=p4}
N -1360 2570 -1360 2580 {
lab=vpres2}
N -1240 2570 -1240 2580 {
lab=vpos2}
N -1290 2720 -1280 2720 {
lab=ctrl_pos}
N -1240 2600 -1240 2620 {
lab=#net163}
N -1240 2680 -1240 2690 {
lab=#net164}
N -1080 2640 -1080 2650 {
lab=GND}
N -1080 2530 -1080 2540 {
lab=vdd_syn1}
N -1020 2720 -1010 2720 {
lab=GND}
N -1020 2750 -1020 2760 {
lab=p5}
N -1140 2570 -1140 2580 {
lab=vpres2}
N -1020 2570 -1020 2580 {
lab=vpos2}
N -1070 2720 -1060 2720 {
lab=ctrl_pos}
N -1020 2600 -1020 2620 {
lab=#net165}
N -1020 2680 -1020 2690 {
lab=#net166}
N -860 2640 -860 2650 {
lab=GND}
N -860 2530 -860 2540 {
lab=vdd_syn1}
N -800 2720 -790 2720 {
lab=GND}
N -800 2750 -800 2760 {
lab=p6}
N -920 2570 -920 2580 {
lab=vpres2}
N -800 2570 -800 2580 {
lab=vpos2}
N -850 2720 -840 2720 {
lab=ctrl_pos}
N -800 2600 -800 2620 {
lab=#net167}
N -800 2680 -800 2690 {
lab=#net168}
N -640 2640 -640 2650 {
lab=GND}
N -640 2530 -640 2540 {
lab=vdd_syn1}
N -580 2720 -570 2720 {
lab=GND}
N -580 2750 -580 2760 {
lab=p7}
N -700 2570 -700 2580 {
lab=vpres2}
N -580 2570 -580 2580 {
lab=vpos2}
N -630 2720 -620 2720 {
lab=ctrl_pos}
N -580 2600 -580 2620 {
lab=#net169}
N -580 2680 -580 2690 {
lab=#net170}
N -420 2640 -420 2650 {
lab=GND}
N -420 2530 -420 2540 {
lab=vdd_syn1}
N -360 2720 -350 2720 {
lab=GND}
N -360 2750 -360 2760 {
lab=p8}
N -480 2570 -480 2580 {
lab=vpres2}
N -360 2570 -360 2580 {
lab=vpos2}
N -410 2720 -400 2720 {
lab=ctrl_pos}
N -360 2600 -360 2620 {
lab=#net171}
N -360 2680 -360 2690 {
lab=#net172}
N -200 2640 -200 2650 {
lab=GND}
N -200 2530 -200 2540 {
lab=vdd_syn1}
N -140 2720 -130 2720 {
lab=GND}
N -140 2750 -140 2760 {
lab=p9}
N -260 2570 -260 2580 {
lab=vpres2}
N -140 2570 -140 2580 {
lab=vpos2}
N -190 2720 -180 2720 {
lab=ctrl_pos}
N -140 2600 -140 2620 {
lab=#net173}
N -140 2680 -140 2690 {
lab=#net174}
N -2180 3160 -2180 3170 {
lab=GND}
N -2180 3050 -2180 3060 {
lab=vdd_syn1}
N -2120 3240 -2110 3240 {
lab=GND}
N -2120 3270 -2120 3280 {
lab=p0}
N -2240 3090 -2240 3100 {
lab=vpres2}
N -2120 3090 -2120 3100 {
lab=vpos2}
N -2170 3240 -2160 3240 {
lab=ctrl_pos}
N -2120 3120 -2120 3140 {
lab=#net175}
N -2120 3200 -2120 3210 {
lab=#net176}
N -1960 3160 -1960 3170 {
lab=GND}
N -1960 3050 -1960 3060 {
lab=vdd_syn1}
N -1900 3240 -1890 3240 {
lab=GND}
N -1900 3270 -1900 3280 {
lab=p1}
N -2020 3090 -2020 3100 {
lab=vpres2}
N -1900 3090 -1900 3100 {
lab=vpos2}
N -1950 3240 -1940 3240 {
lab=ctrl_pos}
N -1900 3120 -1900 3140 {
lab=#net177}
N -1900 3200 -1900 3210 {
lab=#net178}
N -1740 3160 -1740 3170 {
lab=GND}
N -1740 3050 -1740 3060 {
lab=vdd_syn1}
N -1680 3240 -1670 3240 {
lab=GND}
N -1680 3270 -1680 3280 {
lab=p2}
N -1800 3090 -1800 3100 {
lab=vpres2}
N -1680 3090 -1680 3100 {
lab=vpos2}
N -1730 3240 -1720 3240 {
lab=ctrl_pos}
N -1680 3120 -1680 3140 {
lab=#net179}
N -1680 3200 -1680 3210 {
lab=#net180}
N -1520 3160 -1520 3170 {
lab=GND}
N -1520 3050 -1520 3060 {
lab=vdd_syn1}
N -1460 3240 -1450 3240 {
lab=GND}
N -1460 3270 -1460 3280 {
lab=p3}
N -1580 3090 -1580 3100 {
lab=vpres2}
N -1460 3090 -1460 3100 {
lab=vpos2}
N -1510 3240 -1500 3240 {
lab=ctrl_pos}
N -1460 3120 -1460 3140 {
lab=#net181}
N -1460 3200 -1460 3210 {
lab=#net182}
N -1300 3160 -1300 3170 {
lab=GND}
N -1300 3050 -1300 3060 {
lab=vdd_syn1}
N -1240 3240 -1230 3240 {
lab=GND}
N -1240 3270 -1240 3280 {
lab=p4}
N -1360 3090 -1360 3100 {
lab=vpres2}
N -1240 3090 -1240 3100 {
lab=vpos2}
N -1290 3240 -1280 3240 {
lab=ctrl_pos}
N -1240 3120 -1240 3140 {
lab=#net183}
N -1240 3200 -1240 3210 {
lab=#net184}
N -1080 3160 -1080 3170 {
lab=GND}
N -1080 3050 -1080 3060 {
lab=vdd_syn1}
N -1020 3240 -1010 3240 {
lab=GND}
N -1020 3270 -1020 3280 {
lab=p5}
N -1140 3090 -1140 3100 {
lab=vpres2}
N -1020 3090 -1020 3100 {
lab=vpos2}
N -1070 3240 -1060 3240 {
lab=ctrl_pos}
N -1020 3120 -1020 3140 {
lab=#net185}
N -1020 3200 -1020 3210 {
lab=#net186}
N -860 3160 -860 3170 {
lab=GND}
N -860 3050 -860 3060 {
lab=vdd_syn1}
N -800 3240 -790 3240 {
lab=GND}
N -800 3270 -800 3280 {
lab=p6}
N -920 3090 -920 3100 {
lab=vpres2}
N -800 3090 -800 3100 {
lab=vpos2}
N -850 3240 -840 3240 {
lab=ctrl_pos}
N -800 3120 -800 3140 {
lab=#net187}
N -800 3200 -800 3210 {
lab=#net188}
N -640 3160 -640 3170 {
lab=GND}
N -640 3050 -640 3060 {
lab=vdd_syn1}
N -580 3240 -570 3240 {
lab=GND}
N -580 3270 -580 3280 {
lab=p7}
N -700 3090 -700 3100 {
lab=vpres2}
N -580 3090 -580 3100 {
lab=vpos2}
N -630 3240 -620 3240 {
lab=ctrl_pos}
N -580 3120 -580 3140 {
lab=#net189}
N -580 3200 -580 3210 {
lab=#net190}
N -420 3160 -420 3170 {
lab=GND}
N -420 3050 -420 3060 {
lab=vdd_syn1}
N -360 3240 -350 3240 {
lab=GND}
N -360 3270 -360 3280 {
lab=p8}
N -480 3090 -480 3100 {
lab=vpres2}
N -360 3090 -360 3100 {
lab=vpos2}
N -410 3240 -400 3240 {
lab=ctrl_pos}
N -360 3120 -360 3140 {
lab=#net191}
N -360 3200 -360 3210 {
lab=#net192}
N -200 3160 -200 3170 {
lab=GND}
N -200 3050 -200 3060 {
lab=vdd_syn1}
N -140 3240 -130 3240 {
lab=GND}
N -140 3270 -140 3280 {
lab=p9}
N -260 3090 -260 3100 {
lab=vpres2}
N -140 3090 -140 3100 {
lab=vpos2}
N -190 3240 -180 3240 {
lab=ctrl_pos}
N -140 3120 -140 3140 {
lab=#net193}
N -140 3200 -140 3210 {
lab=#net194}
C {devices/vsource.sym} -3670 -1010 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -3670 -960 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -3590 -1010 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -3590 -960 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -3590 -1060 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2600 -450 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2700 -500 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2980 -490 0 0 {name=I2 value="PWL(0 0 119.9u 0 120u 5u 199.9u 5u 200u 0 204.9u 0 205u 5u 209.9u 5u 210u 0 214.9u 0 215u 5u)"}
C {devices/gnd.sym} -2980 -440 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2800 -590 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2880 -590 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -3600 -150 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -3720 -150 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -3470 -150 0 0 {name=NGSPICE1
only_toplevel=true
value="
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param Lp_delay=3.5
.param Wp_delay=0.45
.param Ln_delay=3.5
.param Wn_delay=0.45
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 10n 220u
  write SNN_15x10_tb.raw
.endc
" }
C {devices/launcher.sym} -3760 485 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_tb.raw tran"
}
C {devices/lab_pin.sym} -2780 -540 0 0 {name=p10 sig_type=std_logic lab=vc1}
C {devices/vsource.sym} -3410 -1010 0 0 {name=V4 value="PWL(0 1.8 204.9u 1.8 205u 0)"}
C {devices/gnd.sym} -3410 -960 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -3410 -1060 2 0 {name=p16 sig_type=std_logic lab=vdd_delay}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 -880 0 0 {name=x10}
C {devices/gnd.sym} -2180 -990 0 0 {name=l39 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 -590 0 0 {name=x121}
C {devices/lab_pin.sym} -2240 -1070 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2120 -1070 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2350 -660 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2290 -700 3 0 {name=p28 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 -700 3 0 {name=p33 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2120 -990 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 -920 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 -920 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -2120 -880 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2300 -380 1 0 {name=p24 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 -370 0 0 {name=p53 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2160 3610 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2190 3730 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -2120 3570 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -2120 3530 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2120 3860 2 0 {name=p61 sig_type=std_logic lab=N0}
C {devices/vsource.sym} -3670 -590 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -3670 -540 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -3670 -640 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -3670 -450 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 199.9u 1.8 200u 0)"}
C {devices/gnd.sym} -3670 -400 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -3670 -500 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/lab_pin.sym} -2450 -540 1 0 {name=p69 sig_type=std_logic lab=vpre1}
C {devices/vsource.sym} -3670 -310 0 0 {name=V15 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3670 -260 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -3670 -360 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -2950 -540 1 0 {name=Vmeas120 savecurrent=true}
C {devices/lab_pin.sym} -2410 -420 2 0 {name=p74 sig_type=std_logic lab=ctrl1}
C {devices/vsource.sym} -3670 -730 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -3670 -680 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -3670 -780 2 0 {name=p75 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 -320 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2300 -550 1 0 {name=p2 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 -530 3 0 {name=p5 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 -580 2 0 {name=p14 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 -490 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} -3490 -730 0 0 {name=V12 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3490 -680 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -3490 -780 2 0 {name=p17 sig_type=std_logic lab=ctrl2}
C {devices/vsource.sym} -3510 -870 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -3510 -820 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -3510 -920 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -3500 -1010 0 0 {name=V3 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3500 -960 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -3500 -1060 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -3300 -1010 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -3300 -960 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -3300 -1060 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -3220 -1010 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -3220 -960 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -3220 -1060 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -3670 -870 0 0 {name=V7 value=0.5}
C {devices/gnd.sym} -3670 -820 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -3670 -920 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -3590 -870 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -3590 -820 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -3590 -920 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2600 -630 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2050 3730 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2180 -1110 1 0 {name=p15 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2350 -780 0 0 {name=p18 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 -450 0 0 {name=p19 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 -610 0 0 {name=p20 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -3670 -1060 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2840 -620 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2600 -970 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2700 -1020 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2980 -1010 0 0 {name=I1 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 209.9u 0 210u 5u 214.9u 5u 215u 0)"}
C {devices/gnd.sym} -2980 -960 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2800 -1110 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2880 -1110 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2780 -1060 0 0 {name=p25 sig_type=std_logic lab=vc2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 -360 0 0 {name=x20}
C {devices/gnd.sym} -2180 -470 0 0 {name=l15 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 -1110 0 0 {name=x111}
C {devices/lab_pin.sym} -2240 -550 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 -550 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2350 -1180 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -2290 -1220 3 0 {name=p31 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2410 -1220 3 0 {name=p32 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2120 -470 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 -400 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 -400 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -2120 -360 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2300 -900 1 0 {name=p35 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2410 -890 0 0 {name=p36 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2450 -1060 1 0 {name=p37 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2950 -1060 1 0 {name=Vmeas110 savecurrent=true}
C {devices/lab_pin.sym} -2410 -940 2 0 {name=p38 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 -840 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2300 -1070 1 0 {name=p39 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2400 -1050 3 0 {name=p41 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2410 -1100 2 0 {name=p42 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 -1010 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2600 -1150 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2180 -590 1 0 {name=p44 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2350 -1300 0 0 {name=p45 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 -970 0 0 {name=p47 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 -1130 0 0 {name=p48 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2840 -1140 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2170 -400 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2170 -920 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -3300 -730 0 0 {name=V16 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3300 -680 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -3300 -780 2 0 {name=p71 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -3140 -1010 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -3140 -960 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -3140 -1060 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -4160 315 0 0 {name=x111111}
C {devices/gnd.sym} -4160 375 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -4160 255 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -4240 295 0 0 {name=p83 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} -4240 335 0 0 {name=p84 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -2190 3610 1 0 {name=p87 sig_type=std_logic lab=inh1}
C {devices/vsource.sym} -3120 -730 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -3120 -680 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -3120 -780 2 0 {name=p88 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -4090 315 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -4150 465 2 0 {name=p94 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} -4190 485 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -4190 455 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -4190 515 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -4230 465 0 0 {name=p85 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -3960 465 2 0 {name=p89 sig_type=std_logic lab=inh2}
C {sky130_fd_pr/nfet_01v8.sym} -4000 485 3 0 {name=M201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -4000 455 2 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -4000 515 2 0 {name=p90 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -4040 465 0 0 {name=p93 sig_type=std_logic lab=vinh}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2600 -540 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Input_Layer_LIF.sym} -2600 -1060 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -2120 3710 1 0 {name=x0}
C {devices/vsource.sym} -3440 -870 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -3440 -820 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -3440 -920 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2700 -1100 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2700 -580 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2080 3610 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1940 3610 1 0 {name=p57 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1970 3730 0 0 {name=l22 lab=GND}
C {devices/ammeter.sym} -1900 3570 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -1900 3530 2 0 {name=p58 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1900 3860 2 0 {name=p62 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -1830 3730 3 0 {name=p86 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1970 3610 1 0 {name=p98 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1900 3710 1 0 {name=x1}
C {devices/lab_pin.sym} -1860 3610 1 0 {name=p99 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -3670 -1150 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3670 -1100 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -3670 -1200 2 0 {name=p7 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} -3490 -1150 0 0 {name=V20 value="PWL(0 1.8 39.9u 1.8 40u 0 119.9u 0 120u 1.8 199.9u 1.8 200u 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -3490 -1100 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} -3490 -1200 2 0 {name=p51 sig_type=std_logic lab=vdd_syn2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 -890 0 0 {name=x113}
C {devices/lab_pin.sym} -2410 -340 0 0 {name=p49 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 -370 0 0 {name=x123}
C {devices/lab_pin.sym} -2410 -860 0 0 {name=p100 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 -1060 0 0 {name=x112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 -540 0 0 {name=x122}
C {devices/lab_pin.sym} -1720 3610 1 0 {name=p22 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1750 3730 0 0 {name=l30 lab=GND}
C {devices/ammeter.sym} -1680 3570 0 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -1680 3530 2 0 {name=p92 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1680 3860 2 0 {name=p101 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} -1610 3730 3 0 {name=p102 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1750 3610 1 0 {name=p103 sig_type=std_logic lab=inh1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1680 3710 1 0 {name=x2}
C {devices/lab_pin.sym} -1640 3610 1 0 {name=p104 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1500 3610 1 0 {name=p105 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1530 3730 0 0 {name=l37 lab=GND}
C {devices/ammeter.sym} -1460 3570 0 0 {name=Vmeas3 savecurrent=true}
C {devices/lab_pin.sym} -1460 3530 2 0 {name=p106 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1460 3860 2 0 {name=p107 sig_type=std_logic lab=N3}
C {devices/lab_pin.sym} -1390 3730 3 0 {name=p108 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1530 3610 1 0 {name=p109 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1460 3710 1 0 {name=x3}
C {devices/lab_pin.sym} -1420 3610 1 0 {name=p110 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1280 3610 1 0 {name=p111 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1310 3730 0 0 {name=l38 lab=GND}
C {devices/ammeter.sym} -1240 3570 0 0 {name=Vmeas4 savecurrent=true}
C {devices/lab_pin.sym} -1240 3530 2 0 {name=p112 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1240 3860 2 0 {name=p113 sig_type=std_logic lab=N4}
C {devices/lab_pin.sym} -1170 3730 3 0 {name=p114 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1310 3610 1 0 {name=p115 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1240 3710 1 0 {name=x4}
C {devices/lab_pin.sym} -1200 3610 1 0 {name=p116 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1060 3610 1 0 {name=p117 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1090 3730 0 0 {name=l41 lab=GND}
C {devices/ammeter.sym} -1020 3570 0 0 {name=Vmeas5 savecurrent=true}
C {devices/lab_pin.sym} -1020 3530 2 0 {name=p118 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1020 3860 2 0 {name=p119 sig_type=std_logic lab=N5}
C {devices/lab_pin.sym} -950 3730 3 0 {name=p120 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1090 3610 1 0 {name=p121 sig_type=std_logic lab=inh1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -1020 3710 1 0 {name=x5}
C {devices/lab_pin.sym} -980 3610 1 0 {name=p122 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -840 3610 1 0 {name=p123 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -870 3730 0 0 {name=l42 lab=GND}
C {devices/ammeter.sym} -800 3570 0 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -800 3530 2 0 {name=p124 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 3860 2 0 {name=p125 sig_type=std_logic lab=N6}
C {devices/lab_pin.sym} -730 3730 3 0 {name=p126 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -870 3610 1 0 {name=p127 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -800 3710 1 0 {name=x6}
C {devices/lab_pin.sym} -760 3610 1 0 {name=p128 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -620 3610 1 0 {name=p129 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -650 3730 0 0 {name=l43 lab=GND}
C {devices/ammeter.sym} -580 3570 0 0 {name=Vmeas7 savecurrent=true}
C {devices/lab_pin.sym} -580 3530 2 0 {name=p130 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -580 3860 2 0 {name=p131 sig_type=std_logic lab=N7}
C {devices/lab_pin.sym} -510 3730 3 0 {name=p132 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -650 3610 1 0 {name=p133 sig_type=std_logic lab=inh1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -580 3710 1 0 {name=x7}
C {devices/lab_pin.sym} -540 3610 1 0 {name=p134 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -400 3610 1 0 {name=p135 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -430 3730 0 0 {name=l44 lab=GND}
C {devices/ammeter.sym} -360 3570 0 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -360 3530 2 0 {name=p136 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -360 3860 2 0 {name=p137 sig_type=std_logic lab=N8}
C {devices/lab_pin.sym} -290 3730 3 0 {name=p138 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -430 3610 1 0 {name=p139 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -360 3710 1 0 {name=x8}
C {devices/lab_pin.sym} -320 3610 1 0 {name=p140 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -180 3610 1 0 {name=p141 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -210 3730 0 0 {name=l45 lab=GND}
C {devices/ammeter.sym} -140 3570 0 0 {name=Vmeas9 savecurrent=true}
C {devices/lab_pin.sym} -140 3530 2 0 {name=p142 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -140 3860 2 0 {name=p143 sig_type=std_logic lab=N9}
C {devices/lab_pin.sym} -70 3730 3 0 {name=p144 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -210 3610 1 0 {name=p145 sig_type=std_logic lab=inh2}
C {/home/ricardo/RATT_repos/Proyectos_xschem/LIF_neuron/Output_Layer_LIF.sym} -140 3710 1 0 {name=x9}
C {devices/lab_pin.sym} -100 3610 1 0 {name=p146 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 -880 0 0 {name=x11}
C {devices/gnd.sym} -1960 -990 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -2020 -1070 1 0 {name=p52 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1900 -1070 1 0 {name=p54 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1900 -990 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 -920 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 -920 3 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -1900 -880 2 0 {name=p55 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 -1110 1 0 {name=p63 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 -360 0 0 {name=x21}
C {devices/gnd.sym} -1960 -470 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -2020 -550 1 0 {name=p64 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 -550 1 0 {name=p67 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 -470 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 -400 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 -400 3 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -1900 -360 2 0 {name=p68 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 -590 1 0 {name=p70 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 -400 0 0 {name=p77 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1950 -920 0 0 {name=p79 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 -880 0 0 {name=x12}
C {devices/gnd.sym} -1740 -990 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -1800 -1070 1 0 {name=p147 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1680 -1070 1 0 {name=p148 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1680 -990 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 -920 0 0 {name=M12
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 -920 3 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -1680 -880 2 0 {name=p149 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 -1110 1 0 {name=p150 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 -360 0 0 {name=x22}
C {devices/gnd.sym} -1740 -470 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -1800 -550 1 0 {name=p151 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 -550 1 0 {name=p152 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 -470 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 -400 0 0 {name=M22
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 -400 3 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -1680 -360 2 0 {name=p153 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 -590 1 0 {name=p154 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 -400 0 0 {name=p155 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1730 -920 0 0 {name=p156 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 -880 0 0 {name=x13}
C {devices/gnd.sym} -1520 -990 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -1580 -1070 1 0 {name=p157 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1460 -1070 1 0 {name=p158 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1460 -990 0 0 {name=Vmeas13 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 -920 0 0 {name=M13
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 -920 3 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -1460 -880 2 0 {name=p159 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 -1110 1 0 {name=p160 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 -360 0 0 {name=x23}
C {devices/gnd.sym} -1520 -470 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -1580 -550 1 0 {name=p161 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 -550 1 0 {name=p162 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 -470 0 0 {name=Vmeas23 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 -400 0 0 {name=M23
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 -400 3 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1460 -360 2 0 {name=p163 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 -590 1 0 {name=p164 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 -400 0 0 {name=p165 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1510 -920 0 0 {name=p166 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 -880 0 0 {name=x14}
C {devices/gnd.sym} -1300 -990 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -1360 -1070 1 0 {name=p167 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1240 -1070 1 0 {name=p168 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1240 -990 0 0 {name=Vmeas14 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 -920 0 0 {name=M14
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 -920 3 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -1240 -880 2 0 {name=p169 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 -1110 1 0 {name=p170 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 -360 0 0 {name=x24}
C {devices/gnd.sym} -1300 -470 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -1360 -550 1 0 {name=p171 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 -550 1 0 {name=p172 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 -470 0 0 {name=Vmeas24 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 -400 0 0 {name=M24
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 -400 3 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -1240 -360 2 0 {name=p173 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 -590 1 0 {name=p174 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 -400 0 0 {name=p175 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1290 -920 0 0 {name=p176 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 -880 0 0 {name=x15}
C {devices/gnd.sym} -1080 -990 0 0 {name=l58 lab=GND}
C {devices/lab_pin.sym} -1140 -1070 1 0 {name=p177 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1020 -1070 1 0 {name=p178 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1020 -990 0 0 {name=Vmeas15 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 -920 0 0 {name=M15
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 -920 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1020 -880 2 0 {name=p179 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 -1110 1 0 {name=p180 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 -360 0 0 {name=x25}
C {devices/gnd.sym} -1080 -470 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -1140 -550 1 0 {name=p181 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 -550 1 0 {name=p182 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 -470 0 0 {name=Vmeas25 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 -400 0 0 {name=M25
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 -400 3 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -1020 -360 2 0 {name=p183 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 -590 1 0 {name=p184 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 -400 0 0 {name=p185 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1070 -920 0 0 {name=p186 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 -880 0 0 {name=x16}
C {devices/gnd.sym} -860 -990 0 0 {name=l62 lab=GND}
C {devices/lab_pin.sym} -920 -1070 1 0 {name=p187 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -800 -1070 1 0 {name=p188 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -800 -990 0 0 {name=Vmeas16 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 -920 0 0 {name=M16
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 -920 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -800 -880 2 0 {name=p189 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 -1110 1 0 {name=p190 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 -360 0 0 {name=x26}
C {devices/gnd.sym} -860 -470 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -920 -550 1 0 {name=p191 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 -550 1 0 {name=p192 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 -470 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 -400 0 0 {name=M26
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 -400 3 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -800 -360 2 0 {name=p193 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 -590 1 0 {name=p194 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 -400 0 0 {name=p195 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -850 -920 0 0 {name=p196 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 -880 0 0 {name=x17}
C {devices/gnd.sym} -640 -990 0 0 {name=l70 lab=GND}
C {devices/lab_pin.sym} -700 -1070 1 0 {name=p197 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -580 -1070 1 0 {name=p198 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -580 -990 0 0 {name=Vmeas17 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 -920 0 0 {name=M17
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 -920 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -580 -880 2 0 {name=p199 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 -1110 1 0 {name=p200 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 -360 0 0 {name=x27}
C {devices/gnd.sym} -640 -470 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -700 -550 1 0 {name=p201 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 -550 1 0 {name=p202 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 -470 0 0 {name=Vmeas27 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 -400 0 0 {name=M27
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 -400 3 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -580 -360 2 0 {name=p203 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 -590 1 0 {name=p204 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 -400 0 0 {name=p205 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -630 -920 0 0 {name=p206 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 -880 0 0 {name=x18}
C {devices/gnd.sym} -420 -990 0 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} -480 -1070 1 0 {name=p207 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -360 -1070 1 0 {name=p208 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -360 -990 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 -920 0 0 {name=M18
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 -920 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -360 -880 2 0 {name=p209 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 -1110 1 0 {name=p210 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 -360 0 0 {name=x28}
C {devices/gnd.sym} -420 -470 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -480 -550 1 0 {name=p211 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 -550 1 0 {name=p212 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 -470 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 -400 0 0 {name=M28
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 -400 3 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -360 -360 2 0 {name=p213 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 -590 1 0 {name=p214 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 -400 0 0 {name=p215 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -410 -920 0 0 {name=p216 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 -880 0 0 {name=x19}
C {devices/gnd.sym} -200 -990 0 0 {name=l80 lab=GND}
C {devices/lab_pin.sym} -260 -1070 1 0 {name=p217 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -140 -1070 1 0 {name=p218 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -140 -990 0 0 {name=Vmeas19 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -920 0 0 {name=M19
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -920 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -140 -880 2 0 {name=p219 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 -1110 1 0 {name=p220 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 -360 0 0 {name=x29}
C {devices/gnd.sym} -200 -470 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -260 -550 1 0 {name=p221 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 -550 1 0 {name=p222 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 -470 0 0 {name=Vmeas29 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -400 0 0 {name=M29
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -400 3 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -140 -360 2 0 {name=p223 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 -590 1 0 {name=p224 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 -400 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -190 -920 0 0 {name=p226 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 -70 0 0 {name=x130}
C {devices/gnd.sym} -2350 -140 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -2290 -180 3 0 {name=p227 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 -180 3 0 {name=p228 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 140 1 0 {name=p229 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 150 0 0 {name=p230 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 100 2 0 {name=p231 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 200 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -2300 -30 1 0 {name=p232 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 -10 3 0 {name=p233 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 -60 2 0 {name=p234 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 30 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -2350 -260 0 0 {name=p235 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 70 0 0 {name=p236 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 -90 0 0 {name=p237 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 180 0 0 {name=p238 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 150 0 0 {name=x132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 -20 0 0 {name=x131}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 450 0 0 {name=x141}
C {devices/gnd.sym} -2350 380 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -2290 340 3 0 {name=p239 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 340 3 0 {name=p240 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 660 1 0 {name=p241 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 670 0 0 {name=p242 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 620 2 0 {name=p243 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 720 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -2300 490 1 0 {name=p244 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 510 3 0 {name=p245 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 460 2 0 {name=p246 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 550 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -2350 260 0 0 {name=p247 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 590 0 0 {name=p248 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 430 0 0 {name=p249 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 700 0 0 {name=p250 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 670 0 0 {name=x143}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 500 0 0 {name=x142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 970 0 0 {name=x151}
C {devices/gnd.sym} -2350 900 0 0 {name=l90 lab=GND}
C {devices/lab_pin.sym} -2290 860 3 0 {name=p251 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 860 3 0 {name=p252 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 1180 1 0 {name=p253 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 1190 0 0 {name=p254 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 1140 2 0 {name=p255 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 1240 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} -2300 1010 1 0 {name=p256 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 1030 3 0 {name=p257 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 980 2 0 {name=p258 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 1070 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} -2350 780 0 0 {name=p259 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 1110 0 0 {name=p260 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 950 0 0 {name=p261 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 1220 0 0 {name=p262 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 1190 0 0 {name=x153}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 1020 0 0 {name=x152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 1490 0 0 {name=x161}
C {devices/gnd.sym} -2350 1420 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -2290 1380 3 0 {name=p263 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 1380 3 0 {name=p264 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 1700 1 0 {name=p265 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 1710 0 0 {name=p266 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 1660 2 0 {name=p267 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 1760 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} -2300 1530 1 0 {name=p268 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 1550 3 0 {name=p269 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 1500 2 0 {name=p270 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 1590 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -2350 1300 0 0 {name=p271 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 1630 0 0 {name=p272 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 1470 0 0 {name=p273 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 1740 0 0 {name=p274 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 1710 0 0 {name=x163}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 1540 0 0 {name=x162}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 2010 0 0 {name=x171}
C {devices/gnd.sym} -2350 1940 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} -2290 1900 3 0 {name=p275 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 1900 3 0 {name=p276 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 2220 1 0 {name=p277 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 2230 0 0 {name=p278 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 2180 2 0 {name=p279 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 2280 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} -2300 2050 1 0 {name=p280 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 2070 3 0 {name=p281 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 2020 2 0 {name=p282 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 2110 0 0 {name=l98 lab=GND}
C {devices/lab_pin.sym} -2350 1820 0 0 {name=p283 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 2150 0 0 {name=p284 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 1990 0 0 {name=p285 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 2260 0 0 {name=p286 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 2230 0 0 {name=x173}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 2060 0 0 {name=x172}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 2530 0 0 {name=x181}
C {devices/gnd.sym} -2350 2460 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2290 2420 3 0 {name=p287 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 2420 3 0 {name=p288 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 2740 1 0 {name=p289 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 2750 0 0 {name=p290 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 2700 2 0 {name=p291 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 2800 0 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2300 2570 1 0 {name=p292 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 2590 3 0 {name=p293 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 2540 2 0 {name=p294 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 2630 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -2350 2340 0 0 {name=p295 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 2670 0 0 {name=p296 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 2510 0 0 {name=p297 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 2780 0 0 {name=p298 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 2750 0 0 {name=x183}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 2580 0 0 {name=x182}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2170 3050 0 0 {name=x191}
C {devices/gnd.sym} -2350 2980 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} -2290 2940 3 0 {name=p299 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2410 2940 3 0 {name=p300 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2300 3260 1 0 {name=p301 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2410 3270 0 0 {name=p302 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2410 3220 2 0 {name=p303 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2350 3320 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -2300 3090 1 0 {name=p304 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2400 3110 3 0 {name=p305 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2410 3060 2 0 {name=p306 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2350 3150 0 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} -2350 2860 0 0 {name=p307 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2350 3190 0 0 {name=p308 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2350 3030 0 0 {name=p309 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2410 3300 0 0 {name=p310 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2350 3270 0 0 {name=x193}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2350 3100 0 0 {name=x192}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 160 0 0 {name=x30}
C {devices/gnd.sym} -2180 50 0 0 {name=l105 lab=GND}
C {devices/lab_pin.sym} -2240 -30 1 0 {name=p311 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 -30 1 0 {name=p312 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 50 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 120 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 120 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -2120 160 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 -70 1 0 {name=p314 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 120 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 160 0 0 {name=x31}
C {devices/gnd.sym} -1960 50 0 0 {name=l107 lab=GND}
C {devices/lab_pin.sym} -2020 -30 1 0 {name=p316 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 -30 1 0 {name=p317 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 50 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 120 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 120 3 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} -1900 160 2 0 {name=p318 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 -70 1 0 {name=p319 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 120 0 0 {name=p320 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 160 0 0 {name=x32}
C {devices/gnd.sym} -1740 50 0 0 {name=l109 lab=GND}
C {devices/lab_pin.sym} -1800 -30 1 0 {name=p321 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 -30 1 0 {name=p322 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 50 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 120 0 0 {name=M32
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 120 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1680 160 2 0 {name=p323 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 -70 1 0 {name=p324 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 120 0 0 {name=p325 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 160 0 0 {name=x33}
C {devices/gnd.sym} -1520 50 0 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} -1580 -30 1 0 {name=p326 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 -30 1 0 {name=p327 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 50 0 0 {name=Vmeas33 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 120 0 0 {name=M33
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 120 3 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} -1460 160 2 0 {name=p328 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 -70 1 0 {name=p329 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 120 0 0 {name=p330 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 160 0 0 {name=x34}
C {devices/gnd.sym} -1300 50 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -1360 -30 1 0 {name=p331 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 -30 1 0 {name=p332 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 50 0 0 {name=Vmeas34 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 120 0 0 {name=M34
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 120 3 0 {name=l114 lab=GND}
C {devices/lab_pin.sym} -1240 160 2 0 {name=p333 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 -70 1 0 {name=p334 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 120 0 0 {name=p335 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 160 0 0 {name=x35}
C {devices/gnd.sym} -1080 50 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -1140 -30 1 0 {name=p336 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 -30 1 0 {name=p337 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 50 0 0 {name=Vmeas35 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 120 0 0 {name=M35
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 120 3 0 {name=l116 lab=GND}
C {devices/lab_pin.sym} -1020 160 2 0 {name=p338 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 -70 1 0 {name=p339 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 120 0 0 {name=p340 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 160 0 0 {name=x36}
C {devices/gnd.sym} -860 50 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -920 -30 1 0 {name=p341 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 -30 1 0 {name=p342 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 50 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 120 0 0 {name=M36
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 120 3 0 {name=l118 lab=GND}
C {devices/lab_pin.sym} -800 160 2 0 {name=p343 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 -70 1 0 {name=p344 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 120 0 0 {name=p345 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 160 0 0 {name=x37}
C {devices/gnd.sym} -640 50 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -700 -30 1 0 {name=p346 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 -30 1 0 {name=p347 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 50 0 0 {name=Vmeas37 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 120 0 0 {name=M37
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 120 3 0 {name=l120 lab=GND}
C {devices/lab_pin.sym} -580 160 2 0 {name=p348 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 -70 1 0 {name=p349 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 120 0 0 {name=p350 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 160 0 0 {name=x38}
C {devices/gnd.sym} -420 50 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -480 -30 1 0 {name=p351 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 -30 1 0 {name=p352 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 50 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 120 0 0 {name=M38
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 120 3 0 {name=l122 lab=GND}
C {devices/lab_pin.sym} -360 160 2 0 {name=p353 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 -70 1 0 {name=p354 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 120 0 0 {name=p355 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 160 0 0 {name=x39}
C {devices/gnd.sym} -200 50 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -260 -30 1 0 {name=p356 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 -30 1 0 {name=p357 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 50 0 0 {name=Vmeas39 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 120 0 0 {name=M39
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 120 3 0 {name=l124 lab=GND}
C {devices/lab_pin.sym} -140 160 2 0 {name=p358 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 -70 1 0 {name=p359 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 120 0 0 {name=p360 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 680 0 0 {name=x40}
C {devices/gnd.sym} -2180 570 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -2240 490 1 0 {name=p361 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 490 1 0 {name=p362 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 570 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 640 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 640 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -2120 680 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 450 1 0 {name=p364 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 640 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 680 0 0 {name=x41}
C {devices/gnd.sym} -1960 570 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} -2020 490 1 0 {name=p366 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 490 1 0 {name=p367 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 570 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 640 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 640 3 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -1900 680 2 0 {name=p368 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 450 1 0 {name=p369 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 640 0 0 {name=p370 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 680 0 0 {name=x42}
C {devices/gnd.sym} -1740 570 0 0 {name=l129 lab=GND}
C {devices/lab_pin.sym} -1800 490 1 0 {name=p371 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 490 1 0 {name=p372 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 570 0 0 {name=Vmeas42 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 640 0 0 {name=M42
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 640 3 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -1680 680 2 0 {name=p373 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 450 1 0 {name=p374 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 640 0 0 {name=p375 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 680 0 0 {name=x43}
C {devices/gnd.sym} -1520 570 0 0 {name=l131 lab=GND}
C {devices/lab_pin.sym} -1580 490 1 0 {name=p376 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 490 1 0 {name=p377 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 570 0 0 {name=Vmeas43 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 640 0 0 {name=M43
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 640 3 0 {name=l132 lab=GND}
C {devices/lab_pin.sym} -1460 680 2 0 {name=p378 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 450 1 0 {name=p379 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 640 0 0 {name=p380 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 680 0 0 {name=x44}
C {devices/gnd.sym} -1300 570 0 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} -1360 490 1 0 {name=p381 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 490 1 0 {name=p382 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 570 0 0 {name=Vmeas44 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 640 0 0 {name=M44
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 640 3 0 {name=l134 lab=GND}
C {devices/lab_pin.sym} -1240 680 2 0 {name=p383 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 450 1 0 {name=p384 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 640 0 0 {name=p385 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 680 0 0 {name=x45}
C {devices/gnd.sym} -1080 570 0 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} -1140 490 1 0 {name=p386 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 490 1 0 {name=p387 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 570 0 0 {name=Vmeas45 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 640 0 0 {name=M45
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 640 3 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} -1020 680 2 0 {name=p388 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 450 1 0 {name=p389 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 640 0 0 {name=p390 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 680 0 0 {name=x46}
C {devices/gnd.sym} -860 570 0 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -920 490 1 0 {name=p391 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 490 1 0 {name=p392 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 570 0 0 {name=Vmeas46 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 640 0 0 {name=M46
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 640 3 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -800 680 2 0 {name=p393 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 450 1 0 {name=p394 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 640 0 0 {name=p395 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 680 0 0 {name=x47}
C {devices/gnd.sym} -640 570 0 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} -700 490 1 0 {name=p396 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 490 1 0 {name=p397 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 570 0 0 {name=Vmeas47 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 640 0 0 {name=M47
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 640 3 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -580 680 2 0 {name=p398 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 450 1 0 {name=p399 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 640 0 0 {name=p400 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 680 0 0 {name=x48}
C {devices/gnd.sym} -420 570 0 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -480 490 1 0 {name=p401 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 490 1 0 {name=p402 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 570 0 0 {name=Vmeas48 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 640 0 0 {name=M48
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 640 3 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} -360 680 2 0 {name=p403 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 450 1 0 {name=p404 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 640 0 0 {name=p405 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 680 0 0 {name=x49}
C {devices/gnd.sym} -200 570 0 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} -260 490 1 0 {name=p406 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 490 1 0 {name=p407 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 570 0 0 {name=Vmeas49 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 640 0 0 {name=M49
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 640 3 0 {name=l144 lab=GND}
C {devices/lab_pin.sym} -140 680 2 0 {name=p408 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 450 1 0 {name=p409 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 640 0 0 {name=p410 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 1200 0 0 {name=x50}
C {devices/gnd.sym} -2180 1090 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -2240 1010 1 0 {name=p411 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 1010 1 0 {name=p412 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 1090 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 1160 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 1160 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -2120 1200 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 970 1 0 {name=p414 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 1160 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 1200 0 0 {name=x51}
C {devices/gnd.sym} -1960 1090 0 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} -2020 1010 1 0 {name=p416 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 1010 1 0 {name=p417 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 1090 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 1160 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 1160 3 0 {name=l148 lab=GND}
C {devices/lab_pin.sym} -1900 1200 2 0 {name=p418 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 970 1 0 {name=p419 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 1160 0 0 {name=p420 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 1200 0 0 {name=x52}
C {devices/gnd.sym} -1740 1090 0 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} -1800 1010 1 0 {name=p421 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 1010 1 0 {name=p422 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 1090 0 0 {name=Vmeas52 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 1160 0 0 {name=M52
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 1160 3 0 {name=l150 lab=GND}
C {devices/lab_pin.sym} -1680 1200 2 0 {name=p423 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 970 1 0 {name=p424 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 1160 0 0 {name=p425 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 1200 0 0 {name=x53}
C {devices/gnd.sym} -1520 1090 0 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} -1580 1010 1 0 {name=p426 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 1010 1 0 {name=p427 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 1090 0 0 {name=Vmeas53 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 1160 0 0 {name=M53
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 1160 3 0 {name=l152 lab=GND}
C {devices/lab_pin.sym} -1460 1200 2 0 {name=p428 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 970 1 0 {name=p429 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 1160 0 0 {name=p430 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 1200 0 0 {name=x54}
C {devices/gnd.sym} -1300 1090 0 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} -1360 1010 1 0 {name=p431 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 1010 1 0 {name=p432 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 1090 0 0 {name=Vmeas54 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 1160 0 0 {name=M54
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 1160 3 0 {name=l154 lab=GND}
C {devices/lab_pin.sym} -1240 1200 2 0 {name=p433 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 970 1 0 {name=p434 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 1160 0 0 {name=p435 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 1200 0 0 {name=x55}
C {devices/gnd.sym} -1080 1090 0 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} -1140 1010 1 0 {name=p436 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 1010 1 0 {name=p437 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 1090 0 0 {name=Vmeas55 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 1160 0 0 {name=M55
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 1160 3 0 {name=l156 lab=GND}
C {devices/lab_pin.sym} -1020 1200 2 0 {name=p438 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 970 1 0 {name=p439 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 1160 0 0 {name=p440 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 1200 0 0 {name=x56}
C {devices/gnd.sym} -860 1090 0 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -920 1010 1 0 {name=p441 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 1010 1 0 {name=p442 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 1090 0 0 {name=Vmeas56 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 1160 0 0 {name=M56
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 1160 3 0 {name=l158 lab=GND}
C {devices/lab_pin.sym} -800 1200 2 0 {name=p443 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 970 1 0 {name=p444 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 1160 0 0 {name=p445 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 1200 0 0 {name=x57}
C {devices/gnd.sym} -640 1090 0 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} -700 1010 1 0 {name=p446 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 1010 1 0 {name=p447 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 1090 0 0 {name=Vmeas57 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 1160 0 0 {name=M57
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 1160 3 0 {name=l160 lab=GND}
C {devices/lab_pin.sym} -580 1200 2 0 {name=p448 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 970 1 0 {name=p449 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 1160 0 0 {name=p450 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 1200 0 0 {name=x58}
C {devices/gnd.sym} -420 1090 0 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -480 1010 1 0 {name=p451 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 1010 1 0 {name=p452 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 1090 0 0 {name=Vmeas58 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 1160 0 0 {name=M58
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 1160 3 0 {name=l162 lab=GND}
C {devices/lab_pin.sym} -360 1200 2 0 {name=p453 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 970 1 0 {name=p454 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 1160 0 0 {name=p455 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 1200 0 0 {name=x59}
C {devices/gnd.sym} -200 1090 0 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} -260 1010 1 0 {name=p456 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 1010 1 0 {name=p457 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 1090 0 0 {name=Vmeas59 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 1160 0 0 {name=M59
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 1160 3 0 {name=l164 lab=GND}
C {devices/lab_pin.sym} -140 1200 2 0 {name=p458 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 970 1 0 {name=p459 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 1160 0 0 {name=p460 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 1720 0 0 {name=x60}
C {devices/gnd.sym} -2180 1610 0 0 {name=l165 lab=GND}
C {devices/lab_pin.sym} -2240 1530 1 0 {name=p461 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 1530 1 0 {name=p462 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 1610 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 1680 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 1680 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -2120 1720 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 1490 1 0 {name=p464 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 1680 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 1720 0 0 {name=x61}
C {devices/gnd.sym} -1960 1610 0 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} -2020 1530 1 0 {name=p466 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 1530 1 0 {name=p467 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 1610 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 1680 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 1680 3 0 {name=l168 lab=GND}
C {devices/lab_pin.sym} -1900 1720 2 0 {name=p468 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 1490 1 0 {name=p469 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 1680 0 0 {name=p470 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 1720 0 0 {name=x62}
C {devices/gnd.sym} -1740 1610 0 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} -1800 1530 1 0 {name=p471 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 1530 1 0 {name=p472 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 1610 0 0 {name=Vmeas62 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 1680 0 0 {name=M62
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 1680 3 0 {name=l170 lab=GND}
C {devices/lab_pin.sym} -1680 1720 2 0 {name=p473 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 1490 1 0 {name=p474 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 1680 0 0 {name=p475 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 1720 0 0 {name=x63}
C {devices/gnd.sym} -1520 1610 0 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} -1580 1530 1 0 {name=p476 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 1530 1 0 {name=p477 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 1610 0 0 {name=Vmeas63 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 1680 0 0 {name=M63
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 1680 3 0 {name=l172 lab=GND}
C {devices/lab_pin.sym} -1460 1720 2 0 {name=p478 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 1490 1 0 {name=p479 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 1680 0 0 {name=p480 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 1720 0 0 {name=x64}
C {devices/gnd.sym} -1300 1610 0 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} -1360 1530 1 0 {name=p481 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 1530 1 0 {name=p482 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 1610 0 0 {name=Vmeas64 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 1680 0 0 {name=M64
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 1680 3 0 {name=l174 lab=GND}
C {devices/lab_pin.sym} -1240 1720 2 0 {name=p483 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 1490 1 0 {name=p484 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 1680 0 0 {name=p485 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 1720 0 0 {name=x65}
C {devices/gnd.sym} -1080 1610 0 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} -1140 1530 1 0 {name=p486 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 1530 1 0 {name=p487 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 1610 0 0 {name=Vmeas65 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 1680 0 0 {name=M65
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 1680 3 0 {name=l176 lab=GND}
C {devices/lab_pin.sym} -1020 1720 2 0 {name=p488 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 1490 1 0 {name=p489 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 1680 0 0 {name=p490 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 1720 0 0 {name=x66}
C {devices/gnd.sym} -860 1610 0 0 {name=l177 lab=GND}
C {devices/lab_pin.sym} -920 1530 1 0 {name=p491 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 1530 1 0 {name=p492 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 1610 0 0 {name=Vmeas66 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 1680 0 0 {name=M66
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 1680 3 0 {name=l178 lab=GND}
C {devices/lab_pin.sym} -800 1720 2 0 {name=p493 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 1490 1 0 {name=p494 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 1680 0 0 {name=p495 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 1720 0 0 {name=x67}
C {devices/gnd.sym} -640 1610 0 0 {name=l179 lab=GND}
C {devices/lab_pin.sym} -700 1530 1 0 {name=p496 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 1530 1 0 {name=p497 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 1610 0 0 {name=Vmeas67 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 1680 0 0 {name=M67
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 1680 3 0 {name=l180 lab=GND}
C {devices/lab_pin.sym} -580 1720 2 0 {name=p498 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 1490 1 0 {name=p499 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 1680 0 0 {name=p500 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 1720 0 0 {name=x68}
C {devices/gnd.sym} -420 1610 0 0 {name=l181 lab=GND}
C {devices/lab_pin.sym} -480 1530 1 0 {name=p501 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 1530 1 0 {name=p502 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 1610 0 0 {name=Vmeas68 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 1680 0 0 {name=M68
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 1680 3 0 {name=l182 lab=GND}
C {devices/lab_pin.sym} -360 1720 2 0 {name=p503 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 1490 1 0 {name=p504 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 1680 0 0 {name=p505 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 1720 0 0 {name=x69}
C {devices/gnd.sym} -200 1610 0 0 {name=l183 lab=GND}
C {devices/lab_pin.sym} -260 1530 1 0 {name=p506 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 1530 1 0 {name=p507 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 1610 0 0 {name=Vmeas69 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 1680 0 0 {name=M69
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 1680 3 0 {name=l184 lab=GND}
C {devices/lab_pin.sym} -140 1720 2 0 {name=p508 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 1490 1 0 {name=p509 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 1680 0 0 {name=p510 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 2240 0 0 {name=x70}
C {devices/gnd.sym} -2180 2130 0 0 {name=l185 lab=GND}
C {devices/lab_pin.sym} -2240 2050 1 0 {name=p511 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 2050 1 0 {name=p512 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 2130 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 2200 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 2200 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -2120 2240 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 2010 1 0 {name=p514 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 2200 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 2240 0 0 {name=x71}
C {devices/gnd.sym} -1960 2130 0 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -2020 2050 1 0 {name=p516 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 2050 1 0 {name=p517 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 2130 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 2200 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 2200 3 0 {name=l188 lab=GND}
C {devices/lab_pin.sym} -1900 2240 2 0 {name=p518 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 2010 1 0 {name=p519 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 2200 0 0 {name=p520 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 2240 0 0 {name=x72}
C {devices/gnd.sym} -1740 2130 0 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} -1800 2050 1 0 {name=p521 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 2050 1 0 {name=p522 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 2130 0 0 {name=Vmeas72 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 2200 0 0 {name=M72
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 2200 3 0 {name=l190 lab=GND}
C {devices/lab_pin.sym} -1680 2240 2 0 {name=p523 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 2010 1 0 {name=p524 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 2200 0 0 {name=p525 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 2240 0 0 {name=x73}
C {devices/gnd.sym} -1520 2130 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -1580 2050 1 0 {name=p526 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 2050 1 0 {name=p527 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 2130 0 0 {name=Vmeas73 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 2200 0 0 {name=M73
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 2200 3 0 {name=l192 lab=GND}
C {devices/lab_pin.sym} -1460 2240 2 0 {name=p528 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 2010 1 0 {name=p529 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 2200 0 0 {name=p530 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 2240 0 0 {name=x74}
C {devices/gnd.sym} -1300 2130 0 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -1360 2050 1 0 {name=p531 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 2050 1 0 {name=p532 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 2130 0 0 {name=Vmeas74 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 2200 0 0 {name=M74
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 2200 3 0 {name=l194 lab=GND}
C {devices/lab_pin.sym} -1240 2240 2 0 {name=p533 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 2010 1 0 {name=p534 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 2200 0 0 {name=p535 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 2240 0 0 {name=x75}
C {devices/gnd.sym} -1080 2130 0 0 {name=l195 lab=GND}
C {devices/lab_pin.sym} -1140 2050 1 0 {name=p536 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 2050 1 0 {name=p537 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 2130 0 0 {name=Vmeas75 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 2200 0 0 {name=M75
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 2200 3 0 {name=l196 lab=GND}
C {devices/lab_pin.sym} -1020 2240 2 0 {name=p538 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 2010 1 0 {name=p539 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 2200 0 0 {name=p540 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 2240 0 0 {name=x76}
C {devices/gnd.sym} -860 2130 0 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -920 2050 1 0 {name=p541 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 2050 1 0 {name=p542 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 2130 0 0 {name=Vmeas76 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 2200 0 0 {name=M76
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 2200 3 0 {name=l198 lab=GND}
C {devices/lab_pin.sym} -800 2240 2 0 {name=p543 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 2010 1 0 {name=p544 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 2200 0 0 {name=p545 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 2240 0 0 {name=x77}
C {devices/gnd.sym} -640 2130 0 0 {name=l199 lab=GND}
C {devices/lab_pin.sym} -700 2050 1 0 {name=p546 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 2050 1 0 {name=p547 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 2130 0 0 {name=Vmeas77 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 2200 0 0 {name=M77
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 2200 3 0 {name=l200 lab=GND}
C {devices/lab_pin.sym} -580 2240 2 0 {name=p548 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 2010 1 0 {name=p549 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 2200 0 0 {name=p550 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 2240 0 0 {name=x78}
C {devices/gnd.sym} -420 2130 0 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -480 2050 1 0 {name=p551 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 2050 1 0 {name=p552 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 2130 0 0 {name=Vmeas78 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 2200 0 0 {name=M78
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 2200 3 0 {name=l202 lab=GND}
C {devices/lab_pin.sym} -360 2240 2 0 {name=p553 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 2010 1 0 {name=p554 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 2200 0 0 {name=p555 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 2240 0 0 {name=x79}
C {devices/gnd.sym} -200 2130 0 0 {name=l203 lab=GND}
C {devices/lab_pin.sym} -260 2050 1 0 {name=p556 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 2050 1 0 {name=p557 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 2130 0 0 {name=Vmeas79 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 2200 0 0 {name=M79
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 2200 3 0 {name=l204 lab=GND}
C {devices/lab_pin.sym} -140 2240 2 0 {name=p558 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 2010 1 0 {name=p559 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 2200 0 0 {name=p560 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 2760 0 0 {name=x80}
C {devices/gnd.sym} -2180 2650 0 0 {name=l205 lab=GND}
C {devices/lab_pin.sym} -2240 2570 1 0 {name=p561 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 2570 1 0 {name=p562 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 2650 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 2720 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 2720 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -2120 2760 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 2530 1 0 {name=p564 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 2720 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 2760 0 0 {name=x81}
C {devices/gnd.sym} -1960 2650 0 0 {name=l207 lab=GND}
C {devices/lab_pin.sym} -2020 2570 1 0 {name=p566 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 2570 1 0 {name=p567 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 2650 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 2720 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 2720 3 0 {name=l208 lab=GND}
C {devices/lab_pin.sym} -1900 2760 2 0 {name=p568 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 2530 1 0 {name=p569 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 2720 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 2760 0 0 {name=x82}
C {devices/gnd.sym} -1740 2650 0 0 {name=l209 lab=GND}
C {devices/lab_pin.sym} -1800 2570 1 0 {name=p571 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 2570 1 0 {name=p572 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 2650 0 0 {name=Vmeas82 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 2720 0 0 {name=M82
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 2720 3 0 {name=l210 lab=GND}
C {devices/lab_pin.sym} -1680 2760 2 0 {name=p573 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 2530 1 0 {name=p574 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 2720 0 0 {name=p575 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 2760 0 0 {name=x83}
C {devices/gnd.sym} -1520 2650 0 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} -1580 2570 1 0 {name=p576 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 2570 1 0 {name=p577 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 2650 0 0 {name=Vmeas83 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 2720 0 0 {name=M83
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 2720 3 0 {name=l212 lab=GND}
C {devices/lab_pin.sym} -1460 2760 2 0 {name=p578 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 2530 1 0 {name=p579 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 2720 0 0 {name=p580 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 2760 0 0 {name=x84}
C {devices/gnd.sym} -1300 2650 0 0 {name=l213 lab=GND}
C {devices/lab_pin.sym} -1360 2570 1 0 {name=p581 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 2570 1 0 {name=p582 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 2650 0 0 {name=Vmeas84 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 2720 0 0 {name=M84
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 2720 3 0 {name=l214 lab=GND}
C {devices/lab_pin.sym} -1240 2760 2 0 {name=p583 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 2530 1 0 {name=p584 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 2720 0 0 {name=p585 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 2760 0 0 {name=x85}
C {devices/gnd.sym} -1080 2650 0 0 {name=l215 lab=GND}
C {devices/lab_pin.sym} -1140 2570 1 0 {name=p586 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 2570 1 0 {name=p587 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 2650 0 0 {name=Vmeas85 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 2720 0 0 {name=M85
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 2720 3 0 {name=l216 lab=GND}
C {devices/lab_pin.sym} -1020 2760 2 0 {name=p588 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 2530 1 0 {name=p589 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 2720 0 0 {name=p590 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 2760 0 0 {name=x86}
C {devices/gnd.sym} -860 2650 0 0 {name=l217 lab=GND}
C {devices/lab_pin.sym} -920 2570 1 0 {name=p591 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 2570 1 0 {name=p592 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 2650 0 0 {name=Vmeas86 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 2720 0 0 {name=M86
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 2720 3 0 {name=l218 lab=GND}
C {devices/lab_pin.sym} -800 2760 2 0 {name=p593 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 2530 1 0 {name=p594 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 2720 0 0 {name=p595 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 2760 0 0 {name=x87}
C {devices/gnd.sym} -640 2650 0 0 {name=l219 lab=GND}
C {devices/lab_pin.sym} -700 2570 1 0 {name=p596 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 2570 1 0 {name=p597 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 2650 0 0 {name=Vmeas87 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 2720 0 0 {name=M87
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 2720 3 0 {name=l220 lab=GND}
C {devices/lab_pin.sym} -580 2760 2 0 {name=p598 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 2530 1 0 {name=p599 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 2720 0 0 {name=p600 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 2760 0 0 {name=x88}
C {devices/gnd.sym} -420 2650 0 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} -480 2570 1 0 {name=p601 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 2570 1 0 {name=p602 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 2650 0 0 {name=Vmeas88 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 2720 0 0 {name=M88
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 2720 3 0 {name=l222 lab=GND}
C {devices/lab_pin.sym} -360 2760 2 0 {name=p603 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 2530 1 0 {name=p604 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 2720 0 0 {name=p605 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 2760 0 0 {name=x89}
C {devices/gnd.sym} -200 2650 0 0 {name=l223 lab=GND}
C {devices/lab_pin.sym} -260 2570 1 0 {name=p606 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 2570 1 0 {name=p607 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 2650 0 0 {name=Vmeas89 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 2720 0 0 {name=M89
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 2720 3 0 {name=l224 lab=GND}
C {devices/lab_pin.sym} -140 2760 2 0 {name=p608 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 2530 1 0 {name=p609 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 2720 0 0 {name=p610 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -2120 3280 0 0 {name=x90}
C {devices/gnd.sym} -2180 3170 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -2240 3090 1 0 {name=p611 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2120 3090 1 0 {name=p612 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -2120 3170 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2140 3240 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2110 3240 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -2120 3280 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 3050 1 0 {name=p614 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2170 3240 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1900 3280 0 0 {name=x91}
C {devices/gnd.sym} -1960 3170 0 0 {name=l227 lab=GND}
C {devices/lab_pin.sym} -2020 3090 1 0 {name=p616 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1900 3090 1 0 {name=p617 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1900 3170 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1920 3240 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1890 3240 3 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -1900 3280 2 0 {name=p618 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 3050 1 0 {name=p619 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1950 3240 0 0 {name=p620 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1680 3280 0 0 {name=x92}
C {devices/gnd.sym} -1740 3170 0 0 {name=l229 lab=GND}
C {devices/lab_pin.sym} -1800 3090 1 0 {name=p621 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1680 3090 1 0 {name=p622 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1680 3170 0 0 {name=Vmeas92 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1700 3240 0 0 {name=M92
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1670 3240 3 0 {name=l230 lab=GND}
C {devices/lab_pin.sym} -1680 3280 2 0 {name=p623 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -1740 3050 1 0 {name=p624 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1730 3240 0 0 {name=p625 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1460 3280 0 0 {name=x93}
C {devices/gnd.sym} -1520 3170 0 0 {name=l231 lab=GND}
C {devices/lab_pin.sym} -1580 3090 1 0 {name=p626 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1460 3090 1 0 {name=p627 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1460 3170 0 0 {name=Vmeas93 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1480 3240 0 0 {name=M93
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1450 3240 3 0 {name=l232 lab=GND}
C {devices/lab_pin.sym} -1460 3280 2 0 {name=p628 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -1520 3050 1 0 {name=p629 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1510 3240 0 0 {name=p630 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1240 3280 0 0 {name=x94}
C {devices/gnd.sym} -1300 3170 0 0 {name=l233 lab=GND}
C {devices/lab_pin.sym} -1360 3090 1 0 {name=p631 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1240 3090 1 0 {name=p632 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1240 3170 0 0 {name=Vmeas94 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1260 3240 0 0 {name=M94
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1230 3240 3 0 {name=l234 lab=GND}
C {devices/lab_pin.sym} -1240 3280 2 0 {name=p633 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1300 3050 1 0 {name=p634 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1290 3240 0 0 {name=p635 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -1020 3280 0 0 {name=x95}
C {devices/gnd.sym} -1080 3170 0 0 {name=l235 lab=GND}
C {devices/lab_pin.sym} -1140 3090 1 0 {name=p636 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1020 3090 1 0 {name=p637 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1020 3170 0 0 {name=Vmeas95 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1040 3240 0 0 {name=M95
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1010 3240 3 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} -1020 3280 2 0 {name=p638 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1080 3050 1 0 {name=p639 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -1070 3240 0 0 {name=p640 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -800 3280 0 0 {name=x96}
C {devices/gnd.sym} -860 3170 0 0 {name=l237 lab=GND}
C {devices/lab_pin.sym} -920 3090 1 0 {name=p641 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -800 3090 1 0 {name=p642 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -800 3170 0 0 {name=Vmeas96 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -820 3240 0 0 {name=M96
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -790 3240 3 0 {name=l238 lab=GND}
C {devices/lab_pin.sym} -800 3280 2 0 {name=p643 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -860 3050 1 0 {name=p644 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -850 3240 0 0 {name=p645 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -580 3280 0 0 {name=x97}
C {devices/gnd.sym} -640 3170 0 0 {name=l239 lab=GND}
C {devices/lab_pin.sym} -700 3090 1 0 {name=p646 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -580 3090 1 0 {name=p647 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -580 3170 0 0 {name=Vmeas97 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -600 3240 0 0 {name=M97
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -570 3240 3 0 {name=l240 lab=GND}
C {devices/lab_pin.sym} -580 3280 2 0 {name=p648 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -640 3050 1 0 {name=p649 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -630 3240 0 0 {name=p650 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -360 3280 0 0 {name=x98}
C {devices/gnd.sym} -420 3170 0 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} -480 3090 1 0 {name=p651 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -360 3090 1 0 {name=p652 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -360 3170 0 0 {name=Vmeas98 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -380 3240 0 0 {name=M98
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -350 3240 3 0 {name=l242 lab=GND}
C {devices/lab_pin.sym} -360 3280 2 0 {name=p653 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -420 3050 1 0 {name=p654 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -410 3240 0 0 {name=p655 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/synapse/6T1R.sym} -140 3280 0 0 {name=x99}
C {devices/gnd.sym} -200 3170 0 0 {name=l243 lab=GND}
C {devices/lab_pin.sym} -260 3090 1 0 {name=p656 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -140 3090 1 0 {name=p657 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -140 3170 0 0 {name=Vmeas99 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 3240 0 0 {name=M99
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 3240 3 0 {name=l244 lab=GND}
C {devices/lab_pin.sym} -140 3280 2 0 {name=p658 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -200 3050 1 0 {name=p659 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -190 3240 0 0 {name=p660 sig_type=std_logic lab=ctrl_pos}
