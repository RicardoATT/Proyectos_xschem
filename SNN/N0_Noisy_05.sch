v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -1200 800 -800 {flags=graph
y1=-0.053
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vps1; vpre1\\"
\\"vps2; vpre2\\"
\\"vps3; vpre3\\"
\\"vps4; vpre4\\"
\\"vps5; vpre5\\"
\\"vps6; vpre6\\"
\\"vps7; vpre7\\"
\\"vps8; vpre8\\"
\\"vps9; vpre9\\""}
B 2 0 -400 800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Weights updating ;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 1600 -2800 2400 -2400 {flags=graph
y1=-2.2e-07
y2=2.4e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas1000)\\"
\\"Ip1;i(vmeas8)\\"
\\"Ip2;i(vmeas6)\\""}
B 2 3200 -2400 4000 -2000 {flags=graph
y1=0.218312
y2=1.76071
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="\\"0; N0\\"
\\"1; N1\\"
\\"2; N2\\"
\\"3; N3\\"
\\"4; N4\\"
\\"5; N5\\"
\\"6; N6\\"
\\"7; N7\\"
\\"8; N8\\"
\\"9; N9\\""}
B 2 0 -800 800 -400 {flags=graph
y1=2.3
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x19.xr1.n1#ngap -\\"
\\"S20; 5 n.x29.xr1.n1#ngap -\\"
\\"S30; 5 n.x39.xr1.n1#ngap -\\"
\\"S40; 5 n.x49.xr1.n1#ngap -\\"
\\"S50; 5 n.x59.xr1.n1#ngap -\\"
\\"S60; 5 n.x69.xr1.n1#ngap -\\"
\\"S70; 5 n.x79.xr1.n1#ngap -\\"
\\"S80; 5 n.x89.xr1.n1#ngap -\\"
\\"S90; 5 n.x99.xr1.n1#ngap -\\"
\\"S100; 5 n.x109.xr1.n1#ngap -\\"
\\"S110; 5 n.x119.xr1.n1#ngap -\\"
\\"S120; 5 n.x129.xr1.n1#ngap -\\"
\\"S130; 5 n.x139.xr1.n1#ngap -\\"
\\"S140; 5 n.x149.xr1.n1#ngap -\\"
\\"S150; 5 n.x159.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 800 -800 1600 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=0.019
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 2400 -1200 3200 -800 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 3200 -2000 4000 -1600 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 3200 -1600 4000 -1200 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 3200 -1200 4000 -800 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 2400 -800 3200 -400 {flags=graph
y1=0.003
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 2400 -400 3200 0 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 3200 -800 4000 -400 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 3200 -400 4000 0 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 800 -1200 1600 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
B 2 800 -400 1600 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 2400 -2400 3200 -2000 {flags=graph
y1=-0.0560003
y2=1.3952
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="p0
p1
p2
p3
p4
p5
p6
p7
p8
p9"}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="inh0
inh1
inh2
inh3
inh4
inh5
inh6
inh7
inh8
inh9"}
B 2 2400 -2800 3200 -2400 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="4 7 7 8 9 10 11"
node="p0
p8
vdd_syn9
vdd_syn8
vdd_syn7
vdd_syn6
vdd_syn5
"}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=-0.025
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color=9
node=inh_d}
B 2 3200 -2800 4000 -2400 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-3e-05
x2=0.00012
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color=4
node=ctrl_newpattern}
N 20 -2620 20 -2600 {
lab=GND}
N 20 -2700 20 -2680 {
lab=vdd_in}
N 100 -2620 100 -2600 {
lab=GND}
N 100 -2700 100 -2680 {
lab=vdd_pre}
N -3760 -6340 -3760 -6320 {
lab=GND}
N -3760 -6500 -3760 -6480 {
lab=vdd_pre}
N -3940 -6430 -3940 -6410 {
lab=vc2}
N -3940 -6460 -3930 -6460 {
lab=vdd_in}
N -3930 -6490 -3930 -6460 {
lab=vdd_in}
N -3940 -6490 -3930 -6490 {
lab=vdd_in}
N -4020 -6460 -3980 -6460 {
lab=#net1}
N -4060 -6490 -3940 -6490 {
lab=vdd_in}
N -4070 -6460 -4060 -6460 {
lab=vdd_in}
N -4070 -6490 -4070 -6460 {
lab=vdd_in}
N -4070 -6490 -4060 -6490 {
lab=vdd_in}
N -4060 -6430 -4060 -6410 {
lab=#net1}
N -4060 -6410 -4000 -6410 {
lab=#net1}
N -4000 -6460 -4000 -6410 {
lab=#net1}
N -3080 -6800 -3080 -6790 {
lab=GND}
N -3080 -6910 -3080 -6900 {
lab=vdd_syn0}
N -3020 -6720 -3010 -6720 {
lab=GND}
N -3020 -6690 -3020 -6680 {
lab=p0}
N 20 -2200 20 -2180 {
lab=GND}
N 20 -2280 20 -2260 {
lab=uw}
N 200 -2200 200 -2180 {
lab=GND}
N 200 -2280 200 -2260 {
lab=training}
N -3620 -6410 -3610 -6410 {
lab=vpre2}
N 460 -2200 460 -2180 {
lab=GND}
N 460 -2280 460 -2260 {
lab=inference}
N -4080 -6410 -4060 -6410 {
lab=#net1}
N 20 -2340 20 -2320 {
lab=GND}
N 20 -2420 20 -2400 {
lab=ctrl_wu}
N 190 -2480 190 -2460 {
lab=GND}
N 190 -2560 190 -2540 {
lab=vb_wu}
N 190 -2620 190 -2600 {
lab=GND}
N 190 -2700 190 -2680 {
lab=vdd_pos}
N 280 -2620 280 -2600 {
lab=GND}
N 280 -2700 280 -2680 {
lab=vdd_wu}
N 360 -2620 360 -2600 {
lab=GND}
N 360 -2700 360 -2680 {
lab=vdd_tr}
N 110 -2480 110 -2460 {
lab=GND}
N 110 -2560 110 -2540 {
lab=vb_pre}
N 340 -2480 340 -2460 {
lab=GND}
N 340 -2560 340 -2540 {
lab=vb_pos}
N -3150 -6860 -3140 -6860 {
lab=vpres1}
N -3020 -6860 -3010 -6860 {
lab=w_px}
N -3760 -6790 -3760 -6770 {
lab=GND}
N -3760 -6950 -3760 -6930 {
lab=vdd_pre}
N -3940 -6880 -3940 -6860 {
lab=vc1}
N -3940 -6910 -3930 -6910 {
lab=vdd_in}
N -3930 -6940 -3930 -6910 {
lab=vdd_in}
N -3940 -6940 -3930 -6940 {
lab=vdd_in}
N -4020 -6910 -3980 -6910 {
lab=#net2}
N -4060 -6940 -3940 -6940 {
lab=vdd_in}
N -4070 -6910 -4060 -6910 {
lab=vdd_in}
N -4070 -6940 -4070 -6910 {
lab=vdd_in}
N -4070 -6940 -4060 -6940 {
lab=vdd_in}
N -4060 -6880 -4060 -6860 {
lab=#net2}
N -4060 -6860 -4000 -6860 {
lab=#net2}
N -4000 -6910 -4000 -6860 {
lab=#net2}
N -3080 -6350 -3080 -6340 {
lab=GND}
N -3080 -6460 -3080 -6450 {
lab=vdd_syn0}
N -3020 -6270 -3010 -6270 {
lab=GND}
N -3020 -6240 -3020 -6230 {
lab=p0}
N -3620 -6860 -3610 -6860 {
lab=vpre1}
N -4080 -6860 -4060 -6860 {
lab=#net2}
N -3390 -6670 -3390 -6660 {
lab=GND}
N -3340 -6710 -3330 -6710 {
lab=vpres1}
N -3390 -6820 -3390 -6810 {
lab=GND}
N -3340 -6860 -3330 -6860 {
lab=vpres1}
N -3150 -6410 -3140 -6410 {
lab=vpres2}
N -3020 -6410 -3010 -6410 {
lab=b_px}
N -3070 -6270 -3060 -6270 {
lab=ctrl_pos}
N -3070 -6720 -3060 -6720 {
lab=ctrl_pos}
N 170 -2340 170 -2320 {
lab=GND}
N 170 -2420 170 -2400 {
lab=ctrl_inf}
N 520 -2620 520 -2600 {
lab=GND}
N 520 -2700 520 -2680 {
lab=vdd_inh}
N 120 -4590 120 -4580 {
lab=vdd_inh}
N 120 -4300 120 -4290 {
lab=GND}
N 300 -4440 310 -4440 {
lab=inh}
N 20 -2480 20 -2460 {
lab=GND}
N 20 -2560 20 -2540 {
lab=vlky_pre}
N -3940 -6860 -3860 -6860 {
lab=vc1}
N -3860 -6900 -3850 -6900 {
lab=vlky_pre}
N -3860 -6820 -3850 -6820 {
lab=vb_pre}
N -3860 -6450 -3850 -6450 {
lab=vlky_pre}
N -3940 -6410 -3860 -6410 {
lab=vc2}
N -3860 -6370 -3850 -6370 {
lab=vb_pre}
N 20 -2760 20 -2740 {
lab=GND}
N 20 -2840 20 -2820 {
lab=vdd_syn0}
N -3450 -6680 -3440 -6680 {
lab=vb_wu}
N -3020 -6840 -3020 -6820 {
lab=#net3}
N -3020 -6760 -3020 -6750 {
lab=#net4}
N -3020 -6390 -3020 -6370 {
lab=#net5}
N -3020 -6310 -3020 -6300 {
lab=#net6}
N -3080 -5900 -3080 -5890 {
lab=GND}
N -3080 -6010 -3080 -6000 {
lab=vdd_syn0}
N -3020 -5820 -3010 -5820 {
lab=GND}
N -3020 -5790 -3020 -5780 {
lab=p0}
N -3150 -5960 -3140 -5960 {
lab=vpres3}
N -3020 -5960 -3010 -5960 {
lab=w_px}
N -3070 -5820 -3060 -5820 {
lab=ctrl_pos}
N -3020 -5940 -3020 -5920 {
lab=#net7}
N -3020 -5860 -3020 -5850 {
lab=#net8}
N -3080 -5450 -3080 -5440 {
lab=GND}
N -3080 -5560 -3080 -5550 {
lab=vdd_syn0}
N -3020 -5370 -3010 -5370 {
lab=GND}
N -3020 -5340 -3020 -5330 {
lab=p0}
N -3150 -5510 -3140 -5510 {
lab=vpres4}
N -3020 -5510 -3010 -5510 {
lab=b_px}
N -3070 -5370 -3060 -5370 {
lab=ctrl_pos}
N -3020 -5490 -3020 -5470 {
lab=#net9}
N -3020 -5410 -3020 -5400 {
lab=#net10}
N -3080 -5000 -3080 -4990 {
lab=GND}
N -3080 -5110 -3080 -5100 {
lab=vdd_syn0}
N -3020 -4920 -3010 -4920 {
lab=GND}
N -3020 -4890 -3020 -4880 {
lab=p0}
N -3150 -5060 -3140 -5060 {
lab=vpres5}
N -3020 -5060 -3010 -5060 {
lab=w_px}
N -3070 -4920 -3060 -4920 {
lab=ctrl_pos}
N -3020 -5040 -3020 -5020 {
lab=#net11}
N -3020 -4960 -3020 -4950 {
lab=#net12}
N -3080 -4550 -3080 -4540 {
lab=GND}
N -3080 -4660 -3080 -4650 {
lab=vdd_syn0}
N -3020 -4470 -3010 -4470 {
lab=GND}
N -3020 -4440 -3020 -4430 {
lab=p0}
N -3150 -4610 -3140 -4610 {
lab=vpres6}
N -3020 -4610 -3010 -4610 {
lab=b_px}
N -3070 -4470 -3060 -4470 {
lab=ctrl_pos}
N -3020 -4590 -3020 -4570 {
lab=#net13}
N -3020 -4510 -3020 -4500 {
lab=#net14}
N -3080 -4100 -3080 -4090 {
lab=GND}
N -3080 -4210 -3080 -4200 {
lab=vdd_syn0}
N -3020 -4020 -3010 -4020 {
lab=GND}
N -3020 -3990 -3020 -3980 {
lab=p0}
N -3150 -4160 -3140 -4160 {
lab=vpres7}
N -3020 -4160 -3010 -4160 {
lab=b_px}
N -3070 -4020 -3060 -4020 {
lab=ctrl_pos}
N -3020 -4140 -3020 -4120 {
lab=#net15}
N -3020 -4060 -3020 -4050 {
lab=#net16}
N -3080 -3650 -3080 -3640 {
lab=GND}
N -3080 -3760 -3080 -3750 {
lab=vdd_syn0}
N -3020 -3570 -3010 -3570 {
lab=GND}
N -3020 -3540 -3020 -3530 {
lab=p0}
N -3150 -3710 -3140 -3710 {
lab=vpres8}
N -3020 -3710 -3010 -3710 {
lab=w_px}
N -3070 -3570 -3060 -3570 {
lab=ctrl_pos}
N -3020 -3690 -3020 -3670 {
lab=#net17}
N -3020 -3610 -3020 -3600 {
lab=#net18}
N -3080 -3200 -3080 -3190 {
lab=GND}
N -3080 -3310 -3080 -3300 {
lab=vdd_syn0}
N -3020 -3120 -3010 -3120 {
lab=GND}
N -3020 -3090 -3020 -3080 {
lab=p0}
N -3150 -3260 -3140 -3260 {
lab=vpres9}
N -3020 -3260 -3010 -3260 {
lab=b_px}
N -3070 -3120 -3060 -3120 {
lab=ctrl_pos}
N -3020 -3240 -3020 -3220 {
lab=#net19}
N -3020 -3160 -3020 -3150 {
lab=#net20}
N -3760 -5440 -3760 -5420 {
lab=GND}
N -3760 -5600 -3760 -5580 {
lab=vdd_pre}
N -3940 -5530 -3940 -5510 {
lab=vc4}
N -3940 -5560 -3930 -5560 {
lab=vdd_in}
N -3930 -5590 -3930 -5560 {
lab=vdd_in}
N -3940 -5590 -3930 -5590 {
lab=vdd_in}
N -4020 -5560 -3980 -5560 {
lab=#net21}
N -4060 -5590 -3940 -5590 {
lab=vdd_in}
N -4070 -5560 -4060 -5560 {
lab=vdd_in}
N -4070 -5590 -4070 -5560 {
lab=vdd_in}
N -4070 -5590 -4060 -5590 {
lab=vdd_in}
N -4060 -5530 -4060 -5510 {
lab=#net21}
N -4060 -5510 -4000 -5510 {
lab=#net21}
N -4000 -5560 -4000 -5510 {
lab=#net21}
N -3620 -5510 -3610 -5510 {
lab=vpre4}
N -4080 -5510 -4060 -5510 {
lab=#net21}
N -3760 -5890 -3760 -5870 {
lab=GND}
N -3760 -6050 -3760 -6030 {
lab=vdd_pre}
N -3940 -5980 -3940 -5960 {
lab=vc3}
N -3940 -6010 -3930 -6010 {
lab=vdd_in}
N -3930 -6040 -3930 -6010 {
lab=vdd_in}
N -3940 -6040 -3930 -6040 {
lab=vdd_in}
N -4020 -6010 -3980 -6010 {
lab=#net22}
N -4060 -6040 -3940 -6040 {
lab=vdd_in}
N -4070 -6010 -4060 -6010 {
lab=vdd_in}
N -4070 -6040 -4070 -6010 {
lab=vdd_in}
N -4070 -6040 -4060 -6040 {
lab=vdd_in}
N -4060 -5980 -4060 -5960 {
lab=#net22}
N -4060 -5960 -4000 -5960 {
lab=#net22}
N -4000 -6010 -4000 -5960 {
lab=#net22}
N -3620 -5960 -3610 -5960 {
lab=vpre3}
N -4080 -5960 -4060 -5960 {
lab=#net22}
N -3940 -5960 -3860 -5960 {
lab=vc3}
N -3860 -6000 -3850 -6000 {
lab=vlky_pre}
N -3860 -5920 -3850 -5920 {
lab=vb_pre}
N -3860 -5550 -3850 -5550 {
lab=vlky_pre}
N -3940 -5510 -3860 -5510 {
lab=vc4}
N -3860 -5470 -3850 -5470 {
lab=vb_pre}
N -3760 -4540 -3760 -4520 {
lab=GND}
N -3760 -4700 -3760 -4680 {
lab=vdd_pre}
N -3940 -4630 -3940 -4610 {
lab=vc6}
N -3940 -4660 -3930 -4660 {
lab=vdd_in}
N -3930 -4690 -3930 -4660 {
lab=vdd_in}
N -3940 -4690 -3930 -4690 {
lab=vdd_in}
N -4020 -4660 -3980 -4660 {
lab=#net23}
N -4060 -4690 -3940 -4690 {
lab=vdd_in}
N -4070 -4660 -4060 -4660 {
lab=vdd_in}
N -4070 -4690 -4070 -4660 {
lab=vdd_in}
N -4070 -4690 -4060 -4690 {
lab=vdd_in}
N -4060 -4630 -4060 -4610 {
lab=#net23}
N -4060 -4610 -4000 -4610 {
lab=#net23}
N -4000 -4660 -4000 -4610 {
lab=#net23}
N -3620 -4610 -3610 -4610 {
lab=vpre6}
N -4080 -4610 -4060 -4610 {
lab=#net23}
N -3760 -4990 -3760 -4970 {
lab=GND}
N -3760 -5150 -3760 -5130 {
lab=vdd_pre}
N -3940 -5080 -3940 -5060 {
lab=vc5}
N -3940 -5110 -3930 -5110 {
lab=vdd_in}
N -3930 -5140 -3930 -5110 {
lab=vdd_in}
N -3940 -5140 -3930 -5140 {
lab=vdd_in}
N -4020 -5110 -3980 -5110 {
lab=#net24}
N -4060 -5140 -3940 -5140 {
lab=vdd_in}
N -4070 -5110 -4060 -5110 {
lab=vdd_in}
N -4070 -5140 -4070 -5110 {
lab=vdd_in}
N -4070 -5140 -4060 -5140 {
lab=vdd_in}
N -4060 -5080 -4060 -5060 {
lab=#net24}
N -4060 -5060 -4000 -5060 {
lab=#net24}
N -4000 -5110 -4000 -5060 {
lab=#net24}
N -3620 -5060 -3610 -5060 {
lab=vpre5}
N -4080 -5060 -4060 -5060 {
lab=#net24}
N -3940 -5060 -3860 -5060 {
lab=vc5}
N -3860 -5100 -3850 -5100 {
lab=vlky_pre}
N -3860 -5020 -3850 -5020 {
lab=vb_pre}
N -3860 -4650 -3850 -4650 {
lab=vlky_pre}
N -3940 -4610 -3860 -4610 {
lab=vc6}
N -3860 -4570 -3850 -4570 {
lab=vb_pre}
N -3760 -3640 -3760 -3620 {
lab=GND}
N -3760 -3800 -3760 -3780 {
lab=vdd_pre}
N -3940 -3730 -3940 -3710 {
lab=vc8}
N -3940 -3760 -3930 -3760 {
lab=vdd_in}
N -3930 -3790 -3930 -3760 {
lab=vdd_in}
N -3940 -3790 -3930 -3790 {
lab=vdd_in}
N -4020 -3760 -3980 -3760 {
lab=#net25}
N -4060 -3790 -3940 -3790 {
lab=vdd_in}
N -4070 -3760 -4060 -3760 {
lab=vdd_in}
N -4070 -3790 -4070 -3760 {
lab=vdd_in}
N -4070 -3790 -4060 -3790 {
lab=vdd_in}
N -4060 -3730 -4060 -3710 {
lab=#net25}
N -4060 -3710 -4000 -3710 {
lab=#net25}
N -4000 -3760 -4000 -3710 {
lab=#net25}
N -3620 -3710 -3610 -3710 {
lab=vpre8}
N -4080 -3710 -4060 -3710 {
lab=#net25}
N -3760 -4090 -3760 -4070 {
lab=GND}
N -3760 -4250 -3760 -4230 {
lab=vdd_pre}
N -3940 -4180 -3940 -4160 {
lab=vc7}
N -3940 -4210 -3930 -4210 {
lab=vdd_in}
N -3930 -4240 -3930 -4210 {
lab=vdd_in}
N -3940 -4240 -3930 -4240 {
lab=vdd_in}
N -4020 -4210 -3980 -4210 {
lab=#net26}
N -4060 -4240 -3940 -4240 {
lab=vdd_in}
N -4070 -4210 -4060 -4210 {
lab=vdd_in}
N -4070 -4240 -4070 -4210 {
lab=vdd_in}
N -4070 -4240 -4060 -4240 {
lab=vdd_in}
N -4060 -4180 -4060 -4160 {
lab=#net26}
N -4060 -4160 -4000 -4160 {
lab=#net26}
N -4000 -4210 -4000 -4160 {
lab=#net26}
N -3620 -4160 -3610 -4160 {
lab=vpre7}
N -4080 -4160 -4060 -4160 {
lab=#net26}
N -3940 -4160 -3860 -4160 {
lab=vc7}
N -3860 -4200 -3850 -4200 {
lab=vlky_pre}
N -3860 -4120 -3850 -4120 {
lab=vb_pre}
N -3860 -3750 -3850 -3750 {
lab=vlky_pre}
N -3940 -3710 -3860 -3710 {
lab=vc8}
N -3860 -3670 -3850 -3670 {
lab=vb_pre}
N -3760 -3190 -3760 -3170 {
lab=GND}
N -3760 -3350 -3760 -3330 {
lab=vdd_pre}
N -3940 -3280 -3940 -3260 {
lab=vc9}
N -3940 -3310 -3930 -3310 {
lab=vdd_in}
N -3930 -3340 -3930 -3310 {
lab=vdd_in}
N -3940 -3340 -3930 -3340 {
lab=vdd_in}
N -4020 -3310 -3980 -3310 {
lab=#net27}
N -4060 -3340 -3940 -3340 {
lab=vdd_in}
N -4070 -3310 -4060 -3310 {
lab=vdd_in}
N -4070 -3340 -4070 -3310 {
lab=vdd_in}
N -4070 -3340 -4060 -3340 {
lab=vdd_in}
N -4060 -3280 -4060 -3260 {
lab=#net27}
N -4060 -3260 -4000 -3260 {
lab=#net27}
N -4000 -3310 -4000 -3260 {
lab=#net27}
N -3620 -3260 -3610 -3260 {
lab=vpre9}
N -4080 -3260 -4060 -3260 {
lab=#net27}
N -3860 -3300 -3850 -3300 {
lab=vlky_pre}
N -3940 -3260 -3860 -3260 {
lab=vc9}
N -3860 -3220 -3850 -3220 {
lab=vb_pre}
N 30 -4360 40 -4360 {
lab=N0}
N -3080 -2750 -3080 -2740 {
lab=GND}
N -3080 -2860 -3080 -2850 {
lab=vdd_syn0}
N -3020 -2670 -3010 -2670 {
lab=GND}
N -3020 -2640 -3020 -2630 {
lab=p0}
N -3150 -2810 -3140 -2810 {
lab=vpres10}
N -3020 -2810 -3010 -2810 {
lab=b_px}
N -3070 -2670 -3060 -2670 {
lab=ctrl_pos}
N -3020 -2790 -3020 -2770 {
lab=#net28}
N -3020 -2710 -3020 -2700 {
lab=#net29}
N -3080 -2300 -3080 -2290 {
lab=GND}
N -3080 -2410 -3080 -2400 {
lab=vdd_syn0}
N -3020 -2220 -3010 -2220 {
lab=GND}
N -3020 -2190 -3020 -2180 {
lab=p0}
N -3150 -2360 -3140 -2360 {
lab=vpres11}
N -3020 -2360 -3010 -2360 {
lab=w_px}
N -3070 -2220 -3060 -2220 {
lab=ctrl_pos}
N -3020 -2340 -3020 -2320 {
lab=#net30}
N -3020 -2260 -3020 -2250 {
lab=#net31}
N -3080 -1850 -3080 -1840 {
lab=GND}
N -3080 -1960 -3080 -1950 {
lab=vdd_syn0}
N -3020 -1770 -3010 -1770 {
lab=GND}
N -3020 -1740 -3020 -1730 {
lab=p0}
N -3150 -1910 -3140 -1910 {
lab=vpres12}
N -3020 -1910 -3010 -1910 {
lab=b_px}
N -3070 -1770 -3060 -1770 {
lab=ctrl_pos}
N -3020 -1890 -3020 -1870 {
lab=#net32}
N -3020 -1810 -3020 -1800 {
lab=#net33}
N -3080 -1400 -3080 -1390 {
lab=GND}
N -3080 -1510 -3080 -1500 {
lab=vdd_syn0}
N -3020 -1320 -3010 -1320 {
lab=GND}
N -3020 -1290 -3020 -1280 {
lab=p0}
N -3150 -1460 -3140 -1460 {
lab=vpres13}
N -3020 -1460 -3010 -1460 {
lab=w_px}
N -3070 -1320 -3060 -1320 {
lab=ctrl_pos}
N -3020 -1440 -3020 -1420 {
lab=#net34}
N -3020 -1360 -3020 -1350 {
lab=#net35}
N -3080 -950 -3080 -940 {
lab=GND}
N -3080 -1060 -3080 -1050 {
lab=vdd_syn0}
N -3020 -870 -3010 -870 {
lab=GND}
N -3020 -840 -3020 -830 {
lab=p0}
N -3070 -870 -3060 -870 {
lab=ctrl_pos}
N -3020 -990 -3020 -970 {
lab=#net36}
N -3020 -910 -3020 -900 {
lab=#net37}
N -3080 -500 -3080 -490 {
lab=GND}
N -3080 -610 -3080 -600 {
lab=vdd_syn0}
N -3020 -420 -3010 -420 {
lab=GND}
N -3020 -390 -3020 -380 {
lab=p0}
N -3020 -560 -3010 -560 {
lab=w_px}
N -3070 -420 -3060 -420 {
lab=ctrl_pos}
N -3020 -540 -3020 -520 {
lab=#net38}
N -3020 -460 -3020 -450 {
lab=#net39}
N -3760 -2740 -3760 -2720 {
lab=GND}
N -3760 -2900 -3760 -2880 {
lab=vdd_pre}
N -3940 -2830 -3940 -2810 {
lab=vc10}
N -3940 -2860 -3930 -2860 {
lab=vdd_in}
N -3930 -2890 -3930 -2860 {
lab=vdd_in}
N -3940 -2890 -3930 -2890 {
lab=vdd_in}
N -4020 -2860 -3980 -2860 {
lab=#net40}
N -4060 -2890 -3940 -2890 {
lab=vdd_in}
N -4070 -2860 -4060 -2860 {
lab=vdd_in}
N -4070 -2890 -4070 -2860 {
lab=vdd_in}
N -4070 -2890 -4060 -2890 {
lab=vdd_in}
N -4060 -2830 -4060 -2810 {
lab=#net40}
N -4060 -2810 -4000 -2810 {
lab=#net40}
N -4000 -2860 -4000 -2810 {
lab=#net40}
N -3620 -2810 -3610 -2810 {
lab=vpre10}
N -4080 -2810 -4060 -2810 {
lab=#net40}
N -3860 -2850 -3850 -2850 {
lab=vlky_pre}
N -3940 -2810 -3860 -2810 {
lab=vc10}
N -3860 -2770 -3850 -2770 {
lab=vb_pre}
N -3760 -1840 -3760 -1820 {
lab=GND}
N -3760 -2000 -3760 -1980 {
lab=vdd_pre}
N -3940 -1930 -3940 -1910 {
lab=vc12}
N -3940 -1960 -3930 -1960 {
lab=vdd_in}
N -3930 -1990 -3930 -1960 {
lab=vdd_in}
N -3940 -1990 -3930 -1990 {
lab=vdd_in}
N -4020 -1960 -3980 -1960 {
lab=#net41}
N -4060 -1990 -3940 -1990 {
lab=vdd_in}
N -4070 -1960 -4060 -1960 {
lab=vdd_in}
N -4070 -1990 -4070 -1960 {
lab=vdd_in}
N -4070 -1990 -4060 -1990 {
lab=vdd_in}
N -4060 -1930 -4060 -1910 {
lab=#net41}
N -4060 -1910 -4000 -1910 {
lab=#net41}
N -4000 -1960 -4000 -1910 {
lab=#net41}
N -3620 -1910 -3610 -1910 {
lab=vpre12}
N -4080 -1910 -4060 -1910 {
lab=#net41}
N -3760 -2290 -3760 -2270 {
lab=GND}
N -3760 -2450 -3760 -2430 {
lab=vdd_pre}
N -3940 -2380 -3940 -2360 {
lab=vc11}
N -3940 -2410 -3930 -2410 {
lab=vdd_in}
N -3930 -2440 -3930 -2410 {
lab=vdd_in}
N -3940 -2440 -3930 -2440 {
lab=vdd_in}
N -4020 -2410 -3980 -2410 {
lab=#net42}
N -4060 -2440 -3940 -2440 {
lab=vdd_in}
N -4070 -2410 -4060 -2410 {
lab=vdd_in}
N -4070 -2440 -4070 -2410 {
lab=vdd_in}
N -4070 -2440 -4060 -2440 {
lab=vdd_in}
N -4060 -2380 -4060 -2360 {
lab=#net42}
N -4060 -2360 -4000 -2360 {
lab=#net42}
N -4000 -2410 -4000 -2360 {
lab=#net42}
N -3620 -2360 -3610 -2360 {
lab=vpre11}
N -4080 -2360 -4060 -2360 {
lab=#net42}
N -3940 -2360 -3860 -2360 {
lab=vc11}
N -3860 -2400 -3850 -2400 {
lab=vlky_pre}
N -3860 -2320 -3850 -2320 {
lab=vb_pre}
N -3860 -1950 -3850 -1950 {
lab=vlky_pre}
N -3940 -1910 -3860 -1910 {
lab=vc12}
N -3860 -1870 -3850 -1870 {
lab=vb_pre}
N -3760 -940 -3760 -920 {
lab=GND}
N -3760 -1100 -3760 -1080 {
lab=vdd_pre}
N -3940 -1030 -3940 -1010 {
lab=vc14}
N -3940 -1060 -3930 -1060 {
lab=vdd_in}
N -3930 -1090 -3930 -1060 {
lab=vdd_in}
N -3940 -1090 -3930 -1090 {
lab=vdd_in}
N -4020 -1060 -3980 -1060 {
lab=#net43}
N -4060 -1090 -3940 -1090 {
lab=vdd_in}
N -4070 -1060 -4060 -1060 {
lab=vdd_in}
N -4070 -1090 -4070 -1060 {
lab=vdd_in}
N -4070 -1090 -4060 -1090 {
lab=vdd_in}
N -4060 -1030 -4060 -1010 {
lab=#net43}
N -4060 -1010 -4000 -1010 {
lab=#net43}
N -4000 -1060 -4000 -1010 {
lab=#net43}
N -3620 -1010 -3610 -1010 {
lab=vpre14}
N -4080 -1010 -4060 -1010 {
lab=#net43}
N -3760 -1390 -3760 -1370 {
lab=GND}
N -3760 -1550 -3760 -1530 {
lab=vdd_pre}
N -3940 -1480 -3940 -1460 {
lab=vc13}
N -3940 -1510 -3930 -1510 {
lab=vdd_in}
N -3930 -1540 -3930 -1510 {
lab=vdd_in}
N -3940 -1540 -3930 -1540 {
lab=vdd_in}
N -4020 -1510 -3980 -1510 {
lab=#net44}
N -4060 -1540 -3940 -1540 {
lab=vdd_in}
N -4070 -1510 -4060 -1510 {
lab=vdd_in}
N -4070 -1540 -4070 -1510 {
lab=vdd_in}
N -4070 -1540 -4060 -1540 {
lab=vdd_in}
N -4060 -1480 -4060 -1460 {
lab=#net44}
N -4060 -1460 -4000 -1460 {
lab=#net44}
N -4000 -1510 -4000 -1460 {
lab=#net44}
N -3620 -1460 -3610 -1460 {
lab=vpre13}
N -4080 -1460 -4060 -1460 {
lab=#net44}
N -3940 -1460 -3860 -1460 {
lab=vc13}
N -3860 -1500 -3850 -1500 {
lab=vlky_pre}
N -3860 -1420 -3850 -1420 {
lab=vb_pre}
N -3860 -1050 -3850 -1050 {
lab=vlky_pre}
N -3940 -1010 -3860 -1010 {
lab=vc14}
N -3860 -970 -3850 -970 {
lab=vb_pre}
N -3760 -490 -3760 -470 {
lab=GND}
N -3760 -650 -3760 -630 {
lab=vdd_pre}
N -3940 -580 -3940 -560 {
lab=vc15}
N -3940 -610 -3930 -610 {
lab=vdd_in}
N -3930 -640 -3930 -610 {
lab=vdd_in}
N -3940 -640 -3930 -640 {
lab=vdd_in}
N -4020 -610 -3980 -610 {
lab=#net45}
N -4060 -640 -3940 -640 {
lab=vdd_in}
N -4070 -610 -4060 -610 {
lab=vdd_in}
N -4070 -640 -4070 -610 {
lab=vdd_in}
N -4070 -640 -4060 -640 {
lab=vdd_in}
N -4060 -580 -4060 -560 {
lab=#net45}
N -4060 -560 -4000 -560 {
lab=#net45}
N -4000 -610 -4000 -560 {
lab=#net45}
N -3620 -560 -3610 -560 {
lab=vpre15}
N -4080 -560 -4060 -560 {
lab=#net45}
N -3860 -600 -3850 -600 {
lab=vlky_pre}
N -3940 -560 -3860 -560 {
lab=vc15}
N -3860 -520 -3850 -520 {
lab=vb_pre}
N -3450 -6890 -3440 -6890 {
lab=ctrl_inf}
N -3390 -6770 -3390 -6750 {
lab=vdd_wu}
N -3390 -6920 -3390 -6900 {
lab=vdd_inf}
N -3450 -6740 -3440 -6740 {
lab=ctrl_wu}
N -3440 -6740 -3440 -6710 {
lab=ctrl_wu}
N 250 -2340 250 -2320 {
lab=GND}
N 250 -2420 250 -2400 {
lab=ctrl_pos}
N -3390 -6220 -3390 -6210 {
lab=GND}
N -3340 -6260 -3330 -6260 {
lab=vpres2}
N -3390 -6370 -3390 -6360 {
lab=GND}
N -3340 -6410 -3330 -6410 {
lab=vpres2}
N -3450 -6230 -3440 -6230 {
lab=vb_wu}
N -3450 -6440 -3440 -6440 {
lab=ctrl_inf}
N -3390 -6320 -3390 -6300 {
lab=vdd_wu}
N -3390 -6470 -3390 -6450 {
lab=vdd_inf}
N -3450 -6290 -3440 -6290 {
lab=ctrl_wu}
N -3440 -6290 -3440 -6260 {
lab=ctrl_wu}
N -3390 -5770 -3390 -5760 {
lab=GND}
N -3340 -5810 -3330 -5810 {
lab=vpres3}
N -3390 -5920 -3390 -5910 {
lab=GND}
N -3450 -5960 -3440 -5960 {
lab=vpre3}
N -3340 -5960 -3330 -5960 {
lab=vpres3}
N -3450 -5780 -3440 -5780 {
lab=vb_wu}
N -3450 -5990 -3440 -5990 {
lab=ctrl_inf}
N -3390 -5870 -3390 -5850 {
lab=vdd_wu}
N -3390 -6020 -3390 -6000 {
lab=vdd_inf}
N -3450 -5840 -3440 -5840 {
lab=ctrl_wu}
N -3440 -5840 -3440 -5810 {
lab=ctrl_wu}
N -3390 -5320 -3390 -5310 {
lab=GND}
N -3340 -5360 -3330 -5360 {
lab=vpres4}
N -3390 -5470 -3390 -5460 {
lab=GND}
N -3450 -5510 -3440 -5510 {
lab=vpre4}
N -3340 -5510 -3330 -5510 {
lab=vpres4}
N -3450 -5330 -3440 -5330 {
lab=vb_wu}
N -3450 -5540 -3440 -5540 {
lab=ctrl_inf}
N -3390 -5420 -3390 -5400 {
lab=vdd_wu}
N -3390 -5570 -3390 -5550 {
lab=vdd_inf}
N -3450 -5390 -3440 -5390 {
lab=ctrl_wu}
N -3440 -5390 -3440 -5360 {
lab=ctrl_wu}
N -3390 -4870 -3390 -4860 {
lab=GND}
N -3340 -4910 -3330 -4910 {
lab=vpres5}
N -3390 -5020 -3390 -5010 {
lab=GND}
N -3450 -5060 -3440 -5060 {
lab=vpre5}
N -3340 -5060 -3330 -5060 {
lab=vpres5}
N -3450 -4880 -3440 -4880 {
lab=vb_wu}
N -3450 -5090 -3440 -5090 {
lab=ctrl_inf}
N -3390 -4970 -3390 -4950 {
lab=vdd_wu}
N -3390 -5120 -3390 -5100 {
lab=vdd_inf}
N -3450 -4940 -3440 -4940 {
lab=ctrl_wu}
N -3440 -4940 -3440 -4910 {
lab=ctrl_wu}
N -3390 -4420 -3390 -4410 {
lab=GND}
N -3340 -4460 -3330 -4460 {
lab=vpres6}
N -3390 -4570 -3390 -4560 {
lab=GND}
N -3450 -4610 -3440 -4610 {
lab=vpre6}
N -3340 -4610 -3330 -4610 {
lab=vpres6}
N -3450 -4430 -3440 -4430 {
lab=vb_wu}
N -3450 -4640 -3440 -4640 {
lab=ctrl_inf}
N -3390 -4520 -3390 -4500 {
lab=vdd_wu}
N -3390 -4670 -3390 -4650 {
lab=vdd_inf}
N -3450 -4490 -3440 -4490 {
lab=ctrl_wu}
N -3440 -4490 -3440 -4460 {
lab=ctrl_wu}
N -3390 -3970 -3390 -3960 {
lab=GND}
N -3340 -4010 -3330 -4010 {
lab=vpres7}
N -3390 -4120 -3390 -4110 {
lab=GND}
N -3450 -4160 -3440 -4160 {
lab=vpre7}
N -3340 -4160 -3330 -4160 {
lab=vpres7}
N -3450 -3980 -3440 -3980 {
lab=vb_wu}
N -3450 -4190 -3440 -4190 {
lab=ctrl_inf}
N -3390 -4070 -3390 -4050 {
lab=vdd_wu}
N -3390 -4220 -3390 -4200 {
lab=vdd_inf}
N -3450 -4040 -3440 -4040 {
lab=ctrl_wu}
N -3440 -4040 -3440 -4010 {
lab=ctrl_wu}
N -3390 -3520 -3390 -3510 {
lab=GND}
N -3340 -3560 -3330 -3560 {
lab=vpres8}
N -3390 -3670 -3390 -3660 {
lab=GND}
N -3450 -3710 -3440 -3710 {
lab=vpre8}
N -3340 -3710 -3330 -3710 {
lab=vpres8}
N -3450 -3530 -3440 -3530 {
lab=vb_wu}
N -3450 -3740 -3440 -3740 {
lab=ctrl_inf}
N -3390 -3620 -3390 -3600 {
lab=vdd_wu}
N -3390 -3770 -3390 -3750 {
lab=vdd_inf}
N -3450 -3590 -3440 -3590 {
lab=ctrl_wu}
N -3440 -3590 -3440 -3560 {
lab=ctrl_wu}
N -3390 -3070 -3390 -3060 {
lab=GND}
N -3340 -3110 -3330 -3110 {
lab=vpres9}
N -3390 -3220 -3390 -3210 {
lab=GND}
N -3450 -3260 -3440 -3260 {
lab=vpre9}
N -3340 -3260 -3330 -3260 {
lab=vpres9}
N -3450 -3080 -3440 -3080 {
lab=vb_wu}
N -3450 -3290 -3440 -3290 {
lab=ctrl_inf}
N -3390 -3170 -3390 -3150 {
lab=vdd_wu}
N -3390 -3320 -3390 -3300 {
lab=vdd_inf}
N -3450 -3140 -3440 -3140 {
lab=ctrl_wu}
N -3440 -3140 -3440 -3110 {
lab=ctrl_wu}
N -3390 -2620 -3390 -2610 {
lab=GND}
N -3340 -2660 -3330 -2660 {
lab=vpres10}
N -3390 -2770 -3390 -2760 {
lab=GND}
N -3450 -2810 -3440 -2810 {
lab=vpre10}
N -3340 -2810 -3330 -2810 {
lab=vpres10}
N -3450 -2630 -3440 -2630 {
lab=vb_wu}
N -3450 -2840 -3440 -2840 {
lab=ctrl_inf}
N -3390 -2720 -3390 -2700 {
lab=vdd_wu}
N -3390 -2870 -3390 -2850 {
lab=vdd_inf}
N -3450 -2690 -3440 -2690 {
lab=ctrl_wu}
N -3440 -2690 -3440 -2660 {
lab=ctrl_wu}
N -3390 -2170 -3390 -2160 {
lab=GND}
N -3340 -2210 -3330 -2210 {
lab=vpres11}
N -3390 -2320 -3390 -2310 {
lab=GND}
N -3450 -2360 -3440 -2360 {
lab=vpre11}
N -3340 -2360 -3330 -2360 {
lab=vpres11}
N -3450 -2180 -3440 -2180 {
lab=vb_wu}
N -3450 -2390 -3440 -2390 {
lab=ctrl_inf}
N -3390 -2270 -3390 -2250 {
lab=vdd_wu}
N -3390 -2420 -3390 -2400 {
lab=vdd_inf}
N -3450 -2240 -3440 -2240 {
lab=ctrl_wu}
N -3440 -2240 -3440 -2210 {
lab=ctrl_wu}
N -3390 -1720 -3390 -1710 {
lab=GND}
N -3340 -1760 -3330 -1760 {
lab=vpres12}
N -3390 -1870 -3390 -1860 {
lab=GND}
N -3450 -1910 -3440 -1910 {
lab=vpre12}
N -3340 -1910 -3330 -1910 {
lab=vpres12}
N -3450 -1730 -3440 -1730 {
lab=vb_wu}
N -3450 -1940 -3440 -1940 {
lab=ctrl_inf}
N -3390 -1820 -3390 -1800 {
lab=vdd_wu}
N -3390 -1970 -3390 -1950 {
lab=vdd_inf}
N -3450 -1790 -3440 -1790 {
lab=ctrl_wu}
N -3440 -1790 -3440 -1760 {
lab=ctrl_wu}
N -3390 -1270 -3390 -1260 {
lab=GND}
N -3340 -1310 -3330 -1310 {
lab=vpres13}
N -3390 -1420 -3390 -1410 {
lab=GND}
N -3450 -1460 -3440 -1460 {
lab=vpre13}
N -3340 -1460 -3330 -1460 {
lab=vpres13}
N -3450 -1280 -3440 -1280 {
lab=vb_wu}
N -3450 -1490 -3440 -1490 {
lab=ctrl_inf}
N -3390 -1370 -3390 -1350 {
lab=vdd_wu}
N -3390 -1520 -3390 -1500 {
lab=vdd_inf}
N -3450 -1340 -3440 -1340 {
lab=ctrl_wu}
N -3440 -1340 -3440 -1310 {
lab=ctrl_wu}
N -3390 -820 -3390 -810 {
lab=GND}
N -3340 -860 -3330 -860 {
lab=vpres14}
N -3390 -970 -3390 -960 {
lab=GND}
N -3450 -1010 -3440 -1010 {
lab=vpre14}
N -3450 -830 -3440 -830 {
lab=vb_wu}
N -3450 -1040 -3440 -1040 {
lab=ctrl_inf}
N -3390 -920 -3390 -900 {
lab=vdd_wu}
N -3390 -1070 -3390 -1050 {
lab=vdd_inf}
N -3450 -890 -3440 -890 {
lab=ctrl_wu}
N -3440 -890 -3440 -860 {
lab=ctrl_wu}
N -3390 -370 -3390 -360 {
lab=GND}
N -3340 -410 -3330 -410 {
lab=vpres15}
N -3390 -520 -3390 -510 {
lab=GND}
N -3450 -380 -3440 -380 {
lab=vb_wu}
N -3450 -590 -3440 -590 {
lab=ctrl_inf}
N -3390 -470 -3390 -450 {
lab=vdd_wu}
N -3390 -620 -3390 -600 {
lab=vdd_inf}
N -3450 -440 -3440 -440 {
lab=ctrl_wu}
N -3440 -440 -3440 -410 {
lab=ctrl_wu}
N -3450 -6860 -3440 -6860 {
lab=vpre1}
N -3450 -6410 -3440 -6410 {
lab=vpre2}
N -3450 -560 -3440 -560 {
lab=vpre15}
N -3340 -560 -3330 -560 {
lab=vpres15}
N -3150 -560 -3140 -560 {
lab=vpres15}
N -3150 -1010 -3140 -1010 {
lab=vpres14}
N -3020 -1010 -3010 -1010 {
lab=b_px}
N -3340 -1010 -3330 -1010 {
lab=vpres14}
N 440 -2620 440 -2600 {
lab=GND}
N 440 -2700 440 -2680 {
lab=vdd_inf}
N -2700 -270 -2700 -260 {
lab=#net46}
N -2700 -340 -2700 -330 {
lab=p1}
N -2700 -20 -2700 -10 {
lab=N1}
N -2770 -160 -2770 -140 {
lab=GND}
N -2630 -160 -2630 -140 {
lab=vdd_pos}
N -2770 -260 -2770 -250 {
lab=inh}
N -2740 -260 -2740 -250 {
lab=vb_pos}
N -2660 -260 -2660 -250 {
lab=vlky_pos}
N -2380 -270 -2380 -260 {
lab=#net47}
N -2380 -340 -2380 -330 {
lab=p2}
N -2380 -20 -2380 -10 {
lab=N2}
N -2450 -160 -2450 -140 {
lab=GND}
N -2310 -160 -2310 -140 {
lab=vdd_pos}
N -2450 -260 -2450 -250 {
lab=inh}
N -2420 -260 -2420 -250 {
lab=vb_pos}
N -2340 -260 -2340 -250 {
lab=vlky_pos}
N -2060 -270 -2060 -260 {
lab=#net48}
N -2060 -340 -2060 -330 {
lab=p3}
N -2060 -20 -2060 -10 {
lab=N3}
N -2130 -160 -2130 -140 {
lab=GND}
N -1990 -160 -1990 -140 {
lab=vdd_pos}
N -2130 -260 -2130 -250 {
lab=inh}
N -2100 -260 -2100 -250 {
lab=vb_pos}
N -2020 -260 -2020 -250 {
lab=vlky_pos}
N -1740 -270 -1740 -260 {
lab=#net49}
N -1740 -340 -1740 -330 {
lab=p4}
N -1740 -20 -1740 -10 {
lab=N4}
N -1810 -160 -1810 -140 {
lab=GND}
N -1670 -160 -1670 -140 {
lab=vdd_pos}
N -1810 -260 -1810 -250 {
lab=inh}
N -1780 -260 -1780 -250 {
lab=vb_pos}
N -1700 -260 -1700 -250 {
lab=vlky_pos}
N -1420 -270 -1420 -260 {
lab=#net50}
N -1420 -340 -1420 -330 {
lab=p5}
N -1420 -20 -1420 -10 {
lab=N5}
N -1490 -160 -1490 -140 {
lab=GND}
N -1350 -160 -1350 -140 {
lab=vdd_pos}
N -1490 -260 -1490 -250 {
lab=inh}
N -1460 -260 -1460 -250 {
lab=vb_pos}
N -1380 -260 -1380 -250 {
lab=vlky_pos}
N -1100 -270 -1100 -260 {
lab=#net51}
N -1100 -340 -1100 -330 {
lab=p6}
N -1100 -20 -1100 -10 {
lab=N6}
N -1170 -160 -1170 -140 {
lab=GND}
N -1030 -160 -1030 -140 {
lab=vdd_pos}
N -1170 -260 -1170 -250 {
lab=inh}
N -1140 -260 -1140 -250 {
lab=vb_pos}
N -1060 -260 -1060 -250 {
lab=vlky_pos}
N -780 -270 -780 -260 {
lab=#net52}
N -780 -340 -780 -330 {
lab=p7}
N -780 -20 -780 -10 {
lab=N7}
N -850 -160 -850 -140 {
lab=GND}
N -710 -160 -710 -140 {
lab=vdd_pos}
N -850 -260 -850 -250 {
lab=inh}
N -820 -260 -820 -250 {
lab=vb_pos}
N -740 -260 -740 -250 {
lab=vlky_pos}
N -460 -270 -460 -260 {
lab=#net53}
N -460 -340 -460 -330 {
lab=p8}
N -460 -20 -460 -10 {
lab=N8}
N -530 -160 -530 -140 {
lab=GND}
N -390 -160 -390 -140 {
lab=vdd_pos}
N -530 -260 -530 -250 {
lab=inh}
N -500 -260 -500 -250 {
lab=vb_pos}
N -420 -260 -420 -250 {
lab=vlky_pos}
N -140 -270 -140 -260 {
lab=#net54}
N -140 -340 -140 -330 {
lab=p9}
N -140 -20 -140 -10 {
lab=N9}
N -210 -160 -210 -140 {
lab=GND}
N -70 -160 -70 -140 {
lab=vdd_pos}
N -210 -260 -210 -250 {
lab=inh}
N -180 -260 -180 -250 {
lab=vb_pos}
N -100 -260 -100 -250 {
lab=vlky_pos}
N -2760 -6800 -2760 -6790 {
lab=GND}
N -2760 -6910 -2760 -6900 {
lab=vdd_syn1}
N -2700 -6720 -2690 -6720 {
lab=GND}
N -2700 -6690 -2700 -6680 {
lab=p1}
N -2830 -6860 -2820 -6860 {
lab=vpres1}
N -2700 -6860 -2690 -6860 {
lab=w_px}
N -2750 -6720 -2740 -6720 {
lab=ctrl_pos}
N -2700 -6840 -2700 -6820 {
lab=#net55}
N -2700 -6760 -2700 -6750 {
lab=#net56}
N -2440 -6800 -2440 -6790 {
lab=GND}
N -2440 -6910 -2440 -6900 {
lab=vdd_syn2}
N -2380 -6720 -2370 -6720 {
lab=GND}
N -2380 -6690 -2380 -6680 {
lab=p2}
N -2510 -6860 -2500 -6860 {
lab=vpres1}
N -2380 -6860 -2370 -6860 {
lab=b_px}
N -2430 -6720 -2420 -6720 {
lab=ctrl_pos}
N -2380 -6840 -2380 -6820 {
lab=#net57}
N -2380 -6760 -2380 -6750 {
lab=#net58}
N -2120 -6800 -2120 -6790 {
lab=GND}
N -2120 -6910 -2120 -6900 {
lab=vdd_syn3}
N -2060 -6720 -2050 -6720 {
lab=GND}
N -2060 -6690 -2060 -6680 {
lab=p3}
N -2190 -6860 -2180 -6860 {
lab=vpres1}
N -2060 -6860 -2050 -6860 {
lab=b_px}
N -2110 -6720 -2100 -6720 {
lab=ctrl_pos}
N -2060 -6840 -2060 -6820 {
lab=#net59}
N -2060 -6760 -2060 -6750 {
lab=#net60}
N -1800 -6800 -1800 -6790 {
lab=GND}
N -1800 -6910 -1800 -6900 {
lab=vdd_syn4}
N -1740 -6720 -1730 -6720 {
lab=GND}
N -1740 -6690 -1740 -6680 {
lab=p4}
N -1870 -6860 -1860 -6860 {
lab=vpres1}
N -1740 -6860 -1730 -6860 {
lab=b_px}
N -1790 -6720 -1780 -6720 {
lab=ctrl_pos}
N -1740 -6840 -1740 -6820 {
lab=#net61}
N -1740 -6760 -1740 -6750 {
lab=#net62}
N -1480 -6800 -1480 -6790 {
lab=GND}
N -1480 -6910 -1480 -6900 {
lab=vdd_syn5}
N -1420 -6720 -1410 -6720 {
lab=GND}
N -1420 -6690 -1420 -6680 {
lab=p5}
N -1550 -6860 -1540 -6860 {
lab=vpres1}
N -1420 -6860 -1410 -6860 {
lab=b_px}
N -1470 -6720 -1460 -6720 {
lab=ctrl_pos}
N -1420 -6840 -1420 -6820 {
lab=#net63}
N -1420 -6760 -1420 -6750 {
lab=#net64}
N -1160 -6800 -1160 -6790 {
lab=GND}
N -1160 -6910 -1160 -6900 {
lab=vdd_syn6}
N -1100 -6720 -1090 -6720 {
lab=GND}
N -1100 -6690 -1100 -6680 {
lab=p6}
N -1230 -6860 -1220 -6860 {
lab=vpres1}
N -1100 -6860 -1090 -6860 {
lab=w_px}
N -1150 -6720 -1140 -6720 {
lab=ctrl_pos}
N -1100 -6840 -1100 -6820 {
lab=#net65}
N -1100 -6760 -1100 -6750 {
lab=#net66}
N -840 -6800 -840 -6790 {
lab=GND}
N -840 -6910 -840 -6900 {
lab=vdd_syn7}
N -780 -6720 -770 -6720 {
lab=GND}
N -780 -6690 -780 -6680 {
lab=p7}
N -910 -6860 -900 -6860 {
lab=vpres1}
N -780 -6860 -770 -6860 {
lab=b_px}
N -830 -6720 -820 -6720 {
lab=ctrl_pos}
N -780 -6840 -780 -6820 {
lab=#net67}
N -780 -6760 -780 -6750 {
lab=#net68}
N -520 -6800 -520 -6790 {
lab=GND}
N -520 -6910 -520 -6900 {
lab=vdd_syn8}
N -460 -6720 -450 -6720 {
lab=GND}
N -460 -6690 -460 -6680 {
lab=p8}
N -590 -6860 -580 -6860 {
lab=vpres1}
N -460 -6860 -450 -6860 {
lab=w_px}
N -510 -6720 -500 -6720 {
lab=ctrl_pos}
N -460 -6840 -460 -6820 {
lab=#net69}
N -460 -6760 -460 -6750 {
lab=#net70}
N -200 -6800 -200 -6790 {
lab=GND}
N -200 -6910 -200 -6900 {
lab=vdd_syn9}
N -140 -6720 -130 -6720 {
lab=GND}
N -140 -6690 -140 -6680 {
lab=p9}
N -270 -6860 -260 -6860 {
lab=vpres1}
N -140 -6860 -130 -6860 {
lab=w_px}
N -190 -6720 -180 -6720 {
lab=ctrl_pos}
N -140 -6840 -140 -6820 {
lab=#net71}
N -140 -6760 -140 -6750 {
lab=#net72}
N -2760 -6350 -2760 -6340 {
lab=GND}
N -2760 -6460 -2760 -6450 {
lab=vdd_syn1}
N -2700 -6270 -2690 -6270 {
lab=GND}
N -2700 -6240 -2700 -6230 {
lab=p1}
N -2830 -6410 -2820 -6410 {
lab=vpres2}
N -2700 -6410 -2690 -6410 {
lab=b_px}
N -2750 -6270 -2740 -6270 {
lab=ctrl_pos}
N -2700 -6390 -2700 -6370 {
lab=#net73}
N -2700 -6310 -2700 -6300 {
lab=#net74}
N -2440 -6350 -2440 -6340 {
lab=GND}
N -2440 -6460 -2440 -6450 {
lab=vdd_syn2}
N -2380 -6270 -2370 -6270 {
lab=GND}
N -2380 -6240 -2380 -6230 {
lab=p2}
N -2510 -6410 -2500 -6410 {
lab=vpres2}
N -2380 -6410 -2370 -6410 {
lab=b_px}
N -2430 -6270 -2420 -6270 {
lab=ctrl_pos}
N -2380 -6390 -2380 -6370 {
lab=#net75}
N -2380 -6310 -2380 -6300 {
lab=#net76}
N -2120 -6350 -2120 -6340 {
lab=GND}
N -2120 -6460 -2120 -6450 {
lab=vdd_syn3}
N -2060 -6270 -2050 -6270 {
lab=GND}
N -2060 -6240 -2060 -6230 {
lab=p3}
N -2190 -6410 -2180 -6410 {
lab=vpres2}
N -2060 -6410 -2050 -6410 {
lab=b_px}
N -2110 -6270 -2100 -6270 {
lab=ctrl_pos}
N -2060 -6390 -2060 -6370 {
lab=#net77}
N -2060 -6310 -2060 -6300 {
lab=#net78}
N -1800 -6350 -1800 -6340 {
lab=GND}
N -1800 -6460 -1800 -6450 {
lab=vdd_syn4}
N -1740 -6270 -1730 -6270 {
lab=GND}
N -1740 -6240 -1740 -6230 {
lab=p4}
N -1870 -6410 -1860 -6410 {
lab=vpres2}
N -1740 -6410 -1730 -6410 {
lab=w_px}
N -1790 -6270 -1780 -6270 {
lab=ctrl_pos}
N -1740 -6390 -1740 -6370 {
lab=#net79}
N -1740 -6310 -1740 -6300 {
lab=#net80}
N -1480 -6350 -1480 -6340 {
lab=GND}
N -1480 -6460 -1480 -6450 {
lab=vdd_syn5}
N -1420 -6270 -1410 -6270 {
lab=GND}
N -1420 -6240 -1420 -6230 {
lab=p5}
N -1550 -6410 -1540 -6410 {
lab=vpres2}
N -1420 -6410 -1410 -6410 {
lab=b_px}
N -1470 -6270 -1460 -6270 {
lab=ctrl_pos}
N -1420 -6390 -1420 -6370 {
lab=#net81}
N -1420 -6310 -1420 -6300 {
lab=#net82}
N -1160 -6350 -1160 -6340 {
lab=GND}
N -1160 -6460 -1160 -6450 {
lab=vdd_syn6}
N -1100 -6270 -1090 -6270 {
lab=GND}
N -1100 -6240 -1100 -6230 {
lab=p6}
N -1230 -6410 -1220 -6410 {
lab=vpres2}
N -1100 -6410 -1090 -6410 {
lab=b_px}
N -1150 -6270 -1140 -6270 {
lab=ctrl_pos}
N -1100 -6390 -1100 -6370 {
lab=#net83}
N -1100 -6310 -1100 -6300 {
lab=#net84}
N -840 -6350 -840 -6340 {
lab=GND}
N -840 -6460 -840 -6450 {
lab=vdd_syn7}
N -780 -6270 -770 -6270 {
lab=GND}
N -780 -6240 -780 -6230 {
lab=p7}
N -910 -6410 -900 -6410 {
lab=vpres2}
N -780 -6410 -770 -6410 {
lab=b_px}
N -830 -6270 -820 -6270 {
lab=ctrl_pos}
N -780 -6390 -780 -6370 {
lab=#net85}
N -780 -6310 -780 -6300 {
lab=#net86}
N -520 -6350 -520 -6340 {
lab=GND}
N -520 -6460 -520 -6450 {
lab=vdd_syn8}
N -460 -6270 -450 -6270 {
lab=GND}
N -460 -6240 -460 -6230 {
lab=p8}
N -590 -6410 -580 -6410 {
lab=vpres2}
N -460 -6410 -450 -6410 {
lab=b_px}
N -510 -6270 -500 -6270 {
lab=ctrl_pos}
N -460 -6390 -460 -6370 {
lab=#net87}
N -460 -6310 -460 -6300 {
lab=#net88}
N -200 -6350 -200 -6340 {
lab=GND}
N -200 -6460 -200 -6450 {
lab=vdd_syn9}
N -140 -6270 -130 -6270 {
lab=GND}
N -140 -6240 -140 -6230 {
lab=p9}
N -270 -6410 -260 -6410 {
lab=vpres2}
N -140 -6410 -130 -6410 {
lab=b_px}
N -190 -6270 -180 -6270 {
lab=ctrl_pos}
N -140 -6390 -140 -6370 {
lab=#net89}
N -140 -6310 -140 -6300 {
lab=#net90}
N -2760 -5900 -2760 -5890 {
lab=GND}
N -2760 -6010 -2760 -6000 {
lab=vdd_syn1}
N -2700 -5820 -2690 -5820 {
lab=GND}
N -2700 -5790 -2700 -5780 {
lab=p1}
N -2830 -5960 -2820 -5960 {
lab=vpres3}
N -2700 -5960 -2690 -5960 {
lab=w_px}
N -2750 -5820 -2740 -5820 {
lab=ctrl_pos}
N -2700 -5940 -2700 -5920 {
lab=#net91}
N -2700 -5860 -2700 -5850 {
lab=#net92}
N -2440 -5900 -2440 -5890 {
lab=GND}
N -2440 -6010 -2440 -6000 {
lab=vdd_syn2}
N -2380 -5820 -2370 -5820 {
lab=GND}
N -2380 -5790 -2380 -5780 {
lab=p2}
N -2510 -5960 -2500 -5960 {
lab=vpres3}
N -2380 -5960 -2370 -5960 {
lab=w_px}
N -2430 -5820 -2420 -5820 {
lab=ctrl_pos}
N -2380 -5940 -2380 -5920 {
lab=#net93}
N -2380 -5860 -2380 -5850 {
lab=#net94}
N -2120 -5900 -2120 -5890 {
lab=GND}
N -2120 -6010 -2120 -6000 {
lab=vdd_syn3}
N -2060 -5820 -2050 -5820 {
lab=GND}
N -2060 -5790 -2060 -5780 {
lab=p3}
N -2190 -5960 -2180 -5960 {
lab=vpres3}
N -2060 -5960 -2050 -5960 {
lab=w_px}
N -2110 -5820 -2100 -5820 {
lab=ctrl_pos}
N -2060 -5940 -2060 -5920 {
lab=#net95}
N -2060 -5860 -2060 -5850 {
lab=#net96}
N -1800 -5900 -1800 -5890 {
lab=GND}
N -1800 -6010 -1800 -6000 {
lab=vdd_syn4}
N -1740 -5820 -1730 -5820 {
lab=GND}
N -1740 -5790 -1740 -5780 {
lab=p4}
N -1870 -5960 -1860 -5960 {
lab=vpres3}
N -1740 -5960 -1730 -5960 {
lab=b_px}
N -1790 -5820 -1780 -5820 {
lab=ctrl_pos}
N -1740 -5940 -1740 -5920 {
lab=#net97}
N -1740 -5860 -1740 -5850 {
lab=#net98}
N -1480 -5900 -1480 -5890 {
lab=GND}
N -1480 -6010 -1480 -6000 {
lab=vdd_syn5}
N -1420 -5820 -1410 -5820 {
lab=GND}
N -1420 -5790 -1420 -5780 {
lab=p5}
N -1550 -5960 -1540 -5960 {
lab=vpres3}
N -1420 -5960 -1410 -5960 {
lab=b_px}
N -1470 -5820 -1460 -5820 {
lab=ctrl_pos}
N -1420 -5940 -1420 -5920 {
lab=#net99}
N -1420 -5860 -1420 -5850 {
lab=#net100}
N -1160 -5900 -1160 -5890 {
lab=GND}
N -1160 -6010 -1160 -6000 {
lab=vdd_syn6}
N -1100 -5820 -1090 -5820 {
lab=GND}
N -1100 -5790 -1100 -5780 {
lab=p6}
N -1230 -5960 -1220 -5960 {
lab=vpres3}
N -1100 -5960 -1090 -5960 {
lab=b_px}
N -1150 -5820 -1140 -5820 {
lab=ctrl_pos}
N -1100 -5940 -1100 -5920 {
lab=#net101}
N -1100 -5860 -1100 -5850 {
lab=#net102}
N -840 -5900 -840 -5890 {
lab=GND}
N -840 -6010 -840 -6000 {
lab=vdd_syn7}
N -780 -5820 -770 -5820 {
lab=GND}
N -780 -5790 -780 -5780 {
lab=p7}
N -910 -5960 -900 -5960 {
lab=vpres3}
N -780 -5960 -770 -5960 {
lab=b_px}
N -830 -5820 -820 -5820 {
lab=ctrl_pos}
N -780 -5940 -780 -5920 {
lab=#net103}
N -780 -5860 -780 -5850 {
lab=#net104}
N -520 -5900 -520 -5890 {
lab=GND}
N -520 -6010 -520 -6000 {
lab=vdd_syn8}
N -460 -5820 -450 -5820 {
lab=GND}
N -460 -5790 -460 -5780 {
lab=p8}
N -590 -5960 -580 -5960 {
lab=vpres3}
N -460 -5960 -450 -5960 {
lab=w_px}
N -510 -5820 -500 -5820 {
lab=ctrl_pos}
N -460 -5940 -460 -5920 {
lab=#net105}
N -460 -5860 -460 -5850 {
lab=#net106}
N -200 -5900 -200 -5890 {
lab=GND}
N -200 -6010 -200 -6000 {
lab=vdd_syn9}
N -140 -5820 -130 -5820 {
lab=GND}
N -140 -5790 -140 -5780 {
lab=p9}
N -270 -5960 -260 -5960 {
lab=vpres3}
N -140 -5960 -130 -5960 {
lab=w_px}
N -190 -5820 -180 -5820 {
lab=ctrl_pos}
N -140 -5940 -140 -5920 {
lab=#net107}
N -140 -5860 -140 -5850 {
lab=#net108}
N -2760 -5450 -2760 -5440 {
lab=GND}
N -2760 -5560 -2760 -5550 {
lab=vdd_syn1}
N -2700 -5370 -2690 -5370 {
lab=GND}
N -2700 -5340 -2700 -5330 {
lab=p1}
N -2830 -5510 -2820 -5510 {
lab=vpres4}
N -2700 -5510 -2690 -5510 {
lab=b_px}
N -2750 -5370 -2740 -5370 {
lab=ctrl_pos}
N -2700 -5490 -2700 -5470 {
lab=#net109}
N -2700 -5410 -2700 -5400 {
lab=#net110}
N -2440 -5450 -2440 -5440 {
lab=GND}
N -2440 -5560 -2440 -5550 {
lab=vdd_syn2}
N -2380 -5370 -2370 -5370 {
lab=GND}
N -2380 -5340 -2380 -5330 {
lab=p2}
N -2510 -5510 -2500 -5510 {
lab=vpres4}
N -2380 -5510 -2370 -5510 {
lab=w_px}
N -2430 -5370 -2420 -5370 {
lab=ctrl_pos}
N -2380 -5490 -2380 -5470 {
lab=#net111}
N -2380 -5410 -2380 -5400 {
lab=#net112}
N -2120 -5450 -2120 -5440 {
lab=GND}
N -2120 -5560 -2120 -5550 {
lab=vdd_syn3}
N -2060 -5370 -2050 -5370 {
lab=GND}
N -2060 -5340 -2060 -5330 {
lab=p3}
N -2190 -5510 -2180 -5510 {
lab=vpres4}
N -2060 -5510 -2050 -5510 {
lab=w_px}
N -2110 -5370 -2100 -5370 {
lab=ctrl_pos}
N -2060 -5490 -2060 -5470 {
lab=#net113}
N -2060 -5410 -2060 -5400 {
lab=#net114}
N -1800 -5450 -1800 -5440 {
lab=GND}
N -1800 -5560 -1800 -5550 {
lab=vdd_syn4}
N -1740 -5370 -1730 -5370 {
lab=GND}
N -1740 -5340 -1740 -5330 {
lab=p4}
N -1870 -5510 -1860 -5510 {
lab=vpres4}
N -1740 -5510 -1730 -5510 {
lab=b_px}
N -1790 -5370 -1780 -5370 {
lab=ctrl_pos}
N -1740 -5490 -1740 -5470 {
lab=#net115}
N -1740 -5410 -1740 -5400 {
lab=#net116}
N -1480 -5450 -1480 -5440 {
lab=GND}
N -1480 -5560 -1480 -5550 {
lab=vdd_syn5}
N -1420 -5370 -1410 -5370 {
lab=GND}
N -1420 -5340 -1420 -5330 {
lab=p5}
N -1550 -5510 -1540 -5510 {
lab=vpres4}
N -1420 -5510 -1410 -5510 {
lab=b_px}
N -1470 -5370 -1460 -5370 {
lab=ctrl_pos}
N -1420 -5490 -1420 -5470 {
lab=#net117}
N -1420 -5410 -1420 -5400 {
lab=#net118}
N -1160 -5450 -1160 -5440 {
lab=GND}
N -1160 -5560 -1160 -5550 {
lab=vdd_syn6}
N -1100 -5370 -1090 -5370 {
lab=GND}
N -1100 -5340 -1100 -5330 {
lab=p6}
N -1230 -5510 -1220 -5510 {
lab=vpres4}
N -1100 -5510 -1090 -5510 {
lab=b_px}
N -1150 -5370 -1140 -5370 {
lab=ctrl_pos}
N -1100 -5490 -1100 -5470 {
lab=#net119}
N -1100 -5410 -1100 -5400 {
lab=#net120}
N -840 -5450 -840 -5440 {
lab=GND}
N -840 -5560 -840 -5550 {
lab=vdd_syn7}
N -780 -5370 -770 -5370 {
lab=GND}
N -780 -5340 -780 -5330 {
lab=p7}
N -910 -5510 -900 -5510 {
lab=vpres4}
N -780 -5510 -770 -5510 {
lab=w_px}
N -830 -5370 -820 -5370 {
lab=ctrl_pos}
N -780 -5490 -780 -5470 {
lab=#net121}
N -780 -5410 -780 -5400 {
lab=#net122}
N -520 -5450 -520 -5440 {
lab=GND}
N -520 -5560 -520 -5550 {
lab=vdd_syn8}
N -460 -5370 -450 -5370 {
lab=GND}
N -460 -5340 -460 -5330 {
lab=p8}
N -590 -5510 -580 -5510 {
lab=vpres4}
N -460 -5510 -450 -5510 {
lab=b_px}
N -510 -5370 -500 -5370 {
lab=ctrl_pos}
N -460 -5490 -460 -5470 {
lab=#net123}
N -460 -5410 -460 -5400 {
lab=#net124}
N -200 -5450 -200 -5440 {
lab=GND}
N -200 -5560 -200 -5550 {
lab=vdd_syn9}
N -140 -5370 -130 -5370 {
lab=GND}
N -140 -5340 -140 -5330 {
lab=p9}
N -270 -5510 -260 -5510 {
lab=vpres4}
N -140 -5510 -130 -5510 {
lab=b_px}
N -190 -5370 -180 -5370 {
lab=ctrl_pos}
N -140 -5490 -140 -5470 {
lab=#net125}
N -140 -5410 -140 -5400 {
lab=#net126}
N -2760 -5000 -2760 -4990 {
lab=GND}
N -2760 -5110 -2760 -5100 {
lab=vdd_syn1}
N -2700 -4920 -2690 -4920 {
lab=GND}
N -2700 -4890 -2700 -4880 {
lab=p1}
N -2830 -5060 -2820 -5060 {
lab=vpres5}
N -2700 -5060 -2690 -5060 {
lab=b_px}
N -2750 -4920 -2740 -4920 {
lab=ctrl_pos}
N -2700 -5040 -2700 -5020 {
lab=#net127}
N -2700 -4960 -2700 -4950 {
lab=#net128}
N -2440 -5000 -2440 -4990 {
lab=GND}
N -2440 -5110 -2440 -5100 {
lab=vdd_syn2}
N -2380 -4920 -2370 -4920 {
lab=GND}
N -2380 -4890 -2380 -4880 {
lab=p2}
N -2510 -5060 -2500 -5060 {
lab=vpres5}
N -2380 -5060 -2370 -5060 {
lab=w_px}
N -2430 -4920 -2420 -4920 {
lab=ctrl_pos}
N -2380 -5040 -2380 -5020 {
lab=#net129}
N -2380 -4960 -2380 -4950 {
lab=#net130}
N -2120 -5000 -2120 -4990 {
lab=GND}
N -2120 -5110 -2120 -5100 {
lab=vdd_syn3}
N -2060 -4920 -2050 -4920 {
lab=GND}
N -2060 -4890 -2060 -4880 {
lab=p3}
N -2190 -5060 -2180 -5060 {
lab=vpres5}
N -2060 -5060 -2050 -5060 {
lab=w_px}
N -2110 -4920 -2100 -4920 {
lab=ctrl_pos}
N -2060 -5040 -2060 -5020 {
lab=#net131}
N -2060 -4960 -2060 -4950 {
lab=#net132}
N -1800 -5000 -1800 -4990 {
lab=GND}
N -1800 -5110 -1800 -5100 {
lab=vdd_syn4}
N -1740 -4920 -1730 -4920 {
lab=GND}
N -1740 -4890 -1740 -4880 {
lab=p4}
N -1870 -5060 -1860 -5060 {
lab=vpres5}
N -1740 -5060 -1730 -5060 {
lab=w_px}
N -1790 -4920 -1780 -4920 {
lab=ctrl_pos}
N -1740 -5040 -1740 -5020 {
lab=#net133}
N -1740 -4960 -1740 -4950 {
lab=#net134}
N -1480 -5000 -1480 -4990 {
lab=GND}
N -1480 -5110 -1480 -5100 {
lab=vdd_syn5}
N -1420 -4920 -1410 -4920 {
lab=GND}
N -1420 -4890 -1420 -4880 {
lab=p5}
N -1550 -5060 -1540 -5060 {
lab=vpres5}
N -1420 -5060 -1410 -5060 {
lab=w_px}
N -1470 -4920 -1460 -4920 {
lab=ctrl_pos}
N -1420 -5040 -1420 -5020 {
lab=#net135}
N -1420 -4960 -1420 -4950 {
lab=#net136}
N -1160 -5000 -1160 -4990 {
lab=GND}
N -1160 -5110 -1160 -5100 {
lab=vdd_syn6}
N -1100 -4920 -1090 -4920 {
lab=GND}
N -1100 -4890 -1100 -4880 {
lab=p6}
N -1230 -5060 -1220 -5060 {
lab=vpres5}
N -1100 -5060 -1090 -5060 {
lab=w_px}
N -1150 -4920 -1140 -4920 {
lab=ctrl_pos}
N -1100 -5040 -1100 -5020 {
lab=#net137}
N -1100 -4960 -1100 -4950 {
lab=#net138}
N -840 -5000 -840 -4990 {
lab=GND}
N -840 -5110 -840 -5100 {
lab=vdd_syn7}
N -780 -4920 -770 -4920 {
lab=GND}
N -780 -4890 -780 -4880 {
lab=p7}
N -910 -5060 -900 -5060 {
lab=vpres5}
N -780 -5060 -770 -5060 {
lab=w_px}
N -830 -4920 -820 -4920 {
lab=ctrl_pos}
N -780 -5040 -780 -5020 {
lab=#net139}
N -780 -4960 -780 -4950 {
lab=#net140}
N -520 -5000 -520 -4990 {
lab=GND}
N -520 -5110 -520 -5100 {
lab=vdd_syn8}
N -460 -4920 -450 -4920 {
lab=GND}
N -460 -4890 -460 -4880 {
lab=p8}
N -590 -5060 -580 -5060 {
lab=vpres5}
N -460 -5060 -450 -5060 {
lab=w_px}
N -510 -4920 -500 -4920 {
lab=ctrl_pos}
N -460 -5040 -460 -5020 {
lab=#net141}
N -460 -4960 -460 -4950 {
lab=#net142}
N -200 -5000 -200 -4990 {
lab=GND}
N -200 -5110 -200 -5100 {
lab=vdd_syn9}
N -140 -4920 -130 -4920 {
lab=GND}
N -140 -4890 -140 -4880 {
lab=p9}
N -270 -5060 -260 -5060 {
lab=vpres5}
N -140 -5060 -130 -5060 {
lab=w_px}
N -190 -4920 -180 -4920 {
lab=ctrl_pos}
N -140 -5040 -140 -5020 {
lab=#net143}
N -140 -4960 -140 -4950 {
lab=#net144}
N -2760 -4550 -2760 -4540 {
lab=GND}
N -2760 -4660 -2760 -4650 {
lab=vdd_syn1}
N -2700 -4470 -2690 -4470 {
lab=GND}
N -2700 -4440 -2700 -4430 {
lab=p1}
N -2830 -4610 -2820 -4610 {
lab=vpres6}
N -2700 -4610 -2690 -4610 {
lab=w_px}
N -2750 -4470 -2740 -4470 {
lab=ctrl_pos}
N -2700 -4590 -2700 -4570 {
lab=#net145}
N -2700 -4510 -2700 -4500 {
lab=#net146}
N -2440 -4550 -2440 -4540 {
lab=GND}
N -2440 -4660 -2440 -4650 {
lab=vdd_syn2}
N -2380 -4470 -2370 -4470 {
lab=GND}
N -2380 -4440 -2380 -4430 {
lab=p2}
N -2510 -4610 -2500 -4610 {
lab=vpres6}
N -2380 -4610 -2370 -4610 {
lab=b_px}
N -2430 -4470 -2420 -4470 {
lab=ctrl_pos}
N -2380 -4590 -2380 -4570 {
lab=#net147}
N -2380 -4510 -2380 -4500 {
lab=#net148}
N -2120 -4550 -2120 -4540 {
lab=GND}
N -2120 -4660 -2120 -4650 {
lab=vdd_syn3}
N -2060 -4470 -2050 -4470 {
lab=GND}
N -2060 -4440 -2060 -4430 {
lab=p3}
N -2190 -4610 -2180 -4610 {
lab=vpres6}
N -2060 -4610 -2050 -4610 {
lab=b_px}
N -2110 -4470 -2100 -4470 {
lab=ctrl_pos}
N -2060 -4590 -2060 -4570 {
lab=#net149}
N -2060 -4510 -2060 -4500 {
lab=#net150}
N -1800 -4550 -1800 -4540 {
lab=GND}
N -1800 -4660 -1800 -4650 {
lab=vdd_syn4}
N -1740 -4470 -1730 -4470 {
lab=GND}
N -1740 -4440 -1740 -4430 {
lab=p4}
N -1870 -4610 -1860 -4610 {
lab=vpres6}
N -1740 -4610 -1730 -4610 {
lab=b_px}
N -1790 -4470 -1780 -4470 {
lab=ctrl_pos}
N -1740 -4590 -1740 -4570 {
lab=#net151}
N -1740 -4510 -1740 -4500 {
lab=#net152}
N -1480 -4550 -1480 -4540 {
lab=GND}
N -1480 -4660 -1480 -4650 {
lab=vdd_syn5}
N -1420 -4470 -1410 -4470 {
lab=GND}
N -1420 -4440 -1420 -4430 {
lab=p5}
N -1550 -4610 -1540 -4610 {
lab=vpres6}
N -1420 -4610 -1410 -4610 {
lab=w_px}
N -1470 -4470 -1460 -4470 {
lab=ctrl_pos}
N -1420 -4590 -1420 -4570 {
lab=#net153}
N -1420 -4510 -1420 -4500 {
lab=#net154}
N -1160 -4550 -1160 -4540 {
lab=GND}
N -1160 -4660 -1160 -4650 {
lab=vdd_syn6}
N -1100 -4470 -1090 -4470 {
lab=GND}
N -1100 -4440 -1100 -4430 {
lab=p6}
N -1230 -4610 -1220 -4610 {
lab=vpres6}
N -1100 -4610 -1090 -4610 {
lab=w_px}
N -1150 -4470 -1140 -4470 {
lab=ctrl_pos}
N -1100 -4590 -1100 -4570 {
lab=#net155}
N -1100 -4510 -1100 -4500 {
lab=#net156}
N -840 -4550 -840 -4540 {
lab=GND}
N -840 -4660 -840 -4650 {
lab=vdd_syn7}
N -780 -4470 -770 -4470 {
lab=GND}
N -780 -4440 -780 -4430 {
lab=p7}
N -910 -4610 -900 -4610 {
lab=vpres6}
N -780 -4610 -770 -4610 {
lab=b_px}
N -830 -4470 -820 -4470 {
lab=ctrl_pos}
N -780 -4590 -780 -4570 {
lab=#net157}
N -780 -4510 -780 -4500 {
lab=#net158}
N -520 -4550 -520 -4540 {
lab=GND}
N -520 -4660 -520 -4650 {
lab=vdd_syn8}
N -460 -4470 -450 -4470 {
lab=GND}
N -460 -4440 -460 -4430 {
lab=p8}
N -590 -4610 -580 -4610 {
lab=vpres6}
N -460 -4610 -450 -4610 {
lab=b_px}
N -510 -4470 -500 -4470 {
lab=ctrl_pos}
N -460 -4590 -460 -4570 {
lab=#net159}
N -460 -4510 -460 -4500 {
lab=#net160}
N -200 -4550 -200 -4540 {
lab=GND}
N -200 -4660 -200 -4650 {
lab=vdd_syn9}
N -140 -4470 -130 -4470 {
lab=GND}
N -140 -4440 -140 -4430 {
lab=p9}
N -270 -4610 -260 -4610 {
lab=vpres6}
N -140 -4610 -130 -4610 {
lab=b_px}
N -190 -4470 -180 -4470 {
lab=ctrl_pos}
N -140 -4590 -140 -4570 {
lab=#net161}
N -140 -4510 -140 -4500 {
lab=#net162}
N -2760 -4100 -2760 -4090 {
lab=GND}
N -2760 -4210 -2760 -4200 {
lab=vdd_syn1}
N -2700 -4020 -2690 -4020 {
lab=GND}
N -2700 -3990 -2700 -3980 {
lab=p1}
N -2830 -4160 -2820 -4160 {
lab=vpres7}
N -2700 -4160 -2690 -4160 {
lab=w_px}
N -2750 -4020 -2740 -4020 {
lab=ctrl_pos}
N -2700 -4140 -2700 -4120 {
lab=#net163}
N -2700 -4060 -2700 -4050 {
lab=#net164}
N -2440 -4100 -2440 -4090 {
lab=GND}
N -2440 -4210 -2440 -4200 {
lab=vdd_syn2}
N -2380 -4020 -2370 -4020 {
lab=GND}
N -2380 -3990 -2380 -3980 {
lab=p2}
N -2510 -4160 -2500 -4160 {
lab=vpres7}
N -2380 -4160 -2370 -4160 {
lab=w_px}
N -2430 -4020 -2420 -4020 {
lab=ctrl_pos}
N -2380 -4140 -2380 -4120 {
lab=#net165}
N -2380 -4060 -2380 -4050 {
lab=#net166}
N -2120 -4100 -2120 -4090 {
lab=GND}
N -2120 -4210 -2120 -4200 {
lab=vdd_syn3}
N -2060 -4020 -2050 -4020 {
lab=GND}
N -2060 -3990 -2060 -3980 {
lab=p3}
N -2190 -4160 -2180 -4160 {
lab=vpres7}
N -2060 -4160 -2050 -4160 {
lab=w_px}
N -2110 -4020 -2100 -4020 {
lab=ctrl_pos}
N -2060 -4140 -2060 -4120 {
lab=#net167}
N -2060 -4060 -2060 -4050 {
lab=#net168}
N -1800 -4100 -1800 -4090 {
lab=GND}
N -1800 -4210 -1800 -4200 {
lab=vdd_syn4}
N -1740 -4020 -1730 -4020 {
lab=GND}
N -1740 -3990 -1740 -3980 {
lab=p4}
N -1870 -4160 -1860 -4160 {
lab=vpres7}
N -1740 -4160 -1730 -4160 {
lab=w_px}
N -1790 -4020 -1780 -4020 {
lab=ctrl_pos}
N -1740 -4140 -1740 -4120 {
lab=#net169}
N -1740 -4060 -1740 -4050 {
lab=#net170}
N -1480 -4100 -1480 -4090 {
lab=GND}
N -1480 -4210 -1480 -4200 {
lab=vdd_syn5}
N -1420 -4020 -1410 -4020 {
lab=GND}
N -1420 -3990 -1420 -3980 {
lab=p5}
N -1550 -4160 -1540 -4160 {
lab=vpres7}
N -1420 -4160 -1410 -4160 {
lab=w_px}
N -1470 -4020 -1460 -4020 {
lab=ctrl_pos}
N -1420 -4140 -1420 -4120 {
lab=#net171}
N -1420 -4060 -1420 -4050 {
lab=#net172}
N -1160 -4100 -1160 -4090 {
lab=GND}
N -1160 -4210 -1160 -4200 {
lab=vdd_syn6}
N -1100 -4020 -1090 -4020 {
lab=GND}
N -1100 -3990 -1100 -3980 {
lab=p6}
N -1230 -4160 -1220 -4160 {
lab=vpres7}
N -1100 -4160 -1090 -4160 {
lab=b_px}
N -1150 -4020 -1140 -4020 {
lab=ctrl_pos}
N -1100 -4140 -1100 -4120 {
lab=#net173}
N -1100 -4060 -1100 -4050 {
lab=#net174}
N -840 -4100 -840 -4090 {
lab=GND}
N -840 -4210 -840 -4200 {
lab=vdd_syn7}
N -780 -4020 -770 -4020 {
lab=GND}
N -780 -3990 -780 -3980 {
lab=p7}
N -910 -4160 -900 -4160 {
lab=vpres7}
N -780 -4160 -770 -4160 {
lab=w_px}
N -830 -4020 -820 -4020 {
lab=ctrl_pos}
N -780 -4140 -780 -4120 {
lab=#net175}
N -780 -4060 -780 -4050 {
lab=#net176}
N -520 -4100 -520 -4090 {
lab=GND}
N -520 -4210 -520 -4200 {
lab=vdd_syn8}
N -460 -4020 -450 -4020 {
lab=GND}
N -460 -3990 -460 -3980 {
lab=p8}
N -590 -4160 -580 -4160 {
lab=vpres7}
N -460 -4160 -450 -4160 {
lab=w_px}
N -510 -4020 -500 -4020 {
lab=ctrl_pos}
N -460 -4140 -460 -4120 {
lab=#net177}
N -460 -4060 -460 -4050 {
lab=#net178}
N -200 -4100 -200 -4090 {
lab=GND}
N -200 -4210 -200 -4200 {
lab=vdd_syn9}
N -140 -4020 -130 -4020 {
lab=GND}
N -140 -3990 -140 -3980 {
lab=p9}
N -270 -4160 -260 -4160 {
lab=vpres7}
N -140 -4160 -130 -4160 {
lab=w_px}
N -190 -4020 -180 -4020 {
lab=ctrl_pos}
N -140 -4140 -140 -4120 {
lab=#net179}
N -140 -4060 -140 -4050 {
lab=#net180}
N -2760 -3650 -2760 -3640 {
lab=GND}
N -2760 -3760 -2760 -3750 {
lab=vdd_syn1}
N -2700 -3570 -2690 -3570 {
lab=GND}
N -2700 -3540 -2700 -3530 {
lab=p1}
N -2830 -3710 -2820 -3710 {
lab=vpres8}
N -2700 -3710 -2690 -3710 {
lab=b_px}
N -2750 -3570 -2740 -3570 {
lab=ctrl_pos}
N -2700 -3690 -2700 -3670 {
lab=#net181}
N -2700 -3610 -2700 -3600 {
lab=#net182}
N -2440 -3650 -2440 -3640 {
lab=GND}
N -2440 -3760 -2440 -3750 {
lab=vdd_syn2}
N -2380 -3570 -2370 -3570 {
lab=GND}
N -2380 -3540 -2380 -3530 {
lab=p2}
N -2510 -3710 -2500 -3710 {
lab=vpres8}
N -2380 -3710 -2370 -3710 {
lab=b_px}
N -2430 -3570 -2420 -3570 {
lab=ctrl_pos}
N -2380 -3690 -2380 -3670 {
lab=#net183}
N -2380 -3610 -2380 -3600 {
lab=#net184}
N -2120 -3650 -2120 -3640 {
lab=GND}
N -2120 -3760 -2120 -3750 {
lab=vdd_syn3}
N -2060 -3570 -2050 -3570 {
lab=GND}
N -2060 -3540 -2060 -3530 {
lab=p3}
N -2190 -3710 -2180 -3710 {
lab=vpres8}
N -2060 -3710 -2050 -3710 {
lab=b_px}
N -2110 -3570 -2100 -3570 {
lab=ctrl_pos}
N -2060 -3690 -2060 -3670 {
lab=#net185}
N -2060 -3610 -2060 -3600 {
lab=#net186}
N -1800 -3650 -1800 -3640 {
lab=GND}
N -1800 -3760 -1800 -3750 {
lab=vdd_syn4}
N -1740 -3570 -1730 -3570 {
lab=GND}
N -1740 -3540 -1740 -3530 {
lab=p4}
N -1870 -3710 -1860 -3710 {
lab=vpres8}
N -1740 -3710 -1730 -3710 {
lab=b_px}
N -1790 -3570 -1780 -3570 {
lab=ctrl_pos}
N -1740 -3690 -1740 -3670 {
lab=#net187}
N -1740 -3610 -1740 -3600 {
lab=#net188}
N -1480 -3650 -1480 -3640 {
lab=GND}
N -1480 -3760 -1480 -3750 {
lab=vdd_syn5}
N -1420 -3570 -1410 -3570 {
lab=GND}
N -1420 -3540 -1420 -3530 {
lab=p5}
N -1550 -3710 -1540 -3710 {
lab=vpres8}
N -1420 -3710 -1410 -3710 {
lab=b_px}
N -1470 -3570 -1460 -3570 {
lab=ctrl_pos}
N -1420 -3690 -1420 -3670 {
lab=#net189}
N -1420 -3610 -1420 -3600 {
lab=#net190}
N -1160 -3650 -1160 -3640 {
lab=GND}
N -1160 -3760 -1160 -3750 {
lab=vdd_syn6}
N -1100 -3570 -1090 -3570 {
lab=GND}
N -1100 -3540 -1100 -3530 {
lab=p6}
N -1230 -3710 -1220 -3710 {
lab=vpres8}
N -1100 -3710 -1090 -3710 {
lab=b_px}
N -1150 -3570 -1140 -3570 {
lab=ctrl_pos}
N -1100 -3690 -1100 -3670 {
lab=#net191}
N -1100 -3610 -1100 -3600 {
lab=#net192}
N -840 -3650 -840 -3640 {
lab=GND}
N -840 -3760 -840 -3750 {
lab=vdd_syn7}
N -780 -3570 -770 -3570 {
lab=GND}
N -780 -3540 -780 -3530 {
lab=p7}
N -910 -3710 -900 -3710 {
lab=vpres8}
N -780 -3710 -770 -3710 {
lab=w_px}
N -830 -3570 -820 -3570 {
lab=ctrl_pos}
N -780 -3690 -780 -3670 {
lab=#net193}
N -780 -3610 -780 -3600 {
lab=#net194}
N -520 -3650 -520 -3640 {
lab=GND}
N -520 -3760 -520 -3750 {
lab=vdd_syn8}
N -460 -3570 -450 -3570 {
lab=GND}
N -460 -3540 -460 -3530 {
lab=p8}
N -590 -3710 -580 -3710 {
lab=vpres8}
N -460 -3710 -450 -3710 {
lab=b_px}
N -510 -3570 -500 -3570 {
lab=ctrl_pos}
N -460 -3690 -460 -3670 {
lab=#net195}
N -460 -3610 -460 -3600 {
lab=#net196}
N -200 -3650 -200 -3640 {
lab=GND}
N -200 -3760 -200 -3750 {
lab=vdd_syn9}
N -140 -3570 -130 -3570 {
lab=GND}
N -140 -3540 -140 -3530 {
lab=p9}
N -270 -3710 -260 -3710 {
lab=vpres8}
N -140 -3710 -130 -3710 {
lab=b_px}
N -190 -3570 -180 -3570 {
lab=ctrl_pos}
N -140 -3690 -140 -3670 {
lab=#net197}
N -140 -3610 -140 -3600 {
lab=#net198}
N -2760 -3200 -2760 -3190 {
lab=GND}
N -2760 -3310 -2760 -3300 {
lab=vdd_syn1}
N -2700 -3120 -2690 -3120 {
lab=GND}
N -2700 -3090 -2700 -3080 {
lab=p1}
N -2830 -3260 -2820 -3260 {
lab=vpres9}
N -2700 -3260 -2690 -3260 {
lab=w_px}
N -2750 -3120 -2740 -3120 {
lab=ctrl_pos}
N -2700 -3240 -2700 -3220 {
lab=#net199}
N -2700 -3160 -2700 -3150 {
lab=#net200}
N -2440 -3200 -2440 -3190 {
lab=GND}
N -2440 -3310 -2440 -3300 {
lab=vdd_syn2}
N -2380 -3120 -2370 -3120 {
lab=GND}
N -2380 -3090 -2380 -3080 {
lab=p2}
N -2510 -3260 -2500 -3260 {
lab=vpres9}
N -2380 -3260 -2370 -3260 {
lab=w_px}
N -2430 -3120 -2420 -3120 {
lab=ctrl_pos}
N -2380 -3240 -2380 -3220 {
lab=#net201}
N -2380 -3160 -2380 -3150 {
lab=#net202}
N -2120 -3200 -2120 -3190 {
lab=GND}
N -2120 -3310 -2120 -3300 {
lab=vdd_syn3}
N -2060 -3120 -2050 -3120 {
lab=GND}
N -2060 -3090 -2060 -3080 {
lab=p3}
N -2190 -3260 -2180 -3260 {
lab=vpres9}
N -2060 -3260 -2050 -3260 {
lab=w_px}
N -2110 -3120 -2100 -3120 {
lab=ctrl_pos}
N -2060 -3240 -2060 -3220 {
lab=#net203}
N -2060 -3160 -2060 -3150 {
lab=#net204}
N -1800 -3200 -1800 -3190 {
lab=GND}
N -1800 -3310 -1800 -3300 {
lab=vdd_syn4}
N -1740 -3120 -1730 -3120 {
lab=GND}
N -1740 -3090 -1740 -3080 {
lab=p4}
N -1870 -3260 -1860 -3260 {
lab=vpres9}
N -1740 -3260 -1730 -3260 {
lab=b_px}
N -1790 -3120 -1780 -3120 {
lab=ctrl_pos}
N -1740 -3240 -1740 -3220 {
lab=#net205}
N -1740 -3160 -1740 -3150 {
lab=#net206}
N -1480 -3200 -1480 -3190 {
lab=GND}
N -1480 -3310 -1480 -3300 {
lab=vdd_syn5}
N -1420 -3120 -1410 -3120 {
lab=GND}
N -1420 -3090 -1420 -3080 {
lab=p5}
N -1550 -3260 -1540 -3260 {
lab=vpres9}
N -1420 -3260 -1410 -3260 {
lab=w_px}
N -1470 -3120 -1460 -3120 {
lab=ctrl_pos}
N -1420 -3240 -1420 -3220 {
lab=#net207}
N -1420 -3160 -1420 -3150 {
lab=#net208}
N -1160 -3200 -1160 -3190 {
lab=GND}
N -1160 -3310 -1160 -3300 {
lab=vdd_syn6}
N -1100 -3120 -1090 -3120 {
lab=GND}
N -1100 -3090 -1100 -3080 {
lab=p6}
N -1230 -3260 -1220 -3260 {
lab=vpres9}
N -1100 -3260 -1090 -3260 {
lab=w_px}
N -1150 -3120 -1140 -3120 {
lab=ctrl_pos}
N -1100 -3240 -1100 -3220 {
lab=#net209}
N -1100 -3160 -1100 -3150 {
lab=#net210}
N -840 -3200 -840 -3190 {
lab=GND}
N -840 -3310 -840 -3300 {
lab=vdd_syn7}
N -780 -3120 -770 -3120 {
lab=GND}
N -780 -3090 -780 -3080 {
lab=p7}
N -910 -3260 -900 -3260 {
lab=vpres9}
N -780 -3260 -770 -3260 {
lab=b_px}
N -830 -3120 -820 -3120 {
lab=ctrl_pos}
N -780 -3240 -780 -3220 {
lab=#net211}
N -780 -3160 -780 -3150 {
lab=#net212}
N -520 -3200 -520 -3190 {
lab=GND}
N -520 -3310 -520 -3300 {
lab=vdd_syn8}
N -460 -3120 -450 -3120 {
lab=GND}
N -460 -3090 -460 -3080 {
lab=p8}
N -590 -3260 -580 -3260 {
lab=vpres9}
N -460 -3260 -450 -3260 {
lab=w_px}
N -510 -3120 -500 -3120 {
lab=ctrl_pos}
N -460 -3240 -460 -3220 {
lab=#net213}
N -460 -3160 -460 -3150 {
lab=#net214}
N -200 -3200 -200 -3190 {
lab=GND}
N -200 -3310 -200 -3300 {
lab=vdd_syn9}
N -140 -3120 -130 -3120 {
lab=GND}
N -140 -3090 -140 -3080 {
lab=p9}
N -270 -3260 -260 -3260 {
lab=vpres9}
N -140 -3260 -130 -3260 {
lab=b_px}
N -190 -3120 -180 -3120 {
lab=ctrl_pos}
N -140 -3240 -140 -3220 {
lab=#net215}
N -140 -3160 -140 -3150 {
lab=#net216}
N -2760 -2750 -2760 -2740 {
lab=GND}
N -2760 -2860 -2760 -2850 {
lab=vdd_syn1}
N -2700 -2670 -2690 -2670 {
lab=GND}
N -2700 -2640 -2700 -2630 {
lab=p1}
N -2830 -2810 -2820 -2810 {
lab=vpres10}
N -2700 -2810 -2690 -2810 {
lab=w_px}
N -2750 -2670 -2740 -2670 {
lab=ctrl_pos}
N -2700 -2790 -2700 -2770 {
lab=#net217}
N -2700 -2710 -2700 -2700 {
lab=#net218}
N -2440 -2750 -2440 -2740 {
lab=GND}
N -2440 -2860 -2440 -2850 {
lab=vdd_syn2}
N -2380 -2670 -2370 -2670 {
lab=GND}
N -2380 -2640 -2380 -2630 {
lab=p2}
N -2510 -2810 -2500 -2810 {
lab=vpres10}
N -2380 -2810 -2370 -2810 {
lab=b_px}
N -2430 -2670 -2420 -2670 {
lab=ctrl_pos}
N -2380 -2790 -2380 -2770 {
lab=#net219}
N -2380 -2710 -2380 -2700 {
lab=#net220}
N -2120 -2750 -2120 -2740 {
lab=GND}
N -2120 -2860 -2120 -2850 {
lab=vdd_syn3}
N -2060 -2670 -2050 -2670 {
lab=GND}
N -2060 -2640 -2060 -2630 {
lab=p3}
N -2190 -2810 -2180 -2810 {
lab=vpres10}
N -2060 -2810 -2050 -2810 {
lab=w_px}
N -2110 -2670 -2100 -2670 {
lab=ctrl_pos}
N -2060 -2790 -2060 -2770 {
lab=#net221}
N -2060 -2710 -2060 -2700 {
lab=#net222}
N -1800 -2750 -1800 -2740 {
lab=GND}
N -1800 -2860 -1800 -2850 {
lab=vdd_syn4}
N -1740 -2670 -1730 -2670 {
lab=GND}
N -1740 -2640 -1740 -2630 {
lab=p4}
N -1870 -2810 -1860 -2810 {
lab=vpres10}
N -1740 -2810 -1730 -2810 {
lab=w_px}
N -1790 -2670 -1780 -2670 {
lab=ctrl_pos}
N -1740 -2790 -1740 -2770 {
lab=#net223}
N -1740 -2710 -1740 -2700 {
lab=#net224}
N -1480 -2750 -1480 -2740 {
lab=GND}
N -1480 -2860 -1480 -2850 {
lab=vdd_syn5}
N -1420 -2670 -1410 -2670 {
lab=GND}
N -1420 -2640 -1420 -2630 {
lab=p5}
N -1550 -2810 -1540 -2810 {
lab=vpres10}
N -1420 -2810 -1410 -2810 {
lab=w_px}
N -1470 -2670 -1460 -2670 {
lab=ctrl_pos}
N -1420 -2790 -1420 -2770 {
lab=#net225}
N -1420 -2710 -1420 -2700 {
lab=#net226}
N -1160 -2750 -1160 -2740 {
lab=GND}
N -1160 -2860 -1160 -2850 {
lab=vdd_syn6}
N -1100 -2670 -1090 -2670 {
lab=GND}
N -1100 -2640 -1100 -2630 {
lab=p6}
N -1230 -2810 -1220 -2810 {
lab=vpres10}
N -1100 -2810 -1090 -2810 {
lab=b_px}
N -1150 -2670 -1140 -2670 {
lab=ctrl_pos}
N -1100 -2790 -1100 -2770 {
lab=#net227}
N -1100 -2710 -1100 -2700 {
lab=#net228}
N -840 -2750 -840 -2740 {
lab=GND}
N -840 -2860 -840 -2850 {
lab=vdd_syn7}
N -780 -2670 -770 -2670 {
lab=GND}
N -780 -2640 -780 -2630 {
lab=p7}
N -910 -2810 -900 -2810 {
lab=vpres10}
N -780 -2810 -770 -2810 {
lab=w_px}
N -830 -2670 -820 -2670 {
lab=ctrl_pos}
N -780 -2790 -780 -2770 {
lab=#net229}
N -780 -2710 -780 -2700 {
lab=#net230}
N -520 -2750 -520 -2740 {
lab=GND}
N -520 -2860 -520 -2850 {
lab=vdd_syn8}
N -460 -2670 -450 -2670 {
lab=GND}
N -460 -2640 -460 -2630 {
lab=p8}
N -590 -2810 -580 -2810 {
lab=vpres10}
N -460 -2810 -450 -2810 {
lab=b_px}
N -510 -2670 -500 -2670 {
lab=ctrl_pos}
N -460 -2790 -460 -2770 {
lab=#net231}
N -460 -2710 -460 -2700 {
lab=#net232}
N -200 -2750 -200 -2740 {
lab=GND}
N -200 -2860 -200 -2850 {
lab=vdd_syn9}
N -140 -2670 -130 -2670 {
lab=GND}
N -140 -2640 -140 -2630 {
lab=p9}
N -270 -2810 -260 -2810 {
lab=vpres10}
N -140 -2810 -130 -2810 {
lab=w_px}
N -190 -2670 -180 -2670 {
lab=ctrl_pos}
N -140 -2790 -140 -2770 {
lab=#net233}
N -140 -2710 -140 -2700 {
lab=#net234}
N -2760 -2300 -2760 -2290 {
lab=GND}
N -2760 -2410 -2760 -2400 {
lab=vdd_syn1}
N -2700 -2220 -2690 -2220 {
lab=GND}
N -2700 -2190 -2700 -2180 {
lab=p1}
N -2830 -2360 -2820 -2360 {
lab=vpres11}
N -2700 -2360 -2690 -2360 {
lab=b_px}
N -2750 -2220 -2740 -2220 {
lab=ctrl_pos}
N -2700 -2340 -2700 -2320 {
lab=#net235}
N -2700 -2260 -2700 -2250 {
lab=#net236}
N -2440 -2300 -2440 -2290 {
lab=GND}
N -2440 -2410 -2440 -2400 {
lab=vdd_syn2}
N -2380 -2220 -2370 -2220 {
lab=GND}
N -2380 -2190 -2380 -2180 {
lab=p2}
N -2510 -2360 -2500 -2360 {
lab=vpres11}
N -2380 -2360 -2370 -2360 {
lab=w_px}
N -2430 -2220 -2420 -2220 {
lab=ctrl_pos}
N -2380 -2340 -2380 -2320 {
lab=#net237}
N -2380 -2260 -2380 -2250 {
lab=#net238}
N -2120 -2300 -2120 -2290 {
lab=GND}
N -2120 -2410 -2120 -2400 {
lab=vdd_syn3}
N -2060 -2220 -2050 -2220 {
lab=GND}
N -2060 -2190 -2060 -2180 {
lab=p3}
N -2190 -2360 -2180 -2360 {
lab=vpres11}
N -2060 -2360 -2050 -2360 {
lab=w_px}
N -2110 -2220 -2100 -2220 {
lab=ctrl_pos}
N -2060 -2340 -2060 -2320 {
lab=#net239}
N -2060 -2260 -2060 -2250 {
lab=#net240}
N -1800 -2300 -1800 -2290 {
lab=GND}
N -1800 -2410 -1800 -2400 {
lab=vdd_syn4}
N -1740 -2220 -1730 -2220 {
lab=GND}
N -1740 -2190 -1740 -2180 {
lab=p4}
N -1870 -2360 -1860 -2360 {
lab=vpres11}
N -1740 -2360 -1730 -2360 {
lab=w_px}
N -1790 -2220 -1780 -2220 {
lab=ctrl_pos}
N -1740 -2340 -1740 -2320 {
lab=#net241}
N -1740 -2260 -1740 -2250 {
lab=#net242}
N -1480 -2300 -1480 -2290 {
lab=GND}
N -1480 -2410 -1480 -2400 {
lab=vdd_syn5}
N -1420 -2220 -1410 -2220 {
lab=GND}
N -1420 -2190 -1420 -2180 {
lab=p5}
N -1550 -2360 -1540 -2360 {
lab=vpres11}
N -1420 -2360 -1410 -2360 {
lab=w_px}
N -1470 -2220 -1460 -2220 {
lab=ctrl_pos}
N -1420 -2340 -1420 -2320 {
lab=#net243}
N -1420 -2260 -1420 -2250 {
lab=#net244}
N -1160 -2300 -1160 -2290 {
lab=GND}
N -1160 -2410 -1160 -2400 {
lab=vdd_syn6}
N -1100 -2220 -1090 -2220 {
lab=GND}
N -1100 -2190 -1100 -2180 {
lab=p6}
N -1230 -2360 -1220 -2360 {
lab=vpres11}
N -1100 -2360 -1090 -2360 {
lab=w_px}
N -1150 -2220 -1140 -2220 {
lab=ctrl_pos}
N -1100 -2340 -1100 -2320 {
lab=#net245}
N -1100 -2260 -1100 -2250 {
lab=#net246}
N -840 -2300 -840 -2290 {
lab=GND}
N -840 -2410 -840 -2400 {
lab=vdd_syn7}
N -780 -2220 -770 -2220 {
lab=GND}
N -780 -2190 -780 -2180 {
lab=p7}
N -910 -2360 -900 -2360 {
lab=vpres11}
N -780 -2360 -770 -2360 {
lab=b_px}
N -830 -2220 -820 -2220 {
lab=ctrl_pos}
N -780 -2340 -780 -2320 {
lab=#net247}
N -780 -2260 -780 -2250 {
lab=#net248}
N -520 -2300 -520 -2290 {
lab=GND}
N -520 -2410 -520 -2400 {
lab=vdd_syn8}
N -460 -2220 -450 -2220 {
lab=GND}
N -460 -2190 -460 -2180 {
lab=p8}
N -590 -2360 -580 -2360 {
lab=vpres11}
N -460 -2360 -450 -2360 {
lab=w_px}
N -510 -2220 -500 -2220 {
lab=ctrl_pos}
N -460 -2340 -460 -2320 {
lab=#net249}
N -460 -2260 -460 -2250 {
lab=#net250}
N -200 -2300 -200 -2290 {
lab=GND}
N -200 -2410 -200 -2400 {
lab=vdd_syn9}
N -140 -2220 -130 -2220 {
lab=GND}
N -140 -2190 -140 -2180 {
lab=p9}
N -270 -2360 -260 -2360 {
lab=vpres11}
N -140 -2360 -130 -2360 {
lab=w_px}
N -190 -2220 -180 -2220 {
lab=ctrl_pos}
N -140 -2340 -140 -2320 {
lab=#net251}
N -140 -2260 -140 -2250 {
lab=#net252}
N -2760 -1850 -2760 -1840 {
lab=GND}
N -2760 -1960 -2760 -1950 {
lab=vdd_syn1}
N -2700 -1770 -2690 -1770 {
lab=GND}
N -2700 -1740 -2700 -1730 {
lab=p1}
N -2830 -1910 -2820 -1910 {
lab=vpres12}
N -2700 -1910 -2690 -1910 {
lab=w_px}
N -2750 -1770 -2740 -1770 {
lab=ctrl_pos}
N -2700 -1890 -2700 -1870 {
lab=#net253}
N -2700 -1810 -2700 -1800 {
lab=#net254}
N -2440 -1850 -2440 -1840 {
lab=GND}
N -2440 -1960 -2440 -1950 {
lab=vdd_syn2}
N -2380 -1770 -2370 -1770 {
lab=GND}
N -2380 -1740 -2380 -1730 {
lab=p2}
N -2510 -1910 -2500 -1910 {
lab=vpres12}
N -2380 -1910 -2370 -1910 {
lab=w_px}
N -2430 -1770 -2420 -1770 {
lab=ctrl_pos}
N -2380 -1890 -2380 -1870 {
lab=#net255}
N -2380 -1810 -2380 -1800 {
lab=#net256}
N -2120 -1850 -2120 -1840 {
lab=GND}
N -2120 -1960 -2120 -1950 {
lab=vdd_syn3}
N -2060 -1770 -2050 -1770 {
lab=GND}
N -2060 -1740 -2060 -1730 {
lab=p3}
N -2190 -1910 -2180 -1910 {
lab=vpres12}
N -2060 -1910 -2050 -1910 {
lab=b_px}
N -2110 -1770 -2100 -1770 {
lab=ctrl_pos}
N -2060 -1890 -2060 -1870 {
lab=#net257}
N -2060 -1810 -2060 -1800 {
lab=#net258}
N -1800 -1850 -1800 -1840 {
lab=GND}
N -1800 -1960 -1800 -1950 {
lab=vdd_syn4}
N -1740 -1770 -1730 -1770 {
lab=GND}
N -1740 -1740 -1740 -1730 {
lab=p4}
N -1870 -1910 -1860 -1910 {
lab=vpres12}
N -1740 -1910 -1730 -1910 {
lab=b_px}
N -1790 -1770 -1780 -1770 {
lab=ctrl_pos}
N -1740 -1890 -1740 -1870 {
lab=#net259}
N -1740 -1810 -1740 -1800 {
lab=#net260}
N -1480 -1850 -1480 -1840 {
lab=GND}
N -1480 -1960 -1480 -1950 {
lab=vdd_syn5}
N -1420 -1770 -1410 -1770 {
lab=GND}
N -1420 -1740 -1420 -1730 {
lab=p5}
N -1550 -1910 -1540 -1910 {
lab=vpres12}
N -1420 -1910 -1410 -1910 {
lab=b_px}
N -1470 -1770 -1460 -1770 {
lab=ctrl_pos}
N -1420 -1890 -1420 -1870 {
lab=#net261}
N -1420 -1810 -1420 -1800 {
lab=#net262}
N -1160 -1850 -1160 -1840 {
lab=GND}
N -1160 -1960 -1160 -1950 {
lab=vdd_syn6}
N -1100 -1770 -1090 -1770 {
lab=GND}
N -1100 -1740 -1100 -1730 {
lab=p6}
N -1230 -1910 -1220 -1910 {
lab=vpres12}
N -1100 -1910 -1090 -1910 {
lab=b_px}
N -1150 -1770 -1140 -1770 {
lab=ctrl_pos}
N -1100 -1890 -1100 -1870 {
lab=#net263}
N -1100 -1810 -1100 -1800 {
lab=#net264}
N -840 -1850 -840 -1840 {
lab=GND}
N -840 -1960 -840 -1950 {
lab=vdd_syn7}
N -780 -1770 -770 -1770 {
lab=GND}
N -780 -1740 -780 -1730 {
lab=p7}
N -910 -1910 -900 -1910 {
lab=vpres12}
N -780 -1910 -770 -1910 {
lab=w_px}
N -830 -1770 -820 -1770 {
lab=ctrl_pos}
N -780 -1890 -780 -1870 {
lab=#net265}
N -780 -1810 -780 -1800 {
lab=#net266}
N -520 -1850 -520 -1840 {
lab=GND}
N -520 -1960 -520 -1950 {
lab=vdd_syn8}
N -460 -1770 -450 -1770 {
lab=GND}
N -460 -1740 -460 -1730 {
lab=p8}
N -590 -1910 -580 -1910 {
lab=vpres12}
N -460 -1910 -450 -1910 {
lab=b_px}
N -510 -1770 -500 -1770 {
lab=ctrl_pos}
N -460 -1890 -460 -1870 {
lab=#net267}
N -460 -1810 -460 -1800 {
lab=#net268}
N -200 -1850 -200 -1840 {
lab=GND}
N -200 -1960 -200 -1950 {
lab=vdd_syn9}
N -140 -1770 -130 -1770 {
lab=GND}
N -140 -1740 -140 -1730 {
lab=p9}
N -270 -1910 -260 -1910 {
lab=vpres12}
N -140 -1910 -130 -1910 {
lab=b_px}
N -190 -1770 -180 -1770 {
lab=ctrl_pos}
N -140 -1890 -140 -1870 {
lab=#net269}
N -140 -1810 -140 -1800 {
lab=#net270}
N -2760 -1400 -2760 -1390 {
lab=GND}
N -2760 -1510 -2760 -1500 {
lab=vdd_syn1}
N -2700 -1320 -2690 -1320 {
lab=GND}
N -2700 -1290 -2700 -1280 {
lab=p1}
N -2830 -1460 -2820 -1460 {
lab=vpres13}
N -2700 -1460 -2690 -1460 {
lab=b_px}
N -2750 -1320 -2740 -1320 {
lab=ctrl_pos}
N -2700 -1440 -2700 -1420 {
lab=#net271}
N -2700 -1360 -2700 -1350 {
lab=#net272}
N -2440 -1400 -2440 -1390 {
lab=GND}
N -2440 -1510 -2440 -1500 {
lab=vdd_syn2}
N -2380 -1320 -2370 -1320 {
lab=GND}
N -2380 -1290 -2380 -1280 {
lab=p2}
N -2510 -1460 -2500 -1460 {
lab=vpres13}
N -2380 -1460 -2370 -1460 {
lab=b_px}
N -2430 -1320 -2420 -1320 {
lab=ctrl_pos}
N -2380 -1440 -2380 -1420 {
lab=#net273}
N -2380 -1360 -2380 -1350 {
lab=#net274}
N -2120 -1400 -2120 -1390 {
lab=GND}
N -2120 -1510 -2120 -1500 {
lab=vdd_syn3}
N -2060 -1320 -2050 -1320 {
lab=GND}
N -2060 -1290 -2060 -1280 {
lab=p3}
N -2190 -1460 -2180 -1460 {
lab=vpres13}
N -2060 -1460 -2050 -1460 {
lab=b_px}
N -2110 -1320 -2100 -1320 {
lab=ctrl_pos}
N -2060 -1440 -2060 -1420 {
lab=#net275}
N -2060 -1360 -2060 -1350 {
lab=#net276}
N -1800 -1400 -1800 -1390 {
lab=GND}
N -1800 -1510 -1800 -1500 {
lab=vdd_syn4}
N -1740 -1320 -1730 -1320 {
lab=GND}
N -1740 -1290 -1740 -1280 {
lab=p4}
N -1870 -1460 -1860 -1460 {
lab=vpres13}
N -1740 -1460 -1730 -1460 {
lab=w_px}
N -1790 -1320 -1780 -1320 {
lab=ctrl_pos}
N -1740 -1440 -1740 -1420 {
lab=#net277}
N -1740 -1360 -1740 -1350 {
lab=#net278}
N -1480 -1400 -1480 -1390 {
lab=GND}
N -1480 -1510 -1480 -1500 {
lab=vdd_syn5}
N -1420 -1320 -1410 -1320 {
lab=GND}
N -1420 -1290 -1420 -1280 {
lab=p5}
N -1550 -1460 -1540 -1460 {
lab=vpres13}
N -1420 -1460 -1410 -1460 {
lab=b_px}
N -1470 -1320 -1460 -1320 {
lab=ctrl_pos}
N -1420 -1440 -1420 -1420 {
lab=#net279}
N -1420 -1360 -1420 -1350 {
lab=#net280}
N -1160 -1400 -1160 -1390 {
lab=GND}
N -1160 -1510 -1160 -1500 {
lab=vdd_syn6}
N -1100 -1320 -1090 -1320 {
lab=GND}
N -1100 -1290 -1100 -1280 {
lab=p6}
N -1230 -1460 -1220 -1460 {
lab=vpres13}
N -1100 -1460 -1090 -1460 {
lab=w_px}
N -1150 -1320 -1140 -1320 {
lab=ctrl_pos}
N -1100 -1440 -1100 -1420 {
lab=#net281}
N -1100 -1360 -1100 -1350 {
lab=#net282}
N -840 -1400 -840 -1390 {
lab=GND}
N -840 -1510 -840 -1500 {
lab=vdd_syn7}
N -780 -1320 -770 -1320 {
lab=GND}
N -780 -1290 -780 -1280 {
lab=p7}
N -910 -1460 -900 -1460 {
lab=vpres13}
N -780 -1460 -770 -1460 {
lab=b_px}
N -830 -1320 -820 -1320 {
lab=ctrl_pos}
N -780 -1440 -780 -1420 {
lab=#net283}
N -780 -1360 -780 -1350 {
lab=#net284}
N -520 -1400 -520 -1390 {
lab=GND}
N -520 -1510 -520 -1500 {
lab=vdd_syn8}
N -460 -1320 -450 -1320 {
lab=GND}
N -460 -1290 -460 -1280 {
lab=p8}
N -590 -1460 -580 -1460 {
lab=vpres13}
N -460 -1460 -450 -1460 {
lab=w_px}
N -510 -1320 -500 -1320 {
lab=ctrl_pos}
N -460 -1440 -460 -1420 {
lab=#net285}
N -460 -1360 -460 -1350 {
lab=#net286}
N -200 -1400 -200 -1390 {
lab=GND}
N -200 -1510 -200 -1500 {
lab=vdd_syn9}
N -140 -1320 -130 -1320 {
lab=GND}
N -140 -1290 -140 -1280 {
lab=p9}
N -270 -1460 -260 -1460 {
lab=vpres13}
N -140 -1460 -130 -1460 {
lab=w_px}
N -190 -1320 -180 -1320 {
lab=ctrl_pos}
N -140 -1440 -140 -1420 {
lab=#net287}
N -140 -1360 -140 -1350 {
lab=#net288}
N -2760 -950 -2760 -940 {
lab=GND}
N -2760 -1060 -2760 -1050 {
lab=vdd_syn1}
N -2700 -870 -2690 -870 {
lab=GND}
N -2700 -840 -2700 -830 {
lab=p1}
N -2830 -1010 -2820 -1010 {
lab=vpres14}
N -2700 -1010 -2690 -1010 {
lab=b_px}
N -2750 -870 -2740 -870 {
lab=ctrl_pos}
N -2700 -990 -2700 -970 {
lab=#net289}
N -2700 -910 -2700 -900 {
lab=#net290}
N -2440 -950 -2440 -940 {
lab=GND}
N -2440 -1060 -2440 -1050 {
lab=vdd_syn2}
N -2380 -870 -2370 -870 {
lab=GND}
N -2380 -840 -2380 -830 {
lab=p2}
N -2510 -1010 -2500 -1010 {
lab=vpres14}
N -2380 -1010 -2370 -1010 {
lab=b_px}
N -2430 -870 -2420 -870 {
lab=ctrl_pos}
N -2380 -990 -2380 -970 {
lab=#net291}
N -2380 -910 -2380 -900 {
lab=#net292}
N -2120 -950 -2120 -940 {
lab=GND}
N -2120 -1060 -2120 -1050 {
lab=vdd_syn3}
N -2060 -870 -2050 -870 {
lab=GND}
N -2060 -840 -2060 -830 {
lab=p3}
N -2190 -1010 -2180 -1010 {
lab=vpres14}
N -2060 -1010 -2050 -1010 {
lab=b_px}
N -2110 -870 -2100 -870 {
lab=ctrl_pos}
N -2060 -990 -2060 -970 {
lab=#net293}
N -2060 -910 -2060 -900 {
lab=#net294}
N -1800 -950 -1800 -940 {
lab=GND}
N -1800 -1060 -1800 -1050 {
lab=vdd_syn4}
N -1740 -870 -1730 -870 {
lab=GND}
N -1740 -840 -1740 -830 {
lab=p4}
N -1870 -1010 -1860 -1010 {
lab=vpres14}
N -1740 -1010 -1730 -1010 {
lab=w_px}
N -1790 -870 -1780 -870 {
lab=ctrl_pos}
N -1740 -990 -1740 -970 {
lab=#net295}
N -1740 -910 -1740 -900 {
lab=#net296}
N -1480 -950 -1480 -940 {
lab=GND}
N -1480 -1060 -1480 -1050 {
lab=vdd_syn5}
N -1420 -870 -1410 -870 {
lab=GND}
N -1420 -840 -1420 -830 {
lab=p5}
N -1550 -1010 -1540 -1010 {
lab=vpres14}
N -1420 -1010 -1410 -1010 {
lab=b_px}
N -1470 -870 -1460 -870 {
lab=ctrl_pos}
N -1420 -990 -1420 -970 {
lab=#net297}
N -1420 -910 -1420 -900 {
lab=#net298}
N -1160 -950 -1160 -940 {
lab=GND}
N -1160 -1060 -1160 -1050 {
lab=vdd_syn6}
N -1100 -870 -1090 -870 {
lab=GND}
N -1100 -840 -1100 -830 {
lab=p6}
N -1230 -1010 -1220 -1010 {
lab=vpres14}
N -1100 -1010 -1090 -1010 {
lab=b_px}
N -1150 -870 -1140 -870 {
lab=ctrl_pos}
N -1100 -990 -1100 -970 {
lab=#net299}
N -1100 -910 -1100 -900 {
lab=#net300}
N -840 -950 -840 -940 {
lab=GND}
N -840 -1060 -840 -1050 {
lab=vdd_syn7}
N -780 -870 -770 -870 {
lab=GND}
N -780 -840 -780 -830 {
lab=p7}
N -910 -1010 -900 -1010 {
lab=vpres14}
N -780 -1010 -770 -1010 {
lab=w_px}
N -830 -870 -820 -870 {
lab=ctrl_pos}
N -780 -990 -780 -970 {
lab=#net301}
N -780 -910 -780 -900 {
lab=#net302}
N -520 -950 -520 -940 {
lab=GND}
N -520 -1060 -520 -1050 {
lab=vdd_syn8}
N -460 -870 -450 -870 {
lab=GND}
N -460 -840 -460 -830 {
lab=p8}
N -590 -1010 -580 -1010 {
lab=vpres14}
N -460 -1010 -450 -1010 {
lab=b_px}
N -510 -870 -500 -870 {
lab=ctrl_pos}
N -460 -990 -460 -970 {
lab=#net303}
N -460 -910 -460 -900 {
lab=#net304}
N -200 -950 -200 -940 {
lab=GND}
N -200 -1060 -200 -1050 {
lab=vdd_syn9}
N -140 -870 -130 -870 {
lab=GND}
N -140 -840 -140 -830 {
lab=p9}
N -270 -1010 -260 -1010 {
lab=vpres14}
N -140 -1010 -130 -1010 {
lab=w_px}
N -190 -870 -180 -870 {
lab=ctrl_pos}
N -140 -990 -140 -970 {
lab=#net305}
N -140 -910 -140 -900 {
lab=#net306}
N -2760 -500 -2760 -490 {
lab=GND}
N -2760 -610 -2760 -600 {
lab=vdd_syn1}
N -2700 -420 -2690 -420 {
lab=GND}
N -2700 -390 -2700 -380 {
lab=p1}
N -2830 -560 -2820 -560 {
lab=vpres15}
N -2700 -560 -2690 -560 {
lab=b_px}
N -2750 -420 -2740 -420 {
lab=ctrl_pos}
N -2700 -540 -2700 -520 {
lab=#net307}
N -2700 -460 -2700 -450 {
lab=#net308}
N -2440 -500 -2440 -490 {
lab=GND}
N -2440 -610 -2440 -600 {
lab=vdd_syn2}
N -2380 -420 -2370 -420 {
lab=GND}
N -2380 -390 -2380 -380 {
lab=p2}
N -2510 -560 -2500 -560 {
lab=vpres15}
N -2380 -560 -2370 -560 {
lab=b_px}
N -2430 -420 -2420 -420 {
lab=ctrl_pos}
N -2380 -540 -2380 -520 {
lab=#net309}
N -2380 -460 -2380 -450 {
lab=#net310}
N -2120 -500 -2120 -490 {
lab=GND}
N -2120 -610 -2120 -600 {
lab=vdd_syn3}
N -2060 -420 -2050 -420 {
lab=GND}
N -2060 -390 -2060 -380 {
lab=p3}
N -2190 -560 -2180 -560 {
lab=vpres15}
N -2060 -560 -2050 -560 {
lab=w_px}
N -2110 -420 -2100 -420 {
lab=ctrl_pos}
N -2060 -540 -2060 -520 {
lab=#net311}
N -2060 -460 -2060 -450 {
lab=#net312}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn4}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p4}
N -1870 -560 -1860 -560 {
lab=vpres15}
N -1740 -560 -1730 -560 {
lab=b_px}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net313}
N -1740 -460 -1740 -450 {
lab=#net314}
N -1480 -500 -1480 -490 {
lab=GND}
N -1480 -610 -1480 -600 {
lab=vdd_syn5}
N -1420 -420 -1410 -420 {
lab=GND}
N -1420 -390 -1420 -380 {
lab=p5}
N -1550 -560 -1540 -560 {
lab=vpres15}
N -1420 -560 -1410 -560 {
lab=w_px}
N -1470 -420 -1460 -420 {
lab=ctrl_pos}
N -1420 -540 -1420 -520 {
lab=#net315}
N -1420 -460 -1420 -450 {
lab=#net316}
N -1160 -500 -1160 -490 {
lab=GND}
N -1160 -610 -1160 -600 {
lab=vdd_syn6}
N -1100 -420 -1090 -420 {
lab=GND}
N -1100 -390 -1100 -380 {
lab=p6}
N -1230 -560 -1220 -560 {
lab=vpres15}
N -1100 -560 -1090 -560 {
lab=w_px}
N -1150 -420 -1140 -420 {
lab=ctrl_pos}
N -1100 -540 -1100 -520 {
lab=#net317}
N -1100 -460 -1100 -450 {
lab=#net318}
N -840 -500 -840 -490 {
lab=GND}
N -840 -610 -840 -600 {
lab=vdd_syn7}
N -780 -420 -770 -420 {
lab=GND}
N -780 -390 -780 -380 {
lab=p7}
N -910 -560 -900 -560 {
lab=vpres15}
N -780 -560 -770 -560 {
lab=w_px}
N -830 -420 -820 -420 {
lab=ctrl_pos}
N -780 -540 -780 -520 {
lab=#net319}
N -780 -460 -780 -450 {
lab=#net320}
N -520 -500 -520 -490 {
lab=GND}
N -520 -610 -520 -600 {
lab=vdd_syn8}
N -460 -420 -450 -420 {
lab=GND}
N -460 -390 -460 -380 {
lab=p8}
N -590 -560 -580 -560 {
lab=vpres15}
N -460 -560 -450 -560 {
lab=w_px}
N -510 -420 -500 -420 {
lab=ctrl_pos}
N -460 -540 -460 -520 {
lab=#net321}
N -460 -460 -460 -450 {
lab=#net322}
N -200 -500 -200 -490 {
lab=GND}
N -200 -610 -200 -600 {
lab=vdd_syn9}
N -140 -420 -130 -420 {
lab=GND}
N -140 -390 -140 -380 {
lab=p9}
N -270 -560 -260 -560 {
lab=vpres15}
N -140 -560 -130 -560 {
lab=b_px}
N -190 -420 -180 -420 {
lab=ctrl_pos}
N -140 -540 -140 -520 {
lab=#net323}
N -140 -460 -140 -450 {
lab=#net324}
N 30 -4380 40 -4380 {
lab=N1}
N 30 -4400 40 -4400 {
lab=N2}
N 30 -4420 40 -4420 {
lab=N3}
N 30 -4440 40 -4440 {
lab=N4}
N 30 -4460 40 -4460 {
lab=N5}
N 30 -4480 40 -4480 {
lab=N6}
N 30 -4500 40 -4500 {
lab=N7}
N 30 -4520 40 -4520 {
lab=N8}
N 30 -4540 40 -4540 {
lab=N9}
N 120 -2760 120 -2740 {
lab=GND}
N 120 -2840 120 -2820 {
lab=vdd_syn1}
N 220 -2760 220 -2740 {
lab=GND}
N 220 -2840 220 -2820 {
lab=vdd_syn2}
N 320 -2760 320 -2740 {
lab=GND}
N 320 -2840 320 -2820 {
lab=vdd_syn3}
N 420 -2760 420 -2740 {
lab=GND}
N 420 -2840 420 -2820 {
lab=vdd_syn4}
N 520 -2760 520 -2740 {
lab=GND}
N 520 -2840 520 -2820 {
lab=vdd_syn5}
N 620 -2760 620 -2740 {
lab=GND}
N 620 -2840 620 -2820 {
lab=vdd_syn6}
N 720 -2760 720 -2740 {
lab=GND}
N 720 -2840 720 -2820 {
lab=vdd_syn7}
N 820 -2760 820 -2740 {
lab=GND}
N 820 -2840 820 -2820 {
lab=vdd_syn8}
N 920 -2760 920 -2740 {
lab=GND}
N 920 -2840 920 -2820 {
lab=vdd_syn9}
N 700 -2620 700 -2600 {
lab=GND}
N 700 -2700 700 -2680 {
lab=b_px}
N 620 -2620 620 -2600 {
lab=GND}
N 620 -2700 620 -2680 {
lab=w_px}
N -3020 -270 -3020 -260 {
lab=#net325}
N -3020 -340 -3020 -330 {
lab=p0}
N -3020 -20 -3020 -10 {
lab=N0}
N -3090 -160 -3090 -140 {
lab=GND}
N -2950 -160 -2950 -140 {
lab=vdd_pos}
N -3090 -260 -3090 -250 {
lab=inh}
N -3060 -260 -3060 -250 {
lab=vb_pos}
N -2980 -260 -2980 -250 {
lab=vlky_pos}
N 270 -2560 270 -2540 {
lab=vb_tr}
N 270 -2480 270 -2460 {
lab=GND}
N 100 -2420 100 -2400 {
lab=ctrl_tr}
N 100 -2340 100 -2320 {
lab=GND}
N 20 -4340 40 -4340 {
lab=ctrl_newpattern}
N 340 -2340 340 -2320 {
lab=GND}
N 340 -2420 340 -2400 {
lab=ctrl_newpattern}
N 420 -2480 420 -2460 {
lab=GND}
N 420 -2560 420 -2540 {
lab=vlky_pos}
N -3390 -7070 -3390 -7050 {
lab=vdd_tr}
N -3390 -6970 -3390 -6960 {
lab=GND}
N -3340 -7010 -3330 -7010 {
lab=vpos1}
N -3450 -7040 -3440 -7040 {
lab=ctrl_tr}
N -3450 -7010 -3440 -7010 {
lab=vpre1}
N -3450 -6980 -3440 -6980 {
lab=vb_tr}
N -3390 -6620 -3390 -6600 {
lab=vdd_tr}
N -3390 -6520 -3390 -6510 {
lab=GND}
N -3340 -6560 -3330 -6560 {
lab=vpos2}
N -3450 -6590 -3440 -6590 {
lab=ctrl_tr}
N -3450 -6560 -3440 -6560 {
lab=vpre2}
N -3450 -6530 -3440 -6530 {
lab=vb_tr}
N -3390 -6170 -3390 -6150 {
lab=vdd_tr}
N -3390 -6070 -3390 -6060 {
lab=GND}
N -3340 -6110 -3330 -6110 {
lab=vpos3}
N -3450 -6140 -3440 -6140 {
lab=ctrl_tr}
N -3450 -6110 -3440 -6110 {
lab=vpre3}
N -3450 -6080 -3440 -6080 {
lab=vb_tr}
N -3390 -5720 -3390 -5700 {
lab=vdd_tr}
N -3390 -5620 -3390 -5610 {
lab=GND}
N -3340 -5660 -3330 -5660 {
lab=vpos4}
N -3450 -5690 -3440 -5690 {
lab=ctrl_tr}
N -3450 -5660 -3440 -5660 {
lab=vpre4}
N -3450 -5630 -3440 -5630 {
lab=vb_tr}
N -3390 -5270 -3390 -5250 {
lab=vdd_tr}
N -3390 -5170 -3390 -5160 {
lab=GND}
N -3340 -5210 -3330 -5210 {
lab=vpos5}
N -3450 -5240 -3440 -5240 {
lab=ctrl_tr}
N -3450 -5210 -3440 -5210 {
lab=vpre5}
N -3450 -5180 -3440 -5180 {
lab=vb_tr}
N -3390 -4820 -3390 -4800 {
lab=vdd_tr}
N -3390 -4720 -3390 -4710 {
lab=GND}
N -3340 -4760 -3330 -4760 {
lab=vpos6}
N -3450 -4790 -3440 -4790 {
lab=ctrl_tr}
N -3450 -4760 -3440 -4760 {
lab=vpre6}
N -3450 -4730 -3440 -4730 {
lab=vb_tr}
N -3390 -4370 -3390 -4350 {
lab=vdd_tr}
N -3390 -4270 -3390 -4260 {
lab=GND}
N -3340 -4310 -3330 -4310 {
lab=vpos7}
N -3450 -4340 -3440 -4340 {
lab=ctrl_tr}
N -3450 -4310 -3440 -4310 {
lab=vpre7}
N -3450 -4280 -3440 -4280 {
lab=vb_tr}
N -3390 -3920 -3390 -3900 {
lab=vdd_tr}
N -3390 -3820 -3390 -3810 {
lab=GND}
N -3340 -3860 -3330 -3860 {
lab=vpos8}
N -3450 -3890 -3440 -3890 {
lab=ctrl_tr}
N -3450 -3860 -3440 -3860 {
lab=vpre8}
N -3450 -3830 -3440 -3830 {
lab=vb_tr}
N -3390 -3470 -3390 -3450 {
lab=vdd_tr}
N -3390 -3370 -3390 -3360 {
lab=GND}
N -3340 -3410 -3330 -3410 {
lab=vpos9}
N -3450 -3440 -3440 -3440 {
lab=ctrl_tr}
N -3450 -3410 -3440 -3410 {
lab=vpre9}
N -3450 -3380 -3440 -3380 {
lab=vb_tr}
N -3390 -3020 -3390 -3000 {
lab=vdd_tr}
N -3390 -2920 -3390 -2910 {
lab=GND}
N -3340 -2960 -3330 -2960 {
lab=vpos10}
N -3450 -2990 -3440 -2990 {
lab=ctrl_tr}
N -3450 -2960 -3440 -2960 {
lab=vpre10}
N -3450 -2930 -3440 -2930 {
lab=vb_tr}
N -3390 -2570 -3390 -2550 {
lab=vdd_tr}
N -3390 -2470 -3390 -2460 {
lab=GND}
N -3340 -2510 -3330 -2510 {
lab=vpos11}
N -3450 -2540 -3440 -2540 {
lab=ctrl_tr}
N -3450 -2510 -3440 -2510 {
lab=vpre11}
N -3450 -2480 -3440 -2480 {
lab=vb_tr}
N -3390 -2120 -3390 -2100 {
lab=vdd_tr}
N -3390 -2020 -3390 -2010 {
lab=GND}
N -3340 -2060 -3330 -2060 {
lab=vpos12}
N -3450 -2090 -3440 -2090 {
lab=ctrl_tr}
N -3450 -2060 -3440 -2060 {
lab=vpre12}
N -3450 -2030 -3440 -2030 {
lab=vb_tr}
N -3390 -1670 -3390 -1650 {
lab=vdd_tr}
N -3390 -1570 -3390 -1560 {
lab=GND}
N -3340 -1610 -3330 -1610 {
lab=vpos13}
N -3450 -1640 -3440 -1640 {
lab=ctrl_tr}
N -3450 -1610 -3440 -1610 {
lab=vpre13}
N -3450 -1580 -3440 -1580 {
lab=vb_tr}
N -3390 -1220 -3390 -1200 {
lab=vdd_tr}
N -3390 -1120 -3390 -1110 {
lab=GND}
N -3340 -1160 -3330 -1160 {
lab=vpos14}
N -3450 -1190 -3440 -1190 {
lab=ctrl_tr}
N -3450 -1160 -3440 -1160 {
lab=vpre14}
N -3450 -1130 -3440 -1130 {
lab=vb_tr}
N -3390 -770 -3390 -750 {
lab=vdd_tr}
N -3390 -670 -3390 -660 {
lab=GND}
N -3340 -710 -3330 -710 {
lab=vpos15}
N -3450 -740 -3440 -740 {
lab=ctrl_tr}
N -3450 -710 -3440 -710 {
lab=vpre15}
N -3450 -680 -3440 -680 {
lab=vb_tr}
N -4140 -6330 -4140 -6310 {
lab=GND}
N -4140 -6410 -4140 -6390 {
lab=#net326}
N -4140 -6780 -4140 -6760 {
lab=GND}
N -4140 -6860 -4140 -6840 {
lab=#net327}
N -4140 -5430 -4140 -5410 {
lab=GND}
N -4140 -5510 -4140 -5490 {
lab=#net328}
N -4140 -5880 -4140 -5860 {
lab=GND}
N -4140 -5960 -4140 -5940 {
lab=#net329}
N -4140 -4530 -4140 -4510 {
lab=GND}
N -4140 -4610 -4140 -4590 {
lab=#net330}
N -4140 -4980 -4140 -4960 {
lab=GND}
N -4140 -5060 -4140 -5040 {
lab=#net331}
N -4140 -3630 -4140 -3610 {
lab=GND}
N -4140 -3710 -4140 -3690 {
lab=#net332}
N -4140 -4080 -4140 -4060 {
lab=GND}
N -4140 -4160 -4140 -4140 {
lab=#net333}
N -4140 -3180 -4140 -3160 {
lab=GND}
N -4140 -3260 -4140 -3240 {
lab=#net334}
N -4140 -2730 -4140 -2710 {
lab=GND}
N -4140 -2810 -4140 -2790 {
lab=#net335}
N -4140 -1830 -4140 -1810 {
lab=GND}
N -4140 -1910 -4140 -1890 {
lab=#net336}
N -4140 -2280 -4140 -2260 {
lab=GND}
N -4140 -2360 -4140 -2340 {
lab=#net337}
N -4140 -930 -4140 -910 {
lab=GND}
N -4140 -1010 -4140 -990 {
lab=#net338}
N -4140 -1380 -4140 -1360 {
lab=GND}
N -4140 -1460 -4140 -1440 {
lab=#net339}
N -4140 -480 -4140 -460 {
lab=GND}
N -4140 -560 -4140 -540 {
lab=#net340}
C {devices/vsource.sym} 20 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} 20 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 100 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} 100 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 100 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -3760 -6320 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -3860 -6370 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -6460 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -6460 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} 110 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -10 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} 300 -4190 0 0 {name=SIM0
only_toplevel=true
value="
.option set_threads = 16
.option klu
*--Current Injection--*
.param L_in=0.15
.param W_in=1
*--Memristor Output--*
.param L_out=0.15
.param W_out=1.5
*--Memristor synapse--*
.param L_pre=0.45
.param W_pre=0.45
.param L_pos=0.15
.param W_pos=15
.param L_mem_in=0.15
.param W_mem_in=30
.param L_mem_out=0.4
.param W_mem_out=0.45
*--WTA circuit--*
.param Wp_or=1
.param Lp_or=0.15
.param Wn_or=1
.param Ln_or=0.15
.param Wp_or_inv=1
.param Lp_or_inv=0.15
.param Wn_or_inv=1
.param Ln_or_inv=0.15
*--Initial Values--*
.param i_val1=0
.param i_val2=0
.param i_val3=0
.param i_val4=4u
.param i_val5=4u
.param i_val6=4u
.param i_val7=2u
.param i_val8=0
.param i_val9=4u
.param i_val10=4u
.param i_val11=4u
.param i_val12=4u
.param i_val13=0
.param i_val14=0
.param i_val15=0
.control
	save all
	set num_threads = 8
	set wr_vecnames
	set wr_singlescale
	*--Classification 0--*
	tran 10n 150u 0
	write N0_Noisy_05.raw 
	wrdata N0_Noisy_05.txt v(N0) v(N1) v(N2) v(N3) v(N4) v(N5) v(N6) v(N7) v(N8) v(N9)
.endc
" }
C {devices/launcher.sym} 90 -1945 0 0 {name=h1
descr="weight update and pre-training"
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_InfStage_tb.raw tran"
}
C {devices/lab_pin.sym} -3940 -6410 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/gnd.sym} -3080 -6790 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -3150 -6860 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -3020 -6790 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -6720 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -6720 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -3020 -6680 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/vsource.sym} 20 -2230 0 0 {name=V13 value="PWL(0 1.8 4.9u 1.8 5u 0)"}
C {devices/gnd.sym} 20 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} 20 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} 200 -2230 0 0 {name=V14 value="PWL(0 0 9.9u 0 10u 1.8 39.9u 1.8 40u 0)"}
C {devices/gnd.sym} 200 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 200 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} 460 -2230 0 0 {name=V15 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 460 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 460 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/vsource.sym} 20 -2370 0 0 {name=V11 value="PWL(0 1.8 4.9u 1.8 5u 0)"}
C {devices/gnd.sym} 20 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 20 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 190 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} 190 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 190 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 190 -2650 0 0 {name=V3 value=1.8}
C {devices/gnd.sym} 190 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 190 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} 280 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 280 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 280 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_wu}
C {devices/vsource.sym} 360 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} 360 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 360 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tr}
C {devices/vsource.sym} 110 -2510 0 0 {name=V7 value=0.6}
C {devices/gnd.sym} 110 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 110 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} 340 -2510 0 0 {name=V8 value=0.6}
C {devices/gnd.sym} 340 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 340 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -3760 -6500 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} 20 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -4000 -6490 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -6770 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -3860 -6820 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -6910 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -6910 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -6860 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -3080 -6340 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -3150 -6410 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/ammeter.sym} -3020 -6340 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -6270 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -6270 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -3020 -6230 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3330 -6710 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3610 -6860 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/gnd.sym} -3390 -6660 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -3330 -6860 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3450 -6860 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -3450 -6890 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -6810 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -3760 -6950 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3390 -6770 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -6920 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -4000 -6940 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3070 -6270 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -3070 -6720 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} 170 -2370 0 0 {name=V16 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 170 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 170 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} 520 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} 520 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 520 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} 120 -4290 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 120 -4590 2 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} 310 -4440 2 0 {name=p91 sig_type=std_logic lab=inh}
C {devices/vsource.sym} 20 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} 20 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 20 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -6900 1 0 {name=p96 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -6450 1 0 {name=p97 sig_type=std_logic lab=vlky_pre}
C {devices/vsource.sym} 20 -2790 0 0 {name=V10 value=1.8
*"PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 20 -2740 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 20 -2840 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -3080 -5890 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -3020 -5890 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -5820 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -5820 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -3020 -5780 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -5820 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -5440 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -3150 -5510 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -3020 -5440 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -5370 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -5370 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -3020 -5330 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -5370 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -4990 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -3150 -5060 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -3020 -4990 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4920 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4920 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -3020 -4880 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4920 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -4540 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -3020 -4540 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4470 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4470 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -3020 -4430 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4470 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -4090 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -3020 -4090 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4020 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4020 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -3020 -3980 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4020 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3640 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -3020 -3640 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3570 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3570 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -3020 -3530 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3570 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3190 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -3150 -3260 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -3020 -3190 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3120 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3120 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -3020 -3080 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3120 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -5420 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -3860 -5470 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -5560 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -5560 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -5510 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/lab_pin.sym} -3760 -5600 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -5590 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -5870 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -3860 -5920 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -6010 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -6010 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -5960 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/lab_pin.sym} -3760 -6050 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -6040 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -6000 1 0 {name=p671 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -5550 1 0 {name=p672 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -4520 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -3860 -4570 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4660 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4660 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4610 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/lab_pin.sym} -3760 -4700 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -4690 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -4970 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -3860 -5020 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -5110 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -5110 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -5060 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/lab_pin.sym} -3760 -5150 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -5140 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -5100 1 0 {name=p683 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -4650 1 0 {name=p684 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -3620 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -3860 -3670 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3760 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3760 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3710 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/lab_pin.sym} -3760 -3800 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3790 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -4070 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -3860 -4120 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4210 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4210 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4160 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/lab_pin.sym} -3760 -4250 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -4240 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -4200 1 0 {name=p695 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -3750 1 0 {name=p696 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -3170 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -3860 -3220 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3310 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3310 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3260 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/lab_pin.sym} -3760 -3350 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3340 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -3300 1 0 {name=p702 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3610 -6410 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3610 -5960 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3150 -5960 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3610 -3260 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3150 -3710 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3610 -3710 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3150 -4160 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3610 -4160 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3150 -4610 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3610 -4610 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3610 -5060 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3610 -5510 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/launcher.sym} 90 -1975 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {devices/gnd.sym} -3080 -2740 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -3020 -2740 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2670 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2670 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -3020 -2630 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2670 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2290 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -3020 -2290 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2220 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2220 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -3020 -2180 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2220 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1840 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -3020 -1840 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1770 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1770 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -3020 -1730 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1770 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1390 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -3020 -1390 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1320 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1320 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -3020 -1280 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1320 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -940 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -3020 -940 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -870 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -870 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -3020 -830 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -870 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -3020 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -3020 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -2720 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -3860 -2770 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2860 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2860 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2810 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/lab_pin.sym} -3760 -2900 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2890 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -2850 1 0 {name=p328 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -1820 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -3860 -1870 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1960 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1960 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1910 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/lab_pin.sym} -3760 -2000 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1990 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -2270 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -3860 -2320 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2410 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2410 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2360 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/lab_pin.sym} -3760 -2450 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2440 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -2400 1 0 {name=p337 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -1950 1 0 {name=p338 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -920 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -3860 -970 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1060 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1060 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1010 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/lab_pin.sym} -3760 -1100 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1090 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -1370 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -3860 -1420 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1510 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1510 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1460 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/lab_pin.sym} -3760 -1550 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1540 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -1500 1 0 {name=p347 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3860 -1050 1 0 {name=p348 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -3760 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -3860 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/lab_pin.sym} -3760 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -600 1 0 {name=p353 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -3610 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3610 -1010 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3610 -1460 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3610 -2360 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3610 -2810 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3150 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -6680 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -6230 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -5780 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -5330 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4880 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4430 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3980 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3530 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3080 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2630 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2180 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1730 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1280 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -830 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -380 0 0 {name=x150}
C {devices/lab_pin.sym} -3150 -1010 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3150 -1460 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3150 -2810 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3150 -2360 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3610 -1910 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3150 -1910 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3080 -6910 0 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -6460 0 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -4660 0 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2860 0 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3450 -6740 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 250 -2370 0 0 {name=V20 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 250 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 250 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3390 -6210 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -3450 -6440 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -6360 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -3390 -6320 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -6470 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -6290 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -5760 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -3450 -5990 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -5910 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -3390 -5870 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -6020 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -5840 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -5310 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -3450 -5540 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -5460 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -3390 -5420 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -5570 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -5390 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -4860 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -3450 -5090 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -5010 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -3390 -4970 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -5120 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -4940 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -4410 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -3450 -4640 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4560 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -3390 -4520 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4670 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -4490 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3960 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -3450 -4190 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4110 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -3390 -4070 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4220 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -4040 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3510 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -3450 -3740 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3660 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -3390 -3620 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3770 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -3590 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3060 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -3450 -3290 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3210 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -3390 -3170 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3320 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -3140 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2610 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -3450 -2840 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2760 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -3390 -2720 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2870 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -2690 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2160 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -3450 -2390 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2310 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -3390 -2270 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2420 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -2240 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1710 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -3450 -1940 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1860 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -3390 -1820 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1970 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -1790 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1260 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -3450 -1490 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1410 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -3390 -1370 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1520 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -1340 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -810 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -3450 -1040 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -960 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -3390 -920 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1070 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -890 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -3450 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -3390 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -3330 -6410 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3330 -6260 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3450 -6410 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3450 -5960 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3330 -5960 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3330 -5810 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3450 -5510 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3330 -5510 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -5360 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -5060 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3330 -4910 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3450 -5060 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3450 -4610 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3330 -4610 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3330 -4460 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3450 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3330 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3330 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3450 -1010 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3330 -1010 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3330 -860 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3450 -1460 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3330 -1460 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3330 -1310 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3450 -1910 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3330 -1910 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -1760 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -2360 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3330 -2210 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3450 -2360 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3450 -2810 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3330 -2810 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3330 -2660 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3450 -3260 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3330 -3260 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3330 -3110 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3450 -3710 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3330 -3710 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3330 -3560 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3450 -4160 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3330 -4160 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3330 -4010 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3450 -830 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1280 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1730 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2180 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2630 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3080 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3530 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3980 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4430 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4880 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -5330 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -5780 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -6230 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -6680 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 440 -2650 0 0 {name=V22 value=1.8}
C {devices/gnd.sym} 440 -2600 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 440 -2700 2 0 {name=p285 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2740 -260 1 0 {name=p286 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2770 -140 0 0 {name=l90 lab=GND}
C {devices/ammeter.sym} -2700 -300 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -2700 -340 2 0 {name=p287 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2700 -10 2 0 {name=p288 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -2630 -140 3 0 {name=p289 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2660 -260 1 0 {name=p291 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2700 -160 1 0 {name=x1}
C {devices/lab_pin.sym} -2420 -260 1 0 {name=p292 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2450 -140 0 0 {name=l91 lab=GND}
C {devices/ammeter.sym} -2380 -300 0 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -2380 -340 2 0 {name=p294 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2380 -10 2 0 {name=p295 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} -2310 -140 3 0 {name=p296 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2340 -260 1 0 {name=p298 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2380 -160 1 0 {name=x2}
C {devices/lab_pin.sym} -2100 -260 1 0 {name=p299 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2130 -140 0 0 {name=l92 lab=GND}
C {devices/ammeter.sym} -2060 -300 0 0 {name=Vmeas3 savecurrent=true}
C {devices/lab_pin.sym} -2060 -340 2 0 {name=p300 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2060 -10 2 0 {name=p301 sig_type=std_logic lab=N3}
C {devices/lab_pin.sym} -1990 -140 3 0 {name=p302 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2020 -260 1 0 {name=p305 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2060 -160 1 0 {name=x3}
C {devices/lab_pin.sym} -1780 -260 1 0 {name=p306 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -140 0 0 {name=l93 lab=GND}
C {devices/ammeter.sym} -1740 -300 0 0 {name=Vmeas4 savecurrent=true}
C {devices/lab_pin.sym} -1740 -340 2 0 {name=p307 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1740 -10 2 0 {name=p308 sig_type=std_logic lab=N4}
C {devices/lab_pin.sym} -1670 -140 3 0 {name=p309 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1700 -260 1 0 {name=p311 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -160 1 0 {name=x4}
C {devices/lab_pin.sym} -1460 -260 1 0 {name=p314 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1490 -140 0 0 {name=l94 lab=GND}
C {devices/ammeter.sym} -1420 -300 0 0 {name=Vmeas5 savecurrent=true}
C {devices/lab_pin.sym} -1420 -340 2 0 {name=p316 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1420 -10 2 0 {name=p318 sig_type=std_logic lab=N5}
C {devices/lab_pin.sym} -1350 -140 3 0 {name=p320 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1380 -260 1 0 {name=p323 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1420 -160 1 0 {name=x5}
C {devices/lab_pin.sym} -1140 -260 1 0 {name=p355 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1170 -140 0 0 {name=l95 lab=GND}
C {devices/ammeter.sym} -1100 -300 0 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -1100 -340 2 0 {name=p356 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1100 -10 2 0 {name=p357 sig_type=std_logic lab=N6}
C {devices/lab_pin.sym} -1030 -140 3 0 {name=p358 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1060 -260 1 0 {name=p364 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1100 -160 1 0 {name=x6}
C {devices/lab_pin.sym} -820 -260 1 0 {name=p366 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -850 -140 0 0 {name=l96 lab=GND}
C {devices/ammeter.sym} -780 -300 0 0 {name=Vmeas7 savecurrent=true}
C {devices/lab_pin.sym} -780 -340 2 0 {name=p368 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -780 -10 2 0 {name=p370 sig_type=std_logic lab=N7}
C {devices/lab_pin.sym} -710 -140 3 0 {name=p371 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -740 -260 1 0 {name=p374 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -780 -160 1 0 {name=x7}
C {devices/lab_pin.sym} -500 -260 1 0 {name=p375 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -530 -140 0 0 {name=l97 lab=GND}
C {devices/ammeter.sym} -460 -300 0 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -460 -340 2 0 {name=p377 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -460 -10 2 0 {name=p379 sig_type=std_logic lab=N8}
C {devices/lab_pin.sym} -390 -140 3 0 {name=p381 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -420 -260 1 0 {name=p384 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -460 -160 1 0 {name=x8}
C {devices/lab_pin.sym} -180 -260 1 0 {name=p390 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -210 -140 0 0 {name=l98 lab=GND}
C {devices/ammeter.sym} -140 -300 0 0 {name=Vmeas9 savecurrent=true}
C {devices/lab_pin.sym} -140 -340 2 0 {name=p391 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -140 -10 2 0 {name=p393 sig_type=std_logic lab=N9}
C {devices/lab_pin.sym} -70 -140 3 0 {name=p395 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -100 -260 1 0 {name=p398 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -140 -160 1 0 {name=x9}
C {devices/gnd.sym} -2760 -6790 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2830 -6860 0 0 {name=p399 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2700 -6790 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -6720 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -6720 3 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2700 -6680 2 0 {name=p402 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -6720 0 0 {name=p403 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -6680 0 0 {name=x11}
C {devices/lab_pin.sym} -2760 -6910 0 0 {name=p404 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -3080 -6010 0 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -5560 0 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -5110 0 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -4210 0 0 {name=p406 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3760 0 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3310 0 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2410 0 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1960 0 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1510 0 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1060 0 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -610 0 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -2440 -6790 0 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -2510 -6860 0 0 {name=p436 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2380 -6790 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -6720 0 0 {name=M12
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -6720 3 0 {name=l129 lab=GND}
C {devices/lab_pin.sym} -2380 -6680 2 0 {name=p438 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -6720 0 0 {name=p439 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -6680 0 0 {name=x12}
C {devices/lab_pin.sym} -2440 -6910 0 0 {name=p440 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -6790 0 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -2190 -6860 0 0 {name=p441 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2060 -6790 0 0 {name=Vmeas13 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -6720 0 0 {name=M13
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -6720 3 0 {name=l131 lab=GND}
C {devices/lab_pin.sym} -2060 -6680 2 0 {name=p443 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -6720 0 0 {name=p444 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -6680 0 0 {name=x13}
C {devices/lab_pin.sym} -2120 -6910 0 0 {name=p445 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -6790 0 0 {name=l132 lab=GND}
C {devices/lab_pin.sym} -1870 -6860 0 0 {name=p446 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1740 -6790 0 0 {name=Vmeas14 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6720 0 0 {name=M14
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6720 3 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} -1740 -6680 2 0 {name=p448 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -6720 0 0 {name=p449 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6680 0 0 {name=x14}
C {devices/lab_pin.sym} -1800 -6910 0 0 {name=p450 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -6790 0 0 {name=l134 lab=GND}
C {devices/lab_pin.sym} -1550 -6860 0 0 {name=p451 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1420 -6790 0 0 {name=Vmeas15 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -6720 0 0 {name=M15
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -6720 3 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} -1420 -6680 2 0 {name=p453 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -6720 0 0 {name=p454 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -6680 0 0 {name=x15}
C {devices/lab_pin.sym} -1480 -6910 0 0 {name=p455 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -6790 0 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} -1230 -6860 0 0 {name=p456 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1100 -6790 0 0 {name=Vmeas16 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -6720 0 0 {name=M16
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -6720 3 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -1100 -6680 2 0 {name=p458 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -6720 0 0 {name=p459 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -6680 0 0 {name=x16}
C {devices/lab_pin.sym} -1160 -6910 0 0 {name=p460 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -6790 0 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -910 -6860 0 0 {name=p461 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -780 -6790 0 0 {name=Vmeas17 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -6720 0 0 {name=M17
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -6720 3 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} -780 -6680 2 0 {name=p464 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -6720 0 0 {name=p466 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -6680 0 0 {name=x17}
C {devices/lab_pin.sym} -840 -6910 0 0 {name=p467 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -6790 0 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -590 -6860 0 0 {name=p468 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -460 -6790 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -6720 0 0 {name=M18
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -6720 3 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -460 -6680 2 0 {name=p470 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -6720 0 0 {name=p471 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -6680 0 0 {name=x18}
C {devices/lab_pin.sym} -520 -6910 0 0 {name=p472 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -6790 0 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} -270 -6860 0 0 {name=p473 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -140 -6790 0 0 {name=Vmeas19 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -6720 0 0 {name=M19
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -6720 3 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} -140 -6680 2 0 {name=p475 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -6720 0 0 {name=p476 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -6680 0 0 {name=x19}
C {devices/lab_pin.sym} -200 -6910 0 0 {name=p477 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -6340 0 0 {name=l144 lab=GND}
C {devices/ammeter.sym} -2700 -6340 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -6270 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -6270 3 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} -2700 -6230 2 0 {name=p480 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -6270 0 0 {name=p481 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -6230 0 0 {name=x21}
C {devices/lab_pin.sym} -2760 -6460 0 0 {name=p482 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -6340 0 0 {name=l148 lab=GND}
C {devices/ammeter.sym} -2380 -6340 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -6270 0 0 {name=M22
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -6270 3 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} -2380 -6230 2 0 {name=p485 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -6270 0 0 {name=p486 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -6230 0 0 {name=x22}
C {devices/lab_pin.sym} -2440 -6460 0 0 {name=p487 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -6340 0 0 {name=l150 lab=GND}
C {devices/ammeter.sym} -2060 -6340 0 0 {name=Vmeas23 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -6270 0 0 {name=M23
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -6270 3 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} -2060 -6230 2 0 {name=p490 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -6270 0 0 {name=p491 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -6230 0 0 {name=x23}
C {devices/lab_pin.sym} -2120 -6460 0 0 {name=p492 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -6340 0 0 {name=l152 lab=GND}
C {devices/ammeter.sym} -1740 -6340 0 0 {name=Vmeas24 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6270 0 0 {name=M24
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6270 3 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} -1740 -6230 2 0 {name=p495 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -6270 0 0 {name=p496 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6230 0 0 {name=x24}
C {devices/lab_pin.sym} -1800 -6460 0 0 {name=p497 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -6340 0 0 {name=l154 lab=GND}
C {devices/ammeter.sym} -1420 -6340 0 0 {name=Vmeas25 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -6270 0 0 {name=M25
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -6270 3 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} -1420 -6230 2 0 {name=p500 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -6270 0 0 {name=p501 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -6230 0 0 {name=x25}
C {devices/lab_pin.sym} -1480 -6460 0 0 {name=p502 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -6340 0 0 {name=l156 lab=GND}
C {devices/ammeter.sym} -1100 -6340 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -6270 0 0 {name=M26
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -6270 3 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -1100 -6230 2 0 {name=p505 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -6270 0 0 {name=p506 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -6230 0 0 {name=x26}
C {devices/lab_pin.sym} -1160 -6460 0 0 {name=p507 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -6340 0 0 {name=l158 lab=GND}
C {devices/ammeter.sym} -780 -6340 0 0 {name=Vmeas27 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -6270 0 0 {name=M27
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -6270 3 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} -780 -6230 2 0 {name=p510 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -6270 0 0 {name=p511 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -6230 0 0 {name=x27}
C {devices/lab_pin.sym} -840 -6460 0 0 {name=p512 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -6340 0 0 {name=l160 lab=GND}
C {devices/ammeter.sym} -460 -6340 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -6270 0 0 {name=M28
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -6270 3 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -460 -6230 2 0 {name=p517 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -6270 0 0 {name=p518 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -6230 0 0 {name=x28}
C {devices/lab_pin.sym} -520 -6460 0 0 {name=p519 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -6340 0 0 {name=l162 lab=GND}
C {devices/ammeter.sym} -140 -6340 0 0 {name=Vmeas29 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -6270 0 0 {name=M29
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -6270 3 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} -140 -6230 2 0 {name=p522 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -6270 0 0 {name=p523 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -6230 0 0 {name=x29}
C {devices/lab_pin.sym} -200 -6460 0 0 {name=p524 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -5890 0 0 {name=l164 lab=GND}
C {devices/ammeter.sym} -2700 -5890 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -5820 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -5820 3 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} -2700 -5780 2 0 {name=p527 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -5820 0 0 {name=p528 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -5780 0 0 {name=x31}
C {devices/lab_pin.sym} -2760 -6010 0 0 {name=p529 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -5890 0 0 {name=l168 lab=GND}
C {devices/ammeter.sym} -2380 -5890 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -5820 0 0 {name=M32
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -5820 3 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} -2380 -5780 2 0 {name=p532 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -5820 0 0 {name=p533 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -5780 0 0 {name=x32}
C {devices/lab_pin.sym} -2440 -6010 0 0 {name=p534 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -5890 0 0 {name=l170 lab=GND}
C {devices/ammeter.sym} -2060 -5890 0 0 {name=Vmeas33 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -5820 0 0 {name=M33
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -5820 3 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} -2060 -5780 2 0 {name=p537 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -5820 0 0 {name=p538 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -5780 0 0 {name=x33}
C {devices/lab_pin.sym} -2120 -6010 0 0 {name=p539 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -5890 0 0 {name=l172 lab=GND}
C {devices/ammeter.sym} -1740 -5890 0 0 {name=Vmeas34 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5820 0 0 {name=M34
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5820 3 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} -1740 -5780 2 0 {name=p542 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -5820 0 0 {name=p543 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5780 0 0 {name=x34}
C {devices/lab_pin.sym} -1800 -6010 0 0 {name=p544 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -5890 0 0 {name=l174 lab=GND}
C {devices/ammeter.sym} -1420 -5890 0 0 {name=Vmeas35 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -5820 0 0 {name=M35
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -5820 3 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} -1420 -5780 2 0 {name=p547 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -5820 0 0 {name=p548 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -5780 0 0 {name=x35}
C {devices/lab_pin.sym} -1480 -6010 0 0 {name=p549 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -5890 0 0 {name=l176 lab=GND}
C {devices/ammeter.sym} -1100 -5890 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -5820 0 0 {name=M36
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -5820 3 0 {name=l177 lab=GND}
C {devices/lab_pin.sym} -1100 -5780 2 0 {name=p552 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -5820 0 0 {name=p553 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -5780 0 0 {name=x36}
C {devices/lab_pin.sym} -1160 -6010 0 0 {name=p554 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -5890 0 0 {name=l178 lab=GND}
C {devices/ammeter.sym} -780 -5890 0 0 {name=Vmeas37 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -5820 0 0 {name=M37
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -5820 3 0 {name=l179 lab=GND}
C {devices/lab_pin.sym} -780 -5780 2 0 {name=p557 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -5820 0 0 {name=p558 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -5780 0 0 {name=x37}
C {devices/lab_pin.sym} -840 -6010 0 0 {name=p559 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -5890 0 0 {name=l180 lab=GND}
C {devices/ammeter.sym} -460 -5890 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -5820 0 0 {name=M38
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -5820 3 0 {name=l181 lab=GND}
C {devices/lab_pin.sym} -460 -5780 2 0 {name=p562 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -5820 0 0 {name=p564 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -5780 0 0 {name=x38}
C {devices/lab_pin.sym} -520 -6010 0 0 {name=p566 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -5890 0 0 {name=l182 lab=GND}
C {devices/ammeter.sym} -140 -5890 0 0 {name=Vmeas39 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -5820 0 0 {name=M39
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -5820 3 0 {name=l183 lab=GND}
C {devices/lab_pin.sym} -140 -5780 2 0 {name=p569 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -5820 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -5780 0 0 {name=x39}
C {devices/lab_pin.sym} -200 -6010 0 0 {name=p571 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -5440 0 0 {name=l184 lab=GND}
C {devices/ammeter.sym} -2700 -5440 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -5370 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -5370 3 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -2700 -5330 2 0 {name=p574 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -5370 0 0 {name=p575 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -5330 0 0 {name=x41}
C {devices/lab_pin.sym} -2760 -5560 0 0 {name=p576 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -5440 0 0 {name=l188 lab=GND}
C {devices/ammeter.sym} -2380 -5440 0 0 {name=Vmeas42 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -5370 0 0 {name=M42
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -5370 3 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} -2380 -5330 2 0 {name=p579 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -5370 0 0 {name=p580 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -5330 0 0 {name=x42}
C {devices/lab_pin.sym} -2440 -5560 0 0 {name=p581 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -5440 0 0 {name=l190 lab=GND}
C {devices/ammeter.sym} -2060 -5440 0 0 {name=Vmeas43 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -5370 0 0 {name=M43
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -5370 3 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -2060 -5330 2 0 {name=p584 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -5370 0 0 {name=p585 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -5330 0 0 {name=x43}
C {devices/lab_pin.sym} -2120 -5560 0 0 {name=p586 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -5440 0 0 {name=l192 lab=GND}
C {devices/ammeter.sym} -1740 -5440 0 0 {name=Vmeas44 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5370 0 0 {name=M44
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5370 3 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -1740 -5330 2 0 {name=p589 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -5370 0 0 {name=p590 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5330 0 0 {name=x44}
C {devices/lab_pin.sym} -1800 -5560 0 0 {name=p591 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -5440 0 0 {name=l194 lab=GND}
C {devices/ammeter.sym} -1420 -5440 0 0 {name=Vmeas45 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -5370 0 0 {name=M45
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -5370 3 0 {name=l195 lab=GND}
C {devices/lab_pin.sym} -1420 -5330 2 0 {name=p594 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -5370 0 0 {name=p595 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -5330 0 0 {name=x45}
C {devices/lab_pin.sym} -1480 -5560 0 0 {name=p596 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -5440 0 0 {name=l196 lab=GND}
C {devices/ammeter.sym} -1100 -5440 0 0 {name=Vmeas46 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -5370 0 0 {name=M46
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -5370 3 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -1100 -5330 2 0 {name=p599 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -5370 0 0 {name=p600 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -5330 0 0 {name=x46}
C {devices/lab_pin.sym} -1160 -5560 0 0 {name=p601 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -5440 0 0 {name=l198 lab=GND}
C {devices/ammeter.sym} -780 -5440 0 0 {name=Vmeas47 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -5370 0 0 {name=M47
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -5370 3 0 {name=l199 lab=GND}
C {devices/lab_pin.sym} -780 -5330 2 0 {name=p604 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -5370 0 0 {name=p605 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -5330 0 0 {name=x47}
C {devices/lab_pin.sym} -840 -5560 0 0 {name=p606 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -5440 0 0 {name=l200 lab=GND}
C {devices/ammeter.sym} -460 -5440 0 0 {name=Vmeas48 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -5370 0 0 {name=M48
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -5370 3 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -460 -5330 2 0 {name=p609 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -5370 0 0 {name=p610 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -5330 0 0 {name=x48}
C {devices/lab_pin.sym} -520 -5560 0 0 {name=p614 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -5440 0 0 {name=l202 lab=GND}
C {devices/ammeter.sym} -140 -5440 0 0 {name=Vmeas49 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -5370 0 0 {name=M49
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -5370 3 0 {name=l203 lab=GND}
C {devices/lab_pin.sym} -140 -5330 2 0 {name=p618 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -5370 0 0 {name=p619 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -5330 0 0 {name=x49}
C {devices/lab_pin.sym} -200 -5560 0 0 {name=p620 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4990 0 0 {name=l204 lab=GND}
C {devices/lab_pin.sym} -2830 -5060 0 0 {name=p621 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2700 -4990 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4920 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4920 3 0 {name=l207 lab=GND}
C {devices/lab_pin.sym} -2700 -4880 2 0 {name=p623 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4920 0 0 {name=p624 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4880 0 0 {name=x51}
C {devices/lab_pin.sym} -2760 -5110 0 0 {name=p625 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4990 0 0 {name=l208 lab=GND}
C {devices/ammeter.sym} -2380 -4990 0 0 {name=Vmeas52 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4920 0 0 {name=M52
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4920 3 0 {name=l209 lab=GND}
C {devices/lab_pin.sym} -2380 -4880 2 0 {name=p628 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4920 0 0 {name=p629 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4880 0 0 {name=x52}
C {devices/lab_pin.sym} -2440 -5110 0 0 {name=p630 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4990 0 0 {name=l210 lab=GND}
C {devices/ammeter.sym} -2060 -4990 0 0 {name=Vmeas53 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4920 0 0 {name=M53
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4920 3 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} -2060 -4880 2 0 {name=p633 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4920 0 0 {name=p634 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4880 0 0 {name=x53}
C {devices/lab_pin.sym} -2120 -5110 0 0 {name=p635 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4990 0 0 {name=l212 lab=GND}
C {devices/ammeter.sym} -1740 -4990 0 0 {name=Vmeas54 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4920 0 0 {name=M54
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4920 3 0 {name=l213 lab=GND}
C {devices/lab_pin.sym} -1740 -4880 2 0 {name=p638 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4920 0 0 {name=p639 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4880 0 0 {name=x54}
C {devices/lab_pin.sym} -1800 -5110 0 0 {name=p640 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4990 0 0 {name=l214 lab=GND}
C {devices/ammeter.sym} -1420 -4990 0 0 {name=Vmeas55 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4920 0 0 {name=M55
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4920 3 0 {name=l215 lab=GND}
C {devices/lab_pin.sym} -1420 -4880 2 0 {name=p643 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4920 0 0 {name=p644 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4880 0 0 {name=x55}
C {devices/lab_pin.sym} -1480 -5110 0 0 {name=p645 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4990 0 0 {name=l216 lab=GND}
C {devices/ammeter.sym} -1100 -4990 0 0 {name=Vmeas56 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4920 0 0 {name=M56
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4920 3 0 {name=l217 lab=GND}
C {devices/lab_pin.sym} -1100 -4880 2 0 {name=p648 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4920 0 0 {name=p649 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4880 0 0 {name=x56}
C {devices/lab_pin.sym} -1160 -5110 0 0 {name=p650 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4990 0 0 {name=l218 lab=GND}
C {devices/ammeter.sym} -780 -4990 0 0 {name=Vmeas57 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4920 0 0 {name=M57
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4920 3 0 {name=l219 lab=GND}
C {devices/lab_pin.sym} -780 -4880 2 0 {name=p653 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4920 0 0 {name=p654 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4880 0 0 {name=x57}
C {devices/lab_pin.sym} -840 -5110 0 0 {name=p655 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4990 0 0 {name=l220 lab=GND}
C {devices/ammeter.sym} -460 -4990 0 0 {name=Vmeas58 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4920 0 0 {name=M58
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4920 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} -460 -4880 2 0 {name=p658 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4920 0 0 {name=p659 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4880 0 0 {name=x58}
C {devices/lab_pin.sym} -520 -5110 0 0 {name=p660 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4990 0 0 {name=l222 lab=GND}
C {devices/ammeter.sym} -140 -4990 0 0 {name=Vmeas59 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4920 0 0 {name=M59
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4920 3 0 {name=l223 lab=GND}
C {devices/lab_pin.sym} -140 -4880 2 0 {name=p675 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4920 0 0 {name=p680 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4880 0 0 {name=x59}
C {devices/lab_pin.sym} -200 -5110 0 0 {name=p687 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4540 0 0 {name=l224 lab=GND}
C {devices/lab_pin.sym} -2830 -4610 0 0 {name=p692 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2700 -4540 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4470 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4470 3 0 {name=l227 lab=GND}
C {devices/lab_pin.sym} -2700 -4430 2 0 {name=p703 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4470 0 0 {name=p704 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4430 0 0 {name=x61}
C {devices/lab_pin.sym} -2760 -4660 0 0 {name=p705 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4540 0 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -2510 -4610 0 0 {name=p706 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2380 -4540 0 0 {name=Vmeas62 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4470 0 0 {name=M62
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4470 3 0 {name=l229 lab=GND}
C {devices/lab_pin.sym} -2380 -4430 2 0 {name=p708 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4470 0 0 {name=p709 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4430 0 0 {name=x62}
C {devices/lab_pin.sym} -2440 -4660 0 0 {name=p710 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4540 0 0 {name=l230 lab=GND}
C {devices/lab_pin.sym} -2190 -4610 0 0 {name=p711 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2060 -4540 0 0 {name=Vmeas63 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4470 0 0 {name=M63
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4470 3 0 {name=l231 lab=GND}
C {devices/lab_pin.sym} -2060 -4430 2 0 {name=p713 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4470 0 0 {name=p714 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4430 0 0 {name=x63}
C {devices/lab_pin.sym} -2120 -4660 0 0 {name=p715 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4540 0 0 {name=l232 lab=GND}
C {devices/lab_pin.sym} -1870 -4610 0 0 {name=p716 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1740 -4540 0 0 {name=Vmeas64 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4470 0 0 {name=M64
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4470 3 0 {name=l233 lab=GND}
C {devices/lab_pin.sym} -1740 -4430 2 0 {name=p718 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4470 0 0 {name=p719 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4430 0 0 {name=x64}
C {devices/lab_pin.sym} -1800 -4660 0 0 {name=p720 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4540 0 0 {name=l234 lab=GND}
C {devices/lab_pin.sym} -1550 -4610 0 0 {name=p721 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1420 -4540 0 0 {name=Vmeas65 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4470 0 0 {name=M65
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4470 3 0 {name=l235 lab=GND}
C {devices/lab_pin.sym} -1420 -4430 2 0 {name=p723 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4470 0 0 {name=p724 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4430 0 0 {name=x65}
C {devices/lab_pin.sym} -1480 -4660 0 0 {name=p725 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4540 0 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} -1230 -4610 0 0 {name=p726 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1100 -4540 0 0 {name=Vmeas66 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4470 0 0 {name=M66
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4470 3 0 {name=l237 lab=GND}
C {devices/lab_pin.sym} -1100 -4430 2 0 {name=p728 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4470 0 0 {name=p729 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4430 0 0 {name=x66}
C {devices/lab_pin.sym} -1160 -4660 0 0 {name=p730 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4540 0 0 {name=l238 lab=GND}
C {devices/lab_pin.sym} -910 -4610 0 0 {name=p731 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -780 -4540 0 0 {name=Vmeas67 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4470 0 0 {name=M67
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4470 3 0 {name=l239 lab=GND}
C {devices/lab_pin.sym} -780 -4430 2 0 {name=p733 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4470 0 0 {name=p734 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4430 0 0 {name=x67}
C {devices/lab_pin.sym} -840 -4660 0 0 {name=p735 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4540 0 0 {name=l240 lab=GND}
C {devices/lab_pin.sym} -590 -4610 0 0 {name=p736 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -460 -4540 0 0 {name=Vmeas68 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4470 0 0 {name=M68
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4470 3 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} -460 -4430 2 0 {name=p738 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4470 0 0 {name=p739 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4430 0 0 {name=x68}
C {devices/lab_pin.sym} -520 -4660 0 0 {name=p740 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4540 0 0 {name=l242 lab=GND}
C {devices/lab_pin.sym} -270 -4610 0 0 {name=p741 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -140 -4540 0 0 {name=Vmeas69 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4470 0 0 {name=M69
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4470 3 0 {name=l243 lab=GND}
C {devices/lab_pin.sym} -140 -4430 2 0 {name=p743 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4470 0 0 {name=p744 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4430 0 0 {name=x69}
C {devices/lab_pin.sym} -200 -4660 0 0 {name=p745 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4090 0 0 {name=l244 lab=GND}
C {devices/lab_pin.sym} -2830 -4160 0 0 {name=p746 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2700 -4090 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4020 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4020 3 0 {name=l259 lab=GND}
C {devices/lab_pin.sym} -2700 -3980 2 0 {name=p748 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4020 0 0 {name=p749 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3980 0 0 {name=x71}
C {devices/lab_pin.sym} -2760 -4210 0 0 {name=p750 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4090 0 0 {name=l260 lab=GND}
C {devices/lab_pin.sym} -2510 -4160 0 0 {name=p751 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2380 -4090 0 0 {name=Vmeas72 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4020 0 0 {name=M72
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4020 3 0 {name=l261 lab=GND}
C {devices/lab_pin.sym} -2380 -3980 2 0 {name=p753 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4020 0 0 {name=p754 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3980 0 0 {name=x72}
C {devices/lab_pin.sym} -2440 -4210 0 0 {name=p755 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4090 0 0 {name=l262 lab=GND}
C {devices/lab_pin.sym} -2190 -4160 0 0 {name=p756 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2060 -4090 0 0 {name=Vmeas73 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4020 0 0 {name=M73
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4020 3 0 {name=l263 lab=GND}
C {devices/lab_pin.sym} -2060 -3980 2 0 {name=p758 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4020 0 0 {name=p759 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3980 0 0 {name=x73}
C {devices/lab_pin.sym} -2120 -4210 0 0 {name=p760 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4090 0 0 {name=l264 lab=GND}
C {devices/lab_pin.sym} -1870 -4160 0 0 {name=p761 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1740 -4090 0 0 {name=Vmeas74 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4020 0 0 {name=M74
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4020 3 0 {name=l265 lab=GND}
C {devices/lab_pin.sym} -1740 -3980 2 0 {name=p763 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4020 0 0 {name=p764 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3980 0 0 {name=x74}
C {devices/lab_pin.sym} -1800 -4210 0 0 {name=p765 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4090 0 0 {name=l266 lab=GND}
C {devices/lab_pin.sym} -1550 -4160 0 0 {name=p766 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1420 -4090 0 0 {name=Vmeas75 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4020 0 0 {name=M75
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4020 3 0 {name=l267 lab=GND}
C {devices/lab_pin.sym} -1420 -3980 2 0 {name=p768 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4020 0 0 {name=p769 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3980 0 0 {name=x75}
C {devices/lab_pin.sym} -1480 -4210 0 0 {name=p770 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4090 0 0 {name=l268 lab=GND}
C {devices/lab_pin.sym} -1230 -4160 0 0 {name=p771 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1100 -4090 0 0 {name=Vmeas76 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4020 0 0 {name=M76
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4020 3 0 {name=l269 lab=GND}
C {devices/lab_pin.sym} -1100 -3980 2 0 {name=p773 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4020 0 0 {name=p774 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3980 0 0 {name=x76}
C {devices/lab_pin.sym} -1160 -4210 0 0 {name=p775 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4090 0 0 {name=l270 lab=GND}
C {devices/lab_pin.sym} -910 -4160 0 0 {name=p776 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -780 -4090 0 0 {name=Vmeas77 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4020 0 0 {name=M77
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4020 3 0 {name=l271 lab=GND}
C {devices/lab_pin.sym} -780 -3980 2 0 {name=p778 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4020 0 0 {name=p779 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3980 0 0 {name=x77}
C {devices/lab_pin.sym} -840 -4210 0 0 {name=p780 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4090 0 0 {name=l272 lab=GND}
C {devices/lab_pin.sym} -590 -4160 0 0 {name=p781 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -460 -4090 0 0 {name=Vmeas78 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4020 0 0 {name=M78
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4020 3 0 {name=l273 lab=GND}
C {devices/lab_pin.sym} -460 -3980 2 0 {name=p783 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4020 0 0 {name=p784 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3980 0 0 {name=x78}
C {devices/lab_pin.sym} -520 -4210 0 0 {name=p785 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4090 0 0 {name=l274 lab=GND}
C {devices/lab_pin.sym} -270 -4160 0 0 {name=p786 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -140 -4090 0 0 {name=Vmeas79 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4020 0 0 {name=M79
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4020 3 0 {name=l275 lab=GND}
C {devices/lab_pin.sym} -140 -3980 2 0 {name=p788 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4020 0 0 {name=p789 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3980 0 0 {name=x79}
C {devices/lab_pin.sym} -200 -4210 0 0 {name=p790 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3640 0 0 {name=l276 lab=GND}
C {devices/lab_pin.sym} -2830 -3710 0 0 {name=p791 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2700 -3640 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3570 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3570 3 0 {name=l277 lab=GND}
C {devices/lab_pin.sym} -2700 -3530 2 0 {name=p793 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3570 0 0 {name=p794 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3530 0 0 {name=x81}
C {devices/lab_pin.sym} -2760 -3760 0 0 {name=p795 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3640 0 0 {name=l278 lab=GND}
C {devices/lab_pin.sym} -2510 -3710 0 0 {name=p796 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2380 -3640 0 0 {name=Vmeas82 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3570 0 0 {name=M82
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3570 3 0 {name=l279 lab=GND}
C {devices/lab_pin.sym} -2380 -3530 2 0 {name=p798 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3570 0 0 {name=p799 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3530 0 0 {name=x82}
C {devices/lab_pin.sym} -2440 -3760 0 0 {name=p800 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3640 0 0 {name=l280 lab=GND}
C {devices/lab_pin.sym} -2190 -3710 0 0 {name=p801 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2060 -3640 0 0 {name=Vmeas83 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3570 0 0 {name=M83
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3570 3 0 {name=l281 lab=GND}
C {devices/lab_pin.sym} -2060 -3530 2 0 {name=p803 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3570 0 0 {name=p804 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3530 0 0 {name=x83}
C {devices/lab_pin.sym} -2120 -3760 0 0 {name=p805 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3640 0 0 {name=l282 lab=GND}
C {devices/lab_pin.sym} -1870 -3710 0 0 {name=p806 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1740 -3640 0 0 {name=Vmeas84 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3570 0 0 {name=M84
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3570 3 0 {name=l283 lab=GND}
C {devices/lab_pin.sym} -1740 -3530 2 0 {name=p808 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3570 0 0 {name=p809 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3530 0 0 {name=x84}
C {devices/lab_pin.sym} -1800 -3760 0 0 {name=p810 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3640 0 0 {name=l284 lab=GND}
C {devices/lab_pin.sym} -1550 -3710 0 0 {name=p811 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1420 -3640 0 0 {name=Vmeas85 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3570 0 0 {name=M85
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3570 3 0 {name=l285 lab=GND}
C {devices/lab_pin.sym} -1420 -3530 2 0 {name=p813 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3570 0 0 {name=p814 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3530 0 0 {name=x85}
C {devices/lab_pin.sym} -1480 -3760 0 0 {name=p815 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3640 0 0 {name=l286 lab=GND}
C {devices/lab_pin.sym} -1230 -3710 0 0 {name=p816 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1100 -3640 0 0 {name=Vmeas86 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3570 0 0 {name=M86
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3570 3 0 {name=l287 lab=GND}
C {devices/lab_pin.sym} -1100 -3530 2 0 {name=p818 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3570 0 0 {name=p819 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3530 0 0 {name=x86}
C {devices/lab_pin.sym} -1160 -3760 0 0 {name=p820 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3640 0 0 {name=l288 lab=GND}
C {devices/lab_pin.sym} -910 -3710 0 0 {name=p821 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -780 -3640 0 0 {name=Vmeas87 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3570 0 0 {name=M87
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3570 3 0 {name=l289 lab=GND}
C {devices/lab_pin.sym} -780 -3530 2 0 {name=p823 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3570 0 0 {name=p824 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3530 0 0 {name=x87}
C {devices/lab_pin.sym} -840 -3760 0 0 {name=p825 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3640 0 0 {name=l290 lab=GND}
C {devices/lab_pin.sym} -590 -3710 0 0 {name=p826 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -460 -3640 0 0 {name=Vmeas88 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3570 0 0 {name=M88
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3570 3 0 {name=l291 lab=GND}
C {devices/lab_pin.sym} -460 -3530 2 0 {name=p828 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3570 0 0 {name=p829 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3530 0 0 {name=x88}
C {devices/lab_pin.sym} -520 -3760 0 0 {name=p830 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3640 0 0 {name=l292 lab=GND}
C {devices/lab_pin.sym} -270 -3710 0 0 {name=p831 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -140 -3640 0 0 {name=Vmeas89 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3570 0 0 {name=M89
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3570 3 0 {name=l293 lab=GND}
C {devices/lab_pin.sym} -140 -3530 2 0 {name=p833 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3570 0 0 {name=p834 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3530 0 0 {name=x89}
C {devices/lab_pin.sym} -200 -3760 0 0 {name=p835 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3190 0 0 {name=l294 lab=GND}
C {devices/lab_pin.sym} -2830 -3260 0 0 {name=p836 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2700 -3190 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3120 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3120 3 0 {name=l295 lab=GND}
C {devices/lab_pin.sym} -2700 -3080 2 0 {name=p838 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3120 0 0 {name=p839 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3080 0 0 {name=x91}
C {devices/lab_pin.sym} -2760 -3310 0 0 {name=p840 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3190 0 0 {name=l296 lab=GND}
C {devices/lab_pin.sym} -2510 -3260 0 0 {name=p841 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2380 -3190 0 0 {name=Vmeas92 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3120 0 0 {name=M92
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3120 3 0 {name=l297 lab=GND}
C {devices/lab_pin.sym} -2380 -3080 2 0 {name=p843 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3120 0 0 {name=p844 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3080 0 0 {name=x92}
C {devices/lab_pin.sym} -2440 -3310 0 0 {name=p845 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3190 0 0 {name=l298 lab=GND}
C {devices/lab_pin.sym} -2190 -3260 0 0 {name=p846 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2060 -3190 0 0 {name=Vmeas93 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3120 0 0 {name=M93
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3120 3 0 {name=l299 lab=GND}
C {devices/lab_pin.sym} -2060 -3080 2 0 {name=p848 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3120 0 0 {name=p849 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3080 0 0 {name=x93}
C {devices/lab_pin.sym} -2120 -3310 0 0 {name=p850 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3190 0 0 {name=l300 lab=GND}
C {devices/lab_pin.sym} -1870 -3260 0 0 {name=p851 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1740 -3190 0 0 {name=Vmeas94 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3120 0 0 {name=M94
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3120 3 0 {name=l301 lab=GND}
C {devices/lab_pin.sym} -1740 -3080 2 0 {name=p853 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3120 0 0 {name=p854 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3080 0 0 {name=x94}
C {devices/lab_pin.sym} -1800 -3310 0 0 {name=p855 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3190 0 0 {name=l302 lab=GND}
C {devices/lab_pin.sym} -1550 -3260 0 0 {name=p856 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1420 -3190 0 0 {name=Vmeas95 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3120 0 0 {name=M95
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3120 3 0 {name=l303 lab=GND}
C {devices/lab_pin.sym} -1420 -3080 2 0 {name=p858 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3120 0 0 {name=p859 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3080 0 0 {name=x95}
C {devices/lab_pin.sym} -1480 -3310 0 0 {name=p860 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3190 0 0 {name=l304 lab=GND}
C {devices/lab_pin.sym} -1230 -3260 0 0 {name=p861 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1100 -3190 0 0 {name=Vmeas96 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3120 0 0 {name=M96
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3120 3 0 {name=l305 lab=GND}
C {devices/lab_pin.sym} -1100 -3080 2 0 {name=p863 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3120 0 0 {name=p864 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3080 0 0 {name=x96}
C {devices/lab_pin.sym} -1160 -3310 0 0 {name=p865 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3190 0 0 {name=l306 lab=GND}
C {devices/lab_pin.sym} -910 -3260 0 0 {name=p866 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -780 -3190 0 0 {name=Vmeas97 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3120 0 0 {name=M97
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3120 3 0 {name=l307 lab=GND}
C {devices/lab_pin.sym} -780 -3080 2 0 {name=p868 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3120 0 0 {name=p869 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3080 0 0 {name=x97}
C {devices/lab_pin.sym} -840 -3310 0 0 {name=p870 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3190 0 0 {name=l308 lab=GND}
C {devices/lab_pin.sym} -590 -3260 0 0 {name=p871 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -460 -3190 0 0 {name=Vmeas98 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3120 0 0 {name=M98
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3120 3 0 {name=l309 lab=GND}
C {devices/lab_pin.sym} -460 -3080 2 0 {name=p873 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3120 0 0 {name=p874 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3080 0 0 {name=x98}
C {devices/lab_pin.sym} -520 -3310 0 0 {name=p875 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3190 0 0 {name=l310 lab=GND}
C {devices/lab_pin.sym} -270 -3260 0 0 {name=p876 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -140 -3190 0 0 {name=Vmeas99 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3120 0 0 {name=M99
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3120 3 0 {name=l311 lab=GND}
C {devices/lab_pin.sym} -140 -3080 2 0 {name=p878 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3120 0 0 {name=p879 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3080 0 0 {name=x99}
C {devices/lab_pin.sym} -200 -3310 0 0 {name=p880 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2740 0 0 {name=l312 lab=GND}
C {devices/lab_pin.sym} -2830 -2810 0 0 {name=p881 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2700 -2740 0 0 {name=Vmeas101 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2670 0 0 {name=M101
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2670 3 0 {name=l313 lab=GND}
C {devices/lab_pin.sym} -2700 -2630 2 0 {name=p883 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2670 0 0 {name=p884 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2630 0 0 {name=x101}
C {devices/lab_pin.sym} -2760 -2860 0 0 {name=p885 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2740 0 0 {name=l314 lab=GND}
C {devices/lab_pin.sym} -2510 -2810 0 0 {name=p886 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2380 -2740 0 0 {name=Vmeas102 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2670 0 0 {name=M102
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2670 3 0 {name=l315 lab=GND}
C {devices/lab_pin.sym} -2380 -2630 2 0 {name=p888 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2670 0 0 {name=p889 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2630 0 0 {name=x102}
C {devices/lab_pin.sym} -2440 -2860 0 0 {name=p890 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2740 0 0 {name=l316 lab=GND}
C {devices/lab_pin.sym} -2190 -2810 0 0 {name=p891 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2060 -2740 0 0 {name=Vmeas103 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2670 0 0 {name=M103
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2670 3 0 {name=l317 lab=GND}
C {devices/lab_pin.sym} -2060 -2630 2 0 {name=p893 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2670 0 0 {name=p894 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2630 0 0 {name=x103}
C {devices/lab_pin.sym} -2120 -2860 0 0 {name=p895 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2740 0 0 {name=l318 lab=GND}
C {devices/lab_pin.sym} -1870 -2810 0 0 {name=p896 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1740 -2740 0 0 {name=Vmeas104 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2670 0 0 {name=M104
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2670 3 0 {name=l319 lab=GND}
C {devices/lab_pin.sym} -1740 -2630 2 0 {name=p898 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2670 0 0 {name=p899 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2630 0 0 {name=x104}
C {devices/lab_pin.sym} -1800 -2860 0 0 {name=p900 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2740 0 0 {name=l320 lab=GND}
C {devices/lab_pin.sym} -1550 -2810 0 0 {name=p901 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1420 -2740 0 0 {name=Vmeas105 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2670 0 0 {name=M105
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2670 3 0 {name=l321 lab=GND}
C {devices/lab_pin.sym} -1420 -2630 2 0 {name=p903 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2670 0 0 {name=p904 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2630 0 0 {name=x105}
C {devices/lab_pin.sym} -1480 -2860 0 0 {name=p905 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2740 0 0 {name=l322 lab=GND}
C {devices/lab_pin.sym} -1230 -2810 0 0 {name=p906 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1100 -2740 0 0 {name=Vmeas106 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2670 0 0 {name=M106
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2670 3 0 {name=l323 lab=GND}
C {devices/lab_pin.sym} -1100 -2630 2 0 {name=p908 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2670 0 0 {name=p909 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2630 0 0 {name=x106}
C {devices/lab_pin.sym} -1160 -2860 0 0 {name=p910 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2740 0 0 {name=l324 lab=GND}
C {devices/lab_pin.sym} -910 -2810 0 0 {name=p911 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -780 -2740 0 0 {name=Vmeas107 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2670 0 0 {name=M107
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2670 3 0 {name=l325 lab=GND}
C {devices/lab_pin.sym} -780 -2630 2 0 {name=p913 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2670 0 0 {name=p914 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2630 0 0 {name=x107}
C {devices/lab_pin.sym} -840 -2860 0 0 {name=p915 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2740 0 0 {name=l326 lab=GND}
C {devices/lab_pin.sym} -590 -2810 0 0 {name=p916 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -460 -2740 0 0 {name=Vmeas108 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2670 0 0 {name=M108
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2670 3 0 {name=l327 lab=GND}
C {devices/lab_pin.sym} -460 -2630 2 0 {name=p918 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2670 0 0 {name=p919 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2630 0 0 {name=x108}
C {devices/lab_pin.sym} -520 -2860 0 0 {name=p920 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2740 0 0 {name=l328 lab=GND}
C {devices/lab_pin.sym} -270 -2810 0 0 {name=p921 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -140 -2740 0 0 {name=Vmeas109 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2670 0 0 {name=M109
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2670 3 0 {name=l329 lab=GND}
C {devices/lab_pin.sym} -140 -2630 2 0 {name=p923 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2670 0 0 {name=p924 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2630 0 0 {name=x109}
C {devices/lab_pin.sym} -200 -2860 0 0 {name=p925 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2290 0 0 {name=l330 lab=GND}
C {devices/lab_pin.sym} -2830 -2360 0 0 {name=p926 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2700 -2290 0 0 {name=Vmeas111 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2220 0 0 {name=M111
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2220 3 0 {name=l331 lab=GND}
C {devices/lab_pin.sym} -2700 -2180 2 0 {name=p928 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2220 0 0 {name=p929 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2180 0 0 {name=x111}
C {devices/lab_pin.sym} -2760 -2410 0 0 {name=p930 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2290 0 0 {name=l332 lab=GND}
C {devices/lab_pin.sym} -2510 -2360 0 0 {name=p931 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2380 -2290 0 0 {name=Vmeas112 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2220 0 0 {name=M112
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2220 3 0 {name=l333 lab=GND}
C {devices/lab_pin.sym} -2380 -2180 2 0 {name=p933 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2220 0 0 {name=p934 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2180 0 0 {name=x112}
C {devices/lab_pin.sym} -2440 -2410 0 0 {name=p935 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2290 0 0 {name=l334 lab=GND}
C {devices/lab_pin.sym} -2190 -2360 0 0 {name=p936 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2060 -2290 0 0 {name=Vmeas113 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2220 0 0 {name=M113
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2220 3 0 {name=l335 lab=GND}
C {devices/lab_pin.sym} -2060 -2180 2 0 {name=p938 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2220 0 0 {name=p939 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2180 0 0 {name=x113}
C {devices/lab_pin.sym} -2120 -2410 0 0 {name=p940 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2290 0 0 {name=l336 lab=GND}
C {devices/lab_pin.sym} -1870 -2360 0 0 {name=p941 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1740 -2290 0 0 {name=Vmeas114 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2220 0 0 {name=M114
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2220 3 0 {name=l337 lab=GND}
C {devices/lab_pin.sym} -1740 -2180 2 0 {name=p943 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2220 0 0 {name=p944 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2180 0 0 {name=x114}
C {devices/lab_pin.sym} -1800 -2410 0 0 {name=p945 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2290 0 0 {name=l338 lab=GND}
C {devices/lab_pin.sym} -1550 -2360 0 0 {name=p946 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1420 -2290 0 0 {name=Vmeas115 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2220 0 0 {name=M115
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2220 3 0 {name=l339 lab=GND}
C {devices/lab_pin.sym} -1420 -2180 2 0 {name=p948 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2220 0 0 {name=p949 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2180 0 0 {name=x115}
C {devices/lab_pin.sym} -1480 -2410 0 0 {name=p950 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2290 0 0 {name=l340 lab=GND}
C {devices/lab_pin.sym} -1230 -2360 0 0 {name=p951 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1100 -2290 0 0 {name=Vmeas116 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2220 0 0 {name=M116
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2220 3 0 {name=l341 lab=GND}
C {devices/lab_pin.sym} -1100 -2180 2 0 {name=p953 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2220 0 0 {name=p954 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2180 0 0 {name=x116}
C {devices/lab_pin.sym} -1160 -2410 0 0 {name=p955 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2290 0 0 {name=l342 lab=GND}
C {devices/lab_pin.sym} -910 -2360 0 0 {name=p956 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -780 -2290 0 0 {name=Vmeas117 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2220 0 0 {name=M117
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2220 3 0 {name=l343 lab=GND}
C {devices/lab_pin.sym} -780 -2180 2 0 {name=p958 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2220 0 0 {name=p959 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2180 0 0 {name=x117}
C {devices/lab_pin.sym} -840 -2410 0 0 {name=p960 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2290 0 0 {name=l344 lab=GND}
C {devices/lab_pin.sym} -590 -2360 0 0 {name=p961 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -460 -2290 0 0 {name=Vmeas118 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2220 0 0 {name=M118
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2220 3 0 {name=l345 lab=GND}
C {devices/lab_pin.sym} -460 -2180 2 0 {name=p963 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2220 0 0 {name=p964 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2180 0 0 {name=x118}
C {devices/lab_pin.sym} -520 -2410 0 0 {name=p965 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2290 0 0 {name=l346 lab=GND}
C {devices/lab_pin.sym} -270 -2360 0 0 {name=p966 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -140 -2290 0 0 {name=Vmeas119 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2220 0 0 {name=M119
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2220 3 0 {name=l347 lab=GND}
C {devices/lab_pin.sym} -140 -2180 2 0 {name=p968 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2220 0 0 {name=p969 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2180 0 0 {name=x119}
C {devices/lab_pin.sym} -200 -2410 0 0 {name=p970 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1840 0 0 {name=l348 lab=GND}
C {devices/lab_pin.sym} -2830 -1910 0 0 {name=p971 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2700 -1840 0 0 {name=Vmeas121 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1770 0 0 {name=M121
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1770 3 0 {name=l349 lab=GND}
C {devices/lab_pin.sym} -2700 -1730 2 0 {name=p973 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1770 0 0 {name=p974 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1730 0 0 {name=x121}
C {devices/lab_pin.sym} -2760 -1960 0 0 {name=p975 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1840 0 0 {name=l350 lab=GND}
C {devices/lab_pin.sym} -2510 -1910 0 0 {name=p976 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2380 -1840 0 0 {name=Vmeas122 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1770 0 0 {name=M122
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1770 3 0 {name=l351 lab=GND}
C {devices/lab_pin.sym} -2380 -1730 2 0 {name=p978 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1770 0 0 {name=p979 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1730 0 0 {name=x122}
C {devices/lab_pin.sym} -2440 -1960 0 0 {name=p980 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1840 0 0 {name=l352 lab=GND}
C {devices/lab_pin.sym} -2190 -1910 0 0 {name=p981 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2060 -1840 0 0 {name=Vmeas123 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1770 0 0 {name=M123
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1770 3 0 {name=l353 lab=GND}
C {devices/lab_pin.sym} -2060 -1730 2 0 {name=p983 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1770 0 0 {name=p984 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1730 0 0 {name=x123}
C {devices/lab_pin.sym} -2120 -1960 0 0 {name=p985 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1840 0 0 {name=l354 lab=GND}
C {devices/lab_pin.sym} -1870 -1910 0 0 {name=p986 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1740 -1840 0 0 {name=Vmeas124 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1770 0 0 {name=M124
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1770 3 0 {name=l355 lab=GND}
C {devices/lab_pin.sym} -1740 -1730 2 0 {name=p988 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1770 0 0 {name=p989 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1730 0 0 {name=x124}
C {devices/lab_pin.sym} -1800 -1960 0 0 {name=p990 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1840 0 0 {name=l356 lab=GND}
C {devices/lab_pin.sym} -1550 -1910 0 0 {name=p991 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1420 -1840 0 0 {name=Vmeas125 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1770 0 0 {name=M125
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1770 3 0 {name=l357 lab=GND}
C {devices/lab_pin.sym} -1420 -1730 2 0 {name=p993 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1770 0 0 {name=p994 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1730 0 0 {name=x125}
C {devices/lab_pin.sym} -1480 -1960 0 0 {name=p995 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1840 0 0 {name=l358 lab=GND}
C {devices/lab_pin.sym} -1230 -1910 0 0 {name=p996 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1100 -1840 0 0 {name=Vmeas126 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1770 0 0 {name=M126
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1770 3 0 {name=l359 lab=GND}
C {devices/lab_pin.sym} -1100 -1730 2 0 {name=p998 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1770 0 0 {name=p999 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1730 0 0 {name=x126}
C {devices/lab_pin.sym} -1160 -1960 0 0 {name=p1000 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1840 0 0 {name=l360 lab=GND}
C {devices/lab_pin.sym} -910 -1910 0 0 {name=p1001 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -780 -1840 0 0 {name=Vmeas127 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1770 0 0 {name=M127
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1770 3 0 {name=l361 lab=GND}
C {devices/lab_pin.sym} -780 -1730 2 0 {name=p1003 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1770 0 0 {name=p1004 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1730 0 0 {name=x127}
C {devices/lab_pin.sym} -840 -1960 0 0 {name=p1005 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1840 0 0 {name=l362 lab=GND}
C {devices/lab_pin.sym} -590 -1910 0 0 {name=p1006 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -460 -1840 0 0 {name=Vmeas128 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1770 0 0 {name=M128
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1770 3 0 {name=l363 lab=GND}
C {devices/lab_pin.sym} -460 -1730 2 0 {name=p1008 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1770 0 0 {name=p1009 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1730 0 0 {name=x128}
C {devices/lab_pin.sym} -520 -1960 0 0 {name=p1010 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1840 0 0 {name=l364 lab=GND}
C {devices/lab_pin.sym} -270 -1910 0 0 {name=p1011 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -140 -1840 0 0 {name=Vmeas129 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1770 0 0 {name=M129
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1770 3 0 {name=l365 lab=GND}
C {devices/lab_pin.sym} -140 -1730 2 0 {name=p1013 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1770 0 0 {name=p1014 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1730 0 0 {name=x129}
C {devices/lab_pin.sym} -200 -1960 0 0 {name=p1015 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1390 0 0 {name=l366 lab=GND}
C {devices/lab_pin.sym} -2830 -1460 0 0 {name=p1016 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2700 -1390 0 0 {name=Vmeas131 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1320 0 0 {name=M131
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1320 3 0 {name=l367 lab=GND}
C {devices/lab_pin.sym} -2700 -1280 2 0 {name=p1018 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1320 0 0 {name=p1019 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1280 0 0 {name=x131}
C {devices/lab_pin.sym} -2760 -1510 0 0 {name=p1020 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1390 0 0 {name=l368 lab=GND}
C {devices/lab_pin.sym} -2510 -1460 0 0 {name=p1021 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2380 -1390 0 0 {name=Vmeas132 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1320 0 0 {name=M132
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1320 3 0 {name=l369 lab=GND}
C {devices/lab_pin.sym} -2380 -1280 2 0 {name=p1023 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1320 0 0 {name=p1024 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1280 0 0 {name=x132}
C {devices/lab_pin.sym} -2440 -1510 0 0 {name=p1025 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1390 0 0 {name=l370 lab=GND}
C {devices/lab_pin.sym} -2190 -1460 0 0 {name=p1026 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2060 -1390 0 0 {name=Vmeas133 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1320 0 0 {name=M133
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1320 3 0 {name=l371 lab=GND}
C {devices/lab_pin.sym} -2060 -1280 2 0 {name=p1028 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1320 0 0 {name=p1029 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1280 0 0 {name=x133}
C {devices/lab_pin.sym} -2120 -1510 0 0 {name=p1030 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1390 0 0 {name=l372 lab=GND}
C {devices/lab_pin.sym} -1870 -1460 0 0 {name=p1031 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1740 -1390 0 0 {name=Vmeas134 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1320 0 0 {name=M134
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1320 3 0 {name=l373 lab=GND}
C {devices/lab_pin.sym} -1740 -1280 2 0 {name=p1033 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1320 0 0 {name=p1034 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1280 0 0 {name=x134}
C {devices/lab_pin.sym} -1800 -1510 0 0 {name=p1035 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1390 0 0 {name=l374 lab=GND}
C {devices/lab_pin.sym} -1550 -1460 0 0 {name=p1036 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1420 -1390 0 0 {name=Vmeas135 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1320 0 0 {name=M135
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1320 3 0 {name=l375 lab=GND}
C {devices/lab_pin.sym} -1420 -1280 2 0 {name=p1038 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1320 0 0 {name=p1039 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1280 0 0 {name=x135}
C {devices/lab_pin.sym} -1480 -1510 0 0 {name=p1040 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1390 0 0 {name=l376 lab=GND}
C {devices/lab_pin.sym} -1230 -1460 0 0 {name=p1041 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1100 -1390 0 0 {name=Vmeas136 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1320 0 0 {name=M136
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1320 3 0 {name=l377 lab=GND}
C {devices/lab_pin.sym} -1100 -1280 2 0 {name=p1043 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1320 0 0 {name=p1044 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1280 0 0 {name=x136}
C {devices/lab_pin.sym} -1160 -1510 0 0 {name=p1045 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1390 0 0 {name=l378 lab=GND}
C {devices/lab_pin.sym} -910 -1460 0 0 {name=p1046 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -780 -1390 0 0 {name=Vmeas137 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1320 0 0 {name=M137
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1320 3 0 {name=l379 lab=GND}
C {devices/lab_pin.sym} -780 -1280 2 0 {name=p1048 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1320 0 0 {name=p1049 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1280 0 0 {name=x137}
C {devices/lab_pin.sym} -840 -1510 0 0 {name=p1050 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1390 0 0 {name=l380 lab=GND}
C {devices/lab_pin.sym} -590 -1460 0 0 {name=p1051 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -460 -1390 0 0 {name=Vmeas138 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1320 0 0 {name=M138
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1320 3 0 {name=l381 lab=GND}
C {devices/lab_pin.sym} -460 -1280 2 0 {name=p1053 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1320 0 0 {name=p1054 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1280 0 0 {name=x138}
C {devices/lab_pin.sym} -520 -1510 0 0 {name=p1055 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1390 0 0 {name=l382 lab=GND}
C {devices/lab_pin.sym} -270 -1460 0 0 {name=p1056 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -140 -1390 0 0 {name=Vmeas139 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1320 0 0 {name=M139
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1320 3 0 {name=l383 lab=GND}
C {devices/lab_pin.sym} -140 -1280 2 0 {name=p1058 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1320 0 0 {name=p1059 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1280 0 0 {name=x139}
C {devices/lab_pin.sym} -200 -1510 0 0 {name=p1060 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -940 0 0 {name=l384 lab=GND}
C {devices/lab_pin.sym} -2830 -1010 0 0 {name=p1061 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2700 -940 0 0 {name=Vmeas141 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -870 0 0 {name=M141
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -870 3 0 {name=l385 lab=GND}
C {devices/lab_pin.sym} -2700 -830 2 0 {name=p1063 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -870 0 0 {name=p1064 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -830 0 0 {name=x141}
C {devices/lab_pin.sym} -2760 -1060 0 0 {name=p1065 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -940 0 0 {name=l386 lab=GND}
C {devices/lab_pin.sym} -2510 -1010 0 0 {name=p1066 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2380 -940 0 0 {name=Vmeas142 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -870 0 0 {name=M142
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -870 3 0 {name=l387 lab=GND}
C {devices/lab_pin.sym} -2380 -830 2 0 {name=p1068 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -870 0 0 {name=p1069 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -830 0 0 {name=x142}
C {devices/lab_pin.sym} -2440 -1060 0 0 {name=p1070 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -940 0 0 {name=l388 lab=GND}
C {devices/lab_pin.sym} -2190 -1010 0 0 {name=p1071 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2060 -940 0 0 {name=Vmeas143 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -870 0 0 {name=M143
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -870 3 0 {name=l389 lab=GND}
C {devices/lab_pin.sym} -2060 -830 2 0 {name=p1073 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -870 0 0 {name=p1074 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -830 0 0 {name=x143}
C {devices/lab_pin.sym} -2120 -1060 0 0 {name=p1075 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -940 0 0 {name=l390 lab=GND}
C {devices/lab_pin.sym} -1870 -1010 0 0 {name=p1076 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1740 -940 0 0 {name=Vmeas144 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -870 0 0 {name=M144
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -870 3 0 {name=l391 lab=GND}
C {devices/lab_pin.sym} -1740 -830 2 0 {name=p1078 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -870 0 0 {name=p1079 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -830 0 0 {name=x144}
C {devices/lab_pin.sym} -1800 -1060 0 0 {name=p1080 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -940 0 0 {name=l392 lab=GND}
C {devices/lab_pin.sym} -1550 -1010 0 0 {name=p1081 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1420 -940 0 0 {name=Vmeas145 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -870 0 0 {name=M145
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -870 3 0 {name=l393 lab=GND}
C {devices/lab_pin.sym} -1420 -830 2 0 {name=p1083 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -870 0 0 {name=p1084 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -830 0 0 {name=x145}
C {devices/lab_pin.sym} -1480 -1060 0 0 {name=p1085 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -940 0 0 {name=l394 lab=GND}
C {devices/lab_pin.sym} -1230 -1010 0 0 {name=p1086 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1100 -940 0 0 {name=Vmeas146 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -870 0 0 {name=M146
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -870 3 0 {name=l395 lab=GND}
C {devices/lab_pin.sym} -1100 -830 2 0 {name=p1088 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -870 0 0 {name=p1089 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -830 0 0 {name=x146}
C {devices/lab_pin.sym} -1160 -1060 0 0 {name=p1090 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -940 0 0 {name=l396 lab=GND}
C {devices/lab_pin.sym} -910 -1010 0 0 {name=p1091 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -780 -940 0 0 {name=Vmeas147 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -870 0 0 {name=M147
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -870 3 0 {name=l397 lab=GND}
C {devices/lab_pin.sym} -780 -830 2 0 {name=p1093 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -870 0 0 {name=p1094 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -830 0 0 {name=x147}
C {devices/lab_pin.sym} -840 -1060 0 0 {name=p1095 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -940 0 0 {name=l398 lab=GND}
C {devices/lab_pin.sym} -590 -1010 0 0 {name=p1096 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -460 -940 0 0 {name=Vmeas148 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -870 0 0 {name=M148
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -870 3 0 {name=l399 lab=GND}
C {devices/lab_pin.sym} -460 -830 2 0 {name=p1098 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -870 0 0 {name=p1099 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -830 0 0 {name=x148}
C {devices/lab_pin.sym} -520 -1060 0 0 {name=p1100 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -940 0 0 {name=l400 lab=GND}
C {devices/lab_pin.sym} -270 -1010 0 0 {name=p1101 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -140 -940 0 0 {name=Vmeas149 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -870 0 0 {name=M149
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -870 3 0 {name=l401 lab=GND}
C {devices/lab_pin.sym} -140 -830 2 0 {name=p1103 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -870 0 0 {name=p1104 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -830 0 0 {name=x149}
C {devices/lab_pin.sym} -200 -1060 0 0 {name=p1105 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -490 0 0 {name=l402 lab=GND}
C {devices/lab_pin.sym} -2830 -560 0 0 {name=p1106 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2700 -490 0 0 {name=Vmeas151 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -420 0 0 {name=M151
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -420 3 0 {name=l403 lab=GND}
C {devices/lab_pin.sym} -2700 -380 2 0 {name=p1108 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -420 0 0 {name=p1109 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -380 0 0 {name=x151}
C {devices/lab_pin.sym} -2760 -610 0 0 {name=p1110 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -490 0 0 {name=l404 lab=GND}
C {devices/lab_pin.sym} -2510 -560 0 0 {name=p1111 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2380 -490 0 0 {name=Vmeas152 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -420 0 0 {name=M152
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -420 3 0 {name=l405 lab=GND}
C {devices/lab_pin.sym} -2380 -380 2 0 {name=p1113 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -420 0 0 {name=p1114 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -380 0 0 {name=x152}
C {devices/lab_pin.sym} -2440 -610 0 0 {name=p1115 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -490 0 0 {name=l406 lab=GND}
C {devices/lab_pin.sym} -2190 -560 0 0 {name=p1116 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2060 -490 0 0 {name=Vmeas153 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -420 0 0 {name=M153
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -420 3 0 {name=l407 lab=GND}
C {devices/lab_pin.sym} -2060 -380 2 0 {name=p1118 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -420 0 0 {name=p1119 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -380 0 0 {name=x153}
C {devices/lab_pin.sym} -2120 -610 0 0 {name=p1120 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -490 0 0 {name=l408 lab=GND}
C {devices/lab_pin.sym} -1870 -560 0 0 {name=p1121 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas154 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M154
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l409 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p1123 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p1124 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x154}
C {devices/lab_pin.sym} -1800 -610 0 0 {name=p1125 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -490 0 0 {name=l410 lab=GND}
C {devices/lab_pin.sym} -1550 -560 0 0 {name=p1126 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1420 -490 0 0 {name=Vmeas155 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -420 0 0 {name=M155
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -420 3 0 {name=l411 lab=GND}
C {devices/lab_pin.sym} -1420 -380 2 0 {name=p1128 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -420 0 0 {name=p1129 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -380 0 0 {name=x155}
C {devices/lab_pin.sym} -1480 -610 0 0 {name=p1130 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -490 0 0 {name=l412 lab=GND}
C {devices/lab_pin.sym} -1230 -560 0 0 {name=p1131 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1100 -490 0 0 {name=Vmeas156 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -420 0 0 {name=M156
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -420 3 0 {name=l413 lab=GND}
C {devices/lab_pin.sym} -1100 -380 2 0 {name=p1133 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -420 0 0 {name=p1134 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -380 0 0 {name=x156}
C {devices/lab_pin.sym} -1160 -610 0 0 {name=p1135 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -490 0 0 {name=l414 lab=GND}
C {devices/lab_pin.sym} -910 -560 0 0 {name=p1136 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -780 -490 0 0 {name=Vmeas157 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -420 0 0 {name=M157
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -420 3 0 {name=l415 lab=GND}
C {devices/lab_pin.sym} -780 -380 2 0 {name=p1138 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -420 0 0 {name=p1139 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -380 0 0 {name=x157}
C {devices/lab_pin.sym} -840 -610 0 0 {name=p1140 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -490 0 0 {name=l416 lab=GND}
C {devices/lab_pin.sym} -590 -560 0 0 {name=p1141 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -460 -490 0 0 {name=Vmeas158 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -420 0 0 {name=M158
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -420 3 0 {name=l417 lab=GND}
C {devices/lab_pin.sym} -460 -380 2 0 {name=p1143 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -420 0 0 {name=p1144 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -380 0 0 {name=x158}
C {devices/lab_pin.sym} -520 -610 0 0 {name=p1145 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -490 0 0 {name=l418 lab=GND}
C {devices/lab_pin.sym} -270 -560 0 0 {name=p1146 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -140 -490 0 0 {name=Vmeas159 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -420 0 0 {name=M159
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -420 3 0 {name=l419 lab=GND}
C {devices/lab_pin.sym} -140 -380 2 0 {name=p1148 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -420 0 0 {name=p1149 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -380 0 0 {name=x159}
C {devices/lab_pin.sym} -200 -610 0 0 {name=p1150 sig_type=std_logic lab=vdd_syn9}
C {devices/lab_pin.sym} -2510 -5060 0 0 {name=p626 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2190 -5060 0 0 {name=p627 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1870 -5060 0 0 {name=p631 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1550 -5060 0 0 {name=p632 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1230 -5060 0 0 {name=p636 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -910 -5060 0 0 {name=p637 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -590 -5060 0 0 {name=p641 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -270 -5060 0 0 {name=p642 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2830 -5510 0 0 {name=p478 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2510 -5510 0 0 {name=p479 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2190 -5510 0 0 {name=p483 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1870 -5510 0 0 {name=p484 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1550 -5510 0 0 {name=p488 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1230 -5510 0 0 {name=p489 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -910 -5510 0 0 {name=p493 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -590 -5510 0 0 {name=p494 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -270 -5510 0 0 {name=p498 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2830 -5960 0 0 {name=p525 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2510 -5960 0 0 {name=p526 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2190 -5960 0 0 {name=p530 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1870 -5960 0 0 {name=p531 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1550 -5960 0 0 {name=p535 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1230 -5960 0 0 {name=p536 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -910 -5960 0 0 {name=p540 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -590 -5960 0 0 {name=p541 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -270 -5960 0 0 {name=p545 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2830 -6410 0 0 {name=p572 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2510 -6410 0 0 {name=p573 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2190 -6410 0 0 {name=p577 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1870 -6410 0 0 {name=p578 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1550 -6410 0 0 {name=p582 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1230 -6410 0 0 {name=p583 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -910 -6410 0 0 {name=p587 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -590 -6410 0 0 {name=p588 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -270 -6410 0 0 {name=p592 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} 30 -4380 0 0 {name=p1151 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} 30 -4400 0 0 {name=p1152 sig_type=std_logic lab=N2}
C {devices/lab_pin.sym} 30 -4420 0 0 {name=p1153 sig_type=std_logic lab=N3}
C {devices/lab_pin.sym} 30 -4440 0 0 {name=p1154 sig_type=std_logic lab=N4}
C {devices/lab_pin.sym} 30 -4460 0 0 {name=p1155 sig_type=std_logic lab=N5}
C {devices/lab_pin.sym} 30 -4480 0 0 {name=p1156 sig_type=std_logic lab=N6}
C {devices/lab_pin.sym} 30 -4500 0 0 {name=p1157 sig_type=std_logic lab=N7}
C {devices/lab_pin.sym} 30 -4520 0 0 {name=p1158 sig_type=std_logic lab=N8}
C {devices/lab_pin.sym} 30 -4540 0 0 {name=p1159 sig_type=std_logic lab=N9}
C {devices/vsource.sym} 120 -2790 0 0 {name=V23 value=1.8}
C {devices/gnd.sym} 120 -2740 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 120 -2840 2 0 {name=p1160 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} 220 -2790 0 0 {name=V24 value=1.8}
C {devices/gnd.sym} 220 -2740 0 0 {name=l420 lab=GND}
C {devices/lab_pin.sym} 220 -2840 2 0 {name=p1161 sig_type=std_logic lab=vdd_syn2}
C {devices/vsource.sym} 320 -2790 0 0 {name=V25 value=1.8}
C {devices/gnd.sym} 320 -2740 0 0 {name=l421 lab=GND}
C {devices/lab_pin.sym} 320 -2840 2 0 {name=p1162 sig_type=std_logic lab=vdd_syn3}
C {devices/vsource.sym} 420 -2790 0 0 {name=V26 value=1.8}
C {devices/gnd.sym} 420 -2740 0 0 {name=l422 lab=GND}
C {devices/lab_pin.sym} 420 -2840 2 0 {name=p1163 sig_type=std_logic lab=vdd_syn4}
C {devices/vsource.sym} 520 -2790 0 0 {name=V27 value=1.8}
C {devices/gnd.sym} 520 -2740 0 0 {name=l423 lab=GND}
C {devices/lab_pin.sym} 520 -2840 2 0 {name=p1164 sig_type=std_logic lab=vdd_syn5}
C {devices/vsource.sym} 620 -2790 0 0 {name=V28 value=1.8}
C {devices/gnd.sym} 620 -2740 0 0 {name=l424 lab=GND}
C {devices/lab_pin.sym} 620 -2840 2 0 {name=p1165 sig_type=std_logic lab=vdd_syn6}
C {devices/vsource.sym} 720 -2790 0 0 {name=V29 value=1.8}
C {devices/gnd.sym} 720 -2740 0 0 {name=l425 lab=GND}
C {devices/lab_pin.sym} 720 -2840 2 0 {name=p1166 sig_type=std_logic lab=vdd_syn7}
C {devices/vsource.sym} 820 -2790 0 0 {name=V30 value=1.8}
C {devices/gnd.sym} 820 -2740 0 0 {name=l426 lab=GND}
C {devices/lab_pin.sym} 820 -2840 2 0 {name=p1167 sig_type=std_logic lab=vdd_syn8}
C {devices/vsource.sym} 920 -2790 0 0 {name=V31 value=1.8}
C {devices/gnd.sym} 920 -2740 0 0 {name=l427 lab=GND}
C {devices/lab_pin.sym} 920 -2840 2 0 {name=p1168 sig_type=std_logic lab=vdd_syn9}
C {devices/vsource.sym} 700 -2650 0 0 {name=V32 value="PWL(0 0 9.9u 0 10u 1.8 39.9u 1.8 40u 0)"}
C {devices/gnd.sym} 700 -2600 0 0 {name=l428 lab=GND}
C {devices/lab_pin.sym} 700 -2700 2 0 {name=p1169 sig_type=std_logic lab=b_px}
C {devices/vsource.sym} 620 -2650 0 0 {name=V33 value=0}
C {devices/gnd.sym} 620 -2600 0 0 {name=l429 lab=GND}
C {devices/lab_pin.sym} 620 -2700 2 0 {name=p1170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -560 2 0 {name=p27 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -1010 2 0 {name=p30 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -1460 2 0 {name=p160 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -1910 2 0 {name=p165 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -2360 2 0 {name=p170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -2810 2 0 {name=p177 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -3260 2 0 {name=p180 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -3710 2 0 {name=p185 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -4160 2 0 {name=p382 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -4610 2 0 {name=p392 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -5060 2 0 {name=p394 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -5510 2 0 {name=p396 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -5960 2 0 {name=p400 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -6410 2 0 {name=p401 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -6860 2 0 {name=p405 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -6410 2 0 {name=p437 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -5060 2 0 {name=p442 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -3710 2 0 {name=p447 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -2360 2 0 {name=p452 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1010 2 0 {name=p457 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -560 2 0 {name=p462 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1460 2 0 {name=p469 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1910 2 0 {name=p474 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -2810 2 0 {name=p499 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -3260 2 0 {name=p503 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -4160 2 0 {name=p504 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -4610 2 0 {name=p508 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -5510 2 0 {name=p509 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -5960 2 0 {name=p514 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -6860 2 0 {name=p516 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -6860 2 0 {name=p520 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -6860 2 0 {name=p521 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -6860 2 0 {name=p546 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -6860 2 0 {name=p550 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -6860 2 0 {name=p551 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -6860 2 0 {name=p555 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -6860 2 0 {name=p556 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -6860 2 0 {name=p560 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -560 2 0 {name=p561 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -560 2 0 {name=p567 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -560 2 0 {name=p568 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -560 2 0 {name=p593 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -560 2 0 {name=p597 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -560 2 0 {name=p598 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -560 2 0 {name=p602 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -560 2 0 {name=p603 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -1010 2 0 {name=p607 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -1010 2 0 {name=p612 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -1010 2 0 {name=p616 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -1010 2 0 {name=p608 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -1010 2 0 {name=p617 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -1010 2 0 {name=p622 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -1010 2 0 {name=p646 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -1010 2 0 {name=p647 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -1460 2 0 {name=p651 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -1460 2 0 {name=p652 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -1460 2 0 {name=p656 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -1460 2 0 {name=p657 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -1460 2 0 {name=p663 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1460 2 0 {name=p668 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -1460 2 0 {name=p699 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -1460 2 0 {name=p707 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -1910 2 0 {name=p712 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -1910 2 0 {name=p717 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -1910 2 0 {name=p722 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -1910 2 0 {name=p727 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -1910 2 0 {name=p732 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -1910 2 0 {name=p737 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1910 2 0 {name=p742 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -1910 2 0 {name=p747 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -2360 2 0 {name=p752 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -2360 2 0 {name=p757 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -2360 2 0 {name=p762 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -2360 2 0 {name=p767 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -2360 2 0 {name=p772 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -2360 2 0 {name=p777 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -2360 2 0 {name=p782 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -2360 2 0 {name=p787 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -2810 2 0 {name=p792 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -2810 2 0 {name=p797 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -2810 2 0 {name=p802 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -2810 2 0 {name=p807 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -2810 2 0 {name=p812 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -2810 2 0 {name=p817 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -2810 2 0 {name=p822 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -2810 2 0 {name=p827 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -3260 2 0 {name=p832 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -3260 2 0 {name=p837 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -3260 2 0 {name=p842 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -3260 2 0 {name=p847 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -3260 2 0 {name=p852 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -3260 2 0 {name=p857 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -3260 2 0 {name=p862 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -3260 2 0 {name=p867 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -3710 2 0 {name=p872 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -3710 2 0 {name=p877 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -3710 2 0 {name=p882 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -3710 2 0 {name=p887 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -3710 2 0 {name=p892 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -3710 2 0 {name=p897 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -3710 2 0 {name=p902 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -3710 2 0 {name=p907 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -4160 2 0 {name=p912 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -4160 2 0 {name=p917 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -4160 2 0 {name=p922 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -4160 2 0 {name=p927 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -4160 2 0 {name=p932 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -4160 2 0 {name=p937 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -4160 2 0 {name=p942 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -4160 2 0 {name=p947 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -4610 2 0 {name=p952 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -4610 2 0 {name=p957 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -4610 2 0 {name=p962 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -4610 2 0 {name=p967 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -4610 2 0 {name=p972 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -4610 2 0 {name=p977 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4610 2 0 {name=p982 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -4610 2 0 {name=p987 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -5060 2 0 {name=p992 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -5060 2 0 {name=p997 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -5060 2 0 {name=p1002 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -5060 2 0 {name=p1007 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -5060 2 0 {name=p1012 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -5060 2 0 {name=p1017 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -5060 2 0 {name=p1022 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -5060 2 0 {name=p1027 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -5510 2 0 {name=p1032 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -5510 2 0 {name=p1037 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -5510 2 0 {name=p1042 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -5510 2 0 {name=p1047 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -5510 2 0 {name=p1052 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -5510 2 0 {name=p1057 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -5510 2 0 {name=p1062 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -5510 2 0 {name=p1067 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -5960 2 0 {name=p1072 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -5960 2 0 {name=p1077 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -5960 2 0 {name=p1082 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -5960 2 0 {name=p1087 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -5960 2 0 {name=p1092 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -5960 2 0 {name=p1097 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -5960 2 0 {name=p1102 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -5960 2 0 {name=p1107 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -6410 2 0 {name=p1112 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -6410 2 0 {name=p1117 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -6410 2 0 {name=p1122 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -6410 2 0 {name=p1127 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -6410 2 0 {name=p1132 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -6410 2 0 {name=p1137 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -6410 2 0 {name=p1142 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -6410 2 0 {name=p1147 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3060 -260 1 0 {name=p2 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -3090 -140 0 0 {name=l16 lab=GND}
C {devices/ammeter.sym} -3020 -300 0 0 {name=Vmeas200 savecurrent=true}
C {devices/lab_pin.sym} -3020 -340 2 0 {name=p12 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3020 -10 2 0 {name=p15 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} -2950 -140 3 0 {name=p16 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2980 -260 1 0 {name=p20 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -3020 -160 1 0 {name=x200}
C {devices/lab_pin.sym} 30 -4360 0 0 {name=p24 sig_type=std_logic lab=N0}
C {devices/vsource.sym} 270 -2510 0 0 {name=V4 savecurrent=false value=0.5}
C {devices/lab_pin.sym} 270 -2560 2 0 {name=p49 sig_type=std_logic lab=vb_tr}
C {devices/gnd.sym} 270 -2460 0 0 {name=l24 lab=GND}
C {devices/vsource.sym} 100 -2370 0 0 {name=V12 savecurrent=false value=0
*"PWL(0 0 9.9u 0 10u 1.8 79.9u 1.8 80u 0)"}
C {devices/lab_pin.sym} 100 -2420 2 0 {name=p52 sig_type=std_logic lab=ctrl_tr}
C {devices/gnd.sym} 100 -2320 0 0 {name=l29 lab=GND}
C {devices/launcher.sym} 90 -1915 0 0 {name=h3
descr="inference between 0_6_8"
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_InfStage_068_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WTA_circuit.sym} 150 -4440 0 0 {name=x160}
C {devices/vsource.sym} 340 -2370 0 0 {name=V34 value="PWL(0 0 548u 0 549u 1.8 550u 0)"}
C {devices/gnd.sym} 340 -2320 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 340 -2420 2 0 {name=p59 sig_type=std_logic lab=ctrl_newpattern}
C {devices/vsource.sym} 420 -2510 0 0 {name=V35 value=0}
C {devices/gnd.sym} 420 -2460 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} 420 -2560 2 0 {name=p60 sig_type=std_logic lab=vlky_pos}
C {devices/lab_pin.sym} 20 -4340 3 0 {name=p61 sig_type=std_logic lab=ctrl_newpattern}
C {devices/launcher.sym} 90 -1855 0 0 {name=h4
descr="inference between 0 to 9"
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_InfStage_full_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -6860 0 0 {name=x201}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -6410 0 0 {name=x202}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -5960 0 0 {name=x203}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -5510 0 0 {name=x204}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -5060 0 0 {name=x205}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4610 0 0 {name=x206}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4160 0 0 {name=x207}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3710 0 0 {name=x208}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3260 0 0 {name=x209}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2810 0 0 {name=x210}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2360 0 0 {name=x211}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1910 0 0 {name=x212}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1460 0 0 {name=x213}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1010 0 0 {name=x214}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -560 0 0 {name=x215}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -7010 0 0 {name=x216}
C {devices/lab_pin.sym} -3390 -7070 0 0 {name=p54 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -6960 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -3330 -7010 2 0 {name=p56 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -3450 -7010 0 0 {name=p62 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -3450 -7040 0 0 {name=p68 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -6980 0 0 {name=p69 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -6860 0 0 {name=x217}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -6710 0 0 {name=x218}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -6560 0 0 {name=x219}
C {devices/lab_pin.sym} -3390 -6620 0 0 {name=p77 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -6510 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -3330 -6560 2 0 {name=p83 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -3450 -6560 0 0 {name=p87 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3450 -6590 0 0 {name=p90 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -6530 0 0 {name=p99 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -6410 0 0 {name=x220}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -6260 0 0 {name=x221}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -6110 0 0 {name=x222}
C {devices/lab_pin.sym} -3390 -6170 0 0 {name=p100 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -6060 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -3330 -6110 2 0 {name=p102 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -3450 -6110 0 0 {name=p105 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3450 -6140 0 0 {name=p109 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -6080 0 0 {name=p112 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -5960 0 0 {name=x223}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -5810 0 0 {name=x224}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -5660 0 0 {name=x225}
C {devices/lab_pin.sym} -3390 -5720 0 0 {name=p118 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -5610 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -3330 -5660 2 0 {name=p122 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -3450 -5660 0 0 {name=p126 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3450 -5690 0 0 {name=p132 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -5630 0 0 {name=p135 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -5510 0 0 {name=x226}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -5360 0 0 {name=x227}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -5210 0 0 {name=x228}
C {devices/lab_pin.sym} -3390 -5270 0 0 {name=p137 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -5160 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -3330 -5210 2 0 {name=p145 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -3450 -5210 0 0 {name=p147 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3450 -5240 0 0 {name=p151 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -5180 0 0 {name=p155 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -5060 0 0 {name=x229}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4910 0 0 {name=x230}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -4760 0 0 {name=x231}
C {devices/lab_pin.sym} -3390 -4820 0 0 {name=p157 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -4710 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -3330 -4760 2 0 {name=p161 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -3450 -4760 0 0 {name=p166 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3450 -4790 0 0 {name=p169 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -4730 0 0 {name=p171 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4610 0 0 {name=x232}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4460 0 0 {name=x233}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -4310 0 0 {name=x234}
C {devices/lab_pin.sym} -3390 -4370 0 0 {name=p173 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -4260 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -3330 -4310 2 0 {name=p175 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -3450 -4310 0 0 {name=p181 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3450 -4340 0 0 {name=p186 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -4280 0 0 {name=p188 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4160 0 0 {name=x235}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4010 0 0 {name=x236}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -3860 0 0 {name=x237}
C {devices/lab_pin.sym} -3390 -3920 0 0 {name=p190 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -3810 0 0 {name=l63 lab=GND}
C {devices/lab_pin.sym} -3330 -3860 2 0 {name=p194 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -3450 -3860 0 0 {name=p197 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3450 -3890 0 0 {name=p198 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -3830 0 0 {name=p200 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3710 0 0 {name=x238}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3560 0 0 {name=x239}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -3410 0 0 {name=x240}
C {devices/lab_pin.sym} -3390 -3470 0 0 {name=p204 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -3360 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -3330 -3410 2 0 {name=p206 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -3450 -3410 0 0 {name=p210 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3450 -3440 0 0 {name=p212 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -3380 0 0 {name=p214 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3260 0 0 {name=x241}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3110 0 0 {name=x242}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -2960 0 0 {name=x243}
C {devices/lab_pin.sym} -3390 -3020 0 0 {name=p221 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -2910 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -3330 -2960 2 0 {name=p226 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -3450 -2960 0 0 {name=p227 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3450 -2990 0 0 {name=p229 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -2930 0 0 {name=p231 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2810 0 0 {name=x244}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2660 0 0 {name=x245}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -2510 0 0 {name=x246}
C {devices/lab_pin.sym} -3390 -2570 0 0 {name=p236 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -2460 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -3330 -2510 2 0 {name=p240 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -3450 -2510 0 0 {name=p242 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3450 -2540 0 0 {name=p244 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -2480 0 0 {name=p248 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2360 0 0 {name=x247}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2210 0 0 {name=x248}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -2060 0 0 {name=x249}
C {devices/lab_pin.sym} -3390 -2120 0 0 {name=p251 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -2010 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -3330 -2060 2 0 {name=p253 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -3450 -2060 0 0 {name=p255 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3450 -2090 0 0 {name=p257 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -2030 0 0 {name=p261 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1910 0 0 {name=x250}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1760 0 0 {name=x251}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -1610 0 0 {name=x252}
C {devices/lab_pin.sym} -3390 -1670 0 0 {name=p266 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -1560 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -3330 -1610 2 0 {name=p268 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -3450 -1610 0 0 {name=p269 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3450 -1640 0 0 {name=p271 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -1580 0 0 {name=p273 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1460 0 0 {name=x253}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1310 0 0 {name=x254}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -1160 0 0 {name=x255}
C {devices/lab_pin.sym} -3390 -1220 0 0 {name=p275 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -1110 0 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} -3330 -1160 2 0 {name=p278 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -3450 -1160 0 0 {name=p280 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3450 -1190 0 0 {name=p282 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -1130 0 0 {name=p284 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1010 0 0 {name=x256}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -860 0 0 {name=x257}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -710 0 0 {name=x258}
C {devices/lab_pin.sym} -3390 -770 0 0 {name=p433 sig_type=std_logic lab=vdd_tr}
C {devices/gnd.sym} -3390 -660 0 0 {name=l430 lab=GND}
C {devices/lab_pin.sym} -3330 -710 2 0 {name=p434 sig_type=std_logic lab=vpos15}
C {devices/lab_pin.sym} -3450 -710 0 0 {name=p435 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3450 -740 0 0 {name=p1171 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -680 0 0 {name=p1172 sig_type=std_logic lab=vb_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -560 0 0 {name=x259}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -410 0 0 {name=x260}
C {devices/launcher.sym} 90 -1885 0 0 {name=h5
descr="inference between 0_9"
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_InfStage_0_9_tb.raw tran"
}
C {devices/isource.sym} -4140 -6360 0 0 {name=I2 value=\{i_val2\}}
C {devices/gnd.sym} -4140 -6310 0 0 {name=l20 lab=GND}
C {devices/ammeter.sym} -4110 -6410 1 0 {name=Vmeas202 savecurrent=true}
C {devices/isource.sym} -4140 -6810 0 0 {name=I1 value=\{i_val1\}}
C {devices/gnd.sym} -4140 -6760 0 0 {name=l14 lab=GND}
C {devices/ammeter.sym} -4110 -6860 1 0 {name=Vmeas201 savecurrent=true}
C {devices/isource.sym} -4140 -5460 0 0 {name=I4 value=\{i_val4\}}
C {devices/gnd.sym} -4140 -5410 0 0 {name=l246 lab=GND}
C {devices/ammeter.sym} -4110 -5510 1 0 {name=Vmeas204 savecurrent=true}
C {devices/isource.sym} -4140 -5910 0 0 {name=I3 value=\{i_val3\}}
C {devices/gnd.sym} -4140 -5860 0 0 {name=l248 lab=GND}
C {devices/ammeter.sym} -4110 -5960 1 0 {name=Vmeas203 savecurrent=true}
C {devices/isource.sym} -4140 -4560 0 0 {name=I6 value=\{i_val6\}}
C {devices/gnd.sym} -4140 -4510 0 0 {name=l250 lab=GND}
C {devices/ammeter.sym} -4110 -4610 1 0 {name=Vmeas206 savecurrent=true}
C {devices/isource.sym} -4140 -5010 0 0 {name=I5 value=\{i_val5\}}
C {devices/gnd.sym} -4140 -4960 0 0 {name=l252 lab=GND}
C {devices/ammeter.sym} -4110 -5060 1 0 {name=Vmeas205 savecurrent=true}
C {devices/isource.sym} -4140 -3660 0 0 {name=I8 value=\{i_val8\}}
C {devices/gnd.sym} -4140 -3610 0 0 {name=l254 lab=GND}
C {devices/ammeter.sym} -4110 -3710 1 0 {name=Vmeas208 savecurrent=true}
C {devices/isource.sym} -4140 -4110 0 0 {name=I7 value=\{i_val7\}}
C {devices/gnd.sym} -4140 -4060 0 0 {name=l256 lab=GND}
C {devices/ammeter.sym} -4110 -4160 1 0 {name=Vmeas207 savecurrent=true}
C {devices/isource.sym} -4140 -3210 0 0 {name=I9 value=\{i_val9\}}
C {devices/gnd.sym} -4140 -3160 0 0 {name=l258 lab=GND}
C {devices/ammeter.sym} -4110 -3260 1 0 {name=Vmeas209 savecurrent=true}
C {devices/isource.sym} -4140 -2760 0 0 {name=I10 value=\{i_val10\}}
C {devices/gnd.sym} -4140 -2710 0 0 {name=l114 lab=GND}
C {devices/ammeter.sym} -4110 -2810 1 0 {name=Vmeas210 savecurrent=true}
C {devices/isource.sym} -4140 -1860 0 0 {name=I12 value=\{i_val12\}}
C {devices/gnd.sym} -4140 -1810 0 0 {name=l116 lab=GND}
C {devices/ammeter.sym} -4110 -1910 1 0 {name=Vmeas212 savecurrent=true}
C {devices/isource.sym} -4140 -2310 0 0 {name=I11 value=\{i_val11\}}
C {devices/gnd.sym} -4140 -2260 0 0 {name=l118 lab=GND}
C {devices/ammeter.sym} -4110 -2360 1 0 {name=Vmeas211 savecurrent=true}
C {devices/isource.sym} -4140 -960 0 0 {name=I14 value=\{i_val14\}}
C {devices/gnd.sym} -4140 -910 0 0 {name=l120 lab=GND}
C {devices/ammeter.sym} -4110 -1010 1 0 {name=Vmeas214 savecurrent=true}
C {devices/isource.sym} -4140 -1410 0 0 {name=I13 value=\{i_val13\}}
C {devices/gnd.sym} -4140 -1360 0 0 {name=l122 lab=GND}
C {devices/ammeter.sym} -4110 -1460 1 0 {name=Vmeas213 savecurrent=true}
C {devices/isource.sym} -4140 -510 0 0 {name=I15 value=\{i_val15\}}
C {devices/gnd.sym} -4140 -460 0 0 {name=l124 lab=GND}
C {devices/ammeter.sym} -4110 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/launcher.sym} 90 -1765 0 0 {name=h6
descr="inference 0"
tclcommand="xschem raw_read $netlist_dir/N3_Noisy_1.raw tran"
}
C {devices/lab_pin.sym} -210 -260 1 0 {name=p31 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -530 -260 1 0 {name=p17 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -850 -260 1 0 {name=p32 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -1170 -260 1 0 {name=p45 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -1490 -260 1 0 {name=p72 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -1810 -260 1 0 {name=p85 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -2130 -260 1 0 {name=p94 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -2450 -260 1 0 {name=p290 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -2770 -260 1 0 {name=p297 sig_type=std_logic lab=inh}
C {devices/lab_pin.sym} -3090 -260 1 0 {name=p303 sig_type=std_logic lab=inh}
