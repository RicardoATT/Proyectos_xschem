v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -400 800 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 -800 -800 0 -400 {flags=graph
y1=2.2
y2=5.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S11; 5 n.x11.xr1.n1#ngap -\\"
\\"S21; 5 n.x21.xr1.n1#ngap -\\"
\\"S31; 5 n.x31.xr1.n1#ngap -\\"
\\"S41; 5 n.x41.xr1.n1#ngap -\\"
\\"S51; 5 n.x51.xr1.n1#ngap -\\"
\\"S61; 5 n.x61.xr1.n1#ngap -\\"
\\"S71; 5 n.x71.xr1.n1#ngap -\\"
\\"S81; 5 n.x81.xr1.n1#ngap -\\"
\\"S91; 5 n.x91.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -800 -400 0 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 -1600 -400 -800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="17 18 19"
node="\\"Syn1;vdd_syn1\\"
\\"Syn2;vdd_syn2\\"
\\"Syn3;vdd_syn3\\""}
B 2 -1600 -1600 -800 -1200 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 1570 -2700 2370 -2300 {flags=graph
y1=0.14
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="4 6 7"
node="N0
N1
N2"}
B 2 -800 -1600 0 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 0 -800 800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S12; 5 n.x12.xr1.n1#ngap -\\"
\\"S22; 5 n.x22.xr1.n1#ngap -\\"
\\"S32; 5 n.x32.xr1.n1#ngap -\\"
\\"S42; 5 n.x42.xr1.n1#ngap -\\"
\\"S52; 5 n.x52.xr1.n1#ngap -\\"
\\"S62; 5 n.x62.xr1.n1#ngap -\\"
\\"S72; 5 n.x72.xr1.n1#ngap -\\"
\\"S82; 5 n.x82.xr1.n1#ngap -\\"
\\"S92; 5 n.x92.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -1600 -800 -800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -1600 -1200 -800 -800 {flags=graph
y1=-1.8e-07
y2=6.2e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"[A]\\""}
B 2 -800 -1200 0 -800 {flags=graph
y1=-3.5e-07
y2=6.8e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I11; i(Vmeas11)\\"
\\"I21; i(Vmeas21)\\"
\\"I31; i(Vmeas31)\\"
\\"I41; i(Vmeas41)\\"
\\"I51; i(Vmeas51)\\"
\\"I61; i(Vmeas61)\\"
\\"I71; i(Vmeas71)\\"
\\"I81; i(Vmeas81)\\"
\\"I91; i(Vmeas91)\\"
\\"[A]\\""}
B 2 0 -1200 800 -800 {flags=graph
y1=-3.1e-07
y2=7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21"
node="\\"I12; i(Vmeas12)\\"
\\"I22; i(Vmeas22)\\"
\\"I32; i(Vmeas32)\\"
\\"I42; i(Vmeas42)\\"
\\"I52; i(Vmeas52)\\"
\\"I62; i(Vmeas62)\\"
\\"I72; i(Vmeas72)\\"
\\"I82; i(Vmeas82)\\"
\\"I92; i(Vmeas92)\\"
\\"[A]\\""}
B 2 770 -2700 1570 -2300 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 17"
node="p0
p1
p2"}
B 2 800 -2000 1600 -1600 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 800 -1200 1600 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 1600 -1200 2400 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 2400 -1200 3200 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 800 -800 1600 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 800 -400 1600 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 1600 -800 2400 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 1600 -400 2400 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 2400 -800 3200 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 2400 -400 3200 0 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.00024
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
N -1500 -3270 -1500 -3250 {
lab=GND}
N -1500 -3350 -1500 -3330 {
lab=vdd_in}
N -1420 -3270 -1420 -3250 {
lab=GND}
N -1420 -3350 -1420 -3330 {
lab=vdd_pre}
N -2660 -7250 -2660 -7230 {
lab=GND}
N -2660 -7410 -2660 -7390 {
lab=vdd_pre}
N -3040 -7240 -3040 -7220 {
lab=GND}
N -2840 -7340 -2840 -7320 {
lab=vc2}
N -2840 -7370 -2830 -7370 {
lab=vdd_in}
N -2830 -7400 -2830 -7370 {
lab=vdd_in}
N -2840 -7400 -2830 -7400 {
lab=vdd_in}
N -2920 -7370 -2880 -7370 {
lab=#net1}
N -2960 -7400 -2840 -7400 {
lab=vdd_in}
N -2970 -7370 -2960 -7370 {
lab=vdd_in}
N -2970 -7400 -2970 -7370 {
lab=vdd_in}
N -2970 -7400 -2960 -7400 {
lab=vdd_in}
N -2960 -7340 -2960 -7320 {
lab=#net1}
N -2960 -7320 -2900 -7320 {
lab=#net1}
N -2900 -7370 -2900 -7320 {
lab=#net1}
N -3040 -7320 -3040 -7300 {
lab=#net2}
N -1240 -3270 -1240 -3250 {
lab=GND}
N -1240 -3350 -1240 -3330 {
lab=vdd_delay}
N -2240 -7780 -2240 -7770 {
lab=GND}
N -2240 -7890 -2240 -7880 {
lab=vdd_syn0}
N -2410 -7450 -2410 -7440 {
lab=GND}
N -2180 -7700 -2170 -7700 {
lab=GND}
N -2180 -7670 -2180 -7660 {
lab=p0}
N -2180 -260 -2180 -250 {
lab=#net3}
N -2180 -330 -2180 -320 {
lab=p0}
N -2180 -10 -2180 0 {
lab=N0}
N -1500 -2850 -1500 -2830 {
lab=GND}
N -1500 -2930 -1500 -2910 {
lab=uw}
N -1500 -2710 -1500 -2690 {
lab=GND}
N -1500 -2790 -1500 -2770 {
lab=training}
N -2520 -7320 -2510 -7320 {
lab=vpre2}
N -2250 -150 -2250 -130 {
lab=GND}
N -2110 -150 -2110 -130 {
lab=vdd_pos}
N -1500 -2570 -1500 -2550 {
lab=GND}
N -1500 -2650 -1500 -2630 {
lab=inference}
N -2980 -7320 -2960 -7320 {
lab=#net1}
N -1500 -2990 -1500 -2970 {
lab=GND}
N -1500 -3070 -1500 -3050 {
lab=ctrl1}
N -2410 -7110 -2410 -7100 {
lab=GND}
N -2360 -7160 -2360 -7150 {
lab=vpres2}
N -2470 -7180 -2460 -7180 {
lab=ctrl1}
N -2410 -7280 -2410 -7270 {
lab=GND}
N -2460 -7320 -2460 -7310 {
lab=vpre2}
N -2470 -7360 -2470 -7350 {
lab=ctrl2}
N -2470 -7350 -2460 -7350 {
lab=ctrl2}
N -1320 -2990 -1320 -2970 {
lab=GND}
N -1320 -3070 -1320 -3050 {
lab=ctrl2}
N -2470 -7200 -2470 -7180 {
lab=ctrl1}
N -1340 -3130 -1340 -3110 {
lab=GND}
N -1340 -3210 -1340 -3190 {
lab=vbias}
N -1330 -3270 -1330 -3250 {
lab=GND}
N -1330 -3350 -1330 -3330 {
lab=vdd_pos}
N -1130 -3270 -1130 -3250 {
lab=GND}
N -1130 -3350 -1130 -3330 {
lab=vdd_sw}
N -1050 -3270 -1050 -3250 {
lab=GND}
N -1050 -3350 -1050 -3330 {
lab=vdd_tg}
N -1500 -3130 -1500 -3110 {
lab=GND}
N -1500 -3210 -1500 -3190 {
lab=vb_pre}
N -1420 -3130 -1420 -3110 {
lab=GND}
N -1420 -3210 -1420 -3190 {
lab=vb_pos}
N -2410 -7390 -2410 -7360 {
lab=vdd_tg}
N -2410 -7560 -2410 -7530 {
lab=vdd_delay}
N -2410 -7230 -2410 -7190 {
lab=vdd_sw}
N -2470 -7490 -2470 -7480 {
lab=vpre2}
N -2350 -7490 -2350 -7480 {
lab=vpos2}
N -2360 -7330 -2360 -7320 {
lab=vpres2}
N -2300 -7850 -2300 -7840 {
lab=vpres1}
N -2180 -7850 -2180 -7840 {
lab=vpos1}
N -2470 -7150 -2460 -7150 {
lab=uw}
N -2660 -7770 -2660 -7750 {
lab=GND}
N -2660 -7930 -2660 -7910 {
lab=vdd_pre}
N -3040 -7760 -3040 -7740 {
lab=GND}
N -2840 -7860 -2840 -7840 {
lab=vc1}
N -2840 -7890 -2830 -7890 {
lab=vdd_in}
N -2830 -7920 -2830 -7890 {
lab=vdd_in}
N -2840 -7920 -2830 -7920 {
lab=vdd_in}
N -2920 -7890 -2880 -7890 {
lab=#net4}
N -2960 -7920 -2840 -7920 {
lab=vdd_in}
N -2970 -7890 -2960 -7890 {
lab=vdd_in}
N -2970 -7920 -2970 -7890 {
lab=vdd_in}
N -2970 -7920 -2960 -7920 {
lab=vdd_in}
N -2960 -7860 -2960 -7840 {
lab=#net4}
N -2960 -7840 -2900 -7840 {
lab=#net4}
N -2900 -7890 -2900 -7840 {
lab=#net4}
N -3040 -7840 -3040 -7820 {
lab=#net5}
N -2240 -7260 -2240 -7250 {
lab=GND}
N -2240 -7370 -2240 -7360 {
lab=vdd_syn0}
N -2410 -7970 -2410 -7960 {
lab=GND}
N -2180 -7180 -2170 -7180 {
lab=GND}
N -2180 -7150 -2180 -7140 {
lab=p0}
N -2520 -7840 -2510 -7840 {
lab=vpre1}
N -2980 -7840 -2960 -7840 {
lab=#net4}
N -2410 -7630 -2410 -7620 {
lab=GND}
N -2360 -7680 -2360 -7670 {
lab=vpres1}
N -2470 -7700 -2460 -7700 {
lab=ctrl1}
N -2410 -7800 -2410 -7790 {
lab=GND}
N -2460 -7840 -2460 -7830 {
lab=vpre1}
N -2470 -7880 -2470 -7870 {
lab=ctrl2}
N -2470 -7870 -2460 -7870 {
lab=ctrl2}
N -2470 -7720 -2470 -7700 {
lab=ctrl1}
N -2410 -7910 -2410 -7880 {
lab=vdd_tg}
N -2410 -8080 -2410 -8050 {
lab=vdd_delay}
N -2410 -7750 -2410 -7710 {
lab=vdd_sw}
N -2470 -8010 -2470 -8000 {
lab=vpre1}
N -2350 -8010 -2350 -8000 {
lab=vpos1}
N -2360 -7850 -2360 -7840 {
lab=vpres1}
N -2300 -7330 -2300 -7320 {
lab=vpres2}
N -2180 -7330 -2180 -7320 {
lab=vpos2}
N -2470 -7670 -2460 -7670 {
lab=uw}
N -2230 -7180 -2220 -7180 {
lab=ctrl_pos}
N -2230 -7700 -2220 -7700 {
lab=ctrl_pos}
N -1130 -2990 -1130 -2970 {
lab=GND}
N -1130 -3070 -1130 -3050 {
lab=ctrl_pos}
N -970 -3270 -970 -3250 {
lab=GND}
N -970 -3350 -970 -3330 {
lab=vdd_inh}
N -580 -3150 -580 -3140 {
lab=vdd_inh}
N -950 -2990 -950 -2970 {
lab=GND}
N -950 -3070 -950 -3050 {
lab=vinh}
N -580 -3040 -580 -3030 {
lab=GND}
N -520 -3090 -510 -3090 {
lab=inh_d}
N -580 -2940 -570 -2940 {
lab=inh0}
N -610 -2950 -610 -2940 {
lab=GND}
N -610 -2900 -610 -2890 {
lab=inh_d}
N -650 -2940 -640 -2940 {
lab=vinh}
N -580 -2800 -570 -2800 {
lab=inh1}
N -610 -2810 -610 -2800 {
lab=GND}
N -610 -2760 -610 -2750 {
lab=inh_d}
N -650 -2800 -640 -2800 {
lab=vinh}
N -1270 -3130 -1270 -3110 {
lab=GND}
N -1270 -3210 -1270 -3190 {
lab=vlky}
N -2840 -7840 -2760 -7840 {
lab=vc1}
N -2760 -7880 -2750 -7880 {
lab=vlky}
N -2760 -7800 -2750 -7800 {
lab=vb_pre}
N -2760 -7360 -2750 -7360 {
lab=vlky}
N -2840 -7320 -2760 -7320 {
lab=vc2}
N -2760 -7280 -2750 -7280 {
lab=vb_pre}
N -2250 -250 -2250 -240 {
lab=inh0}
N -2220 -250 -2220 -240 {
lab=vb_pos}
N -2140 -250 -2140 -240 {
lab=vlky}
N -1960 -260 -1960 -250 {
lab=#net6}
N -1960 -330 -1960 -320 {
lab=p1}
N -1960 -10 -1960 0 {
lab=N1}
N -2030 -150 -2030 -130 {
lab=GND}
N -1890 -150 -1890 -130 {
lab=vdd_pos}
N -2030 -250 -2030 -240 {
lab=inh1}
N -2000 -250 -2000 -240 {
lab=vb_pos}
N -1920 -250 -1920 -240 {
lab=vlky}
N -1500 -3410 -1500 -3390 {
lab=GND}
N -1500 -3490 -1500 -3470 {
lab=vdd_syn0}
N -1400 -3410 -1400 -3390 {
lab=GND}
N -1400 -3490 -1400 -3470 {
lab=vdd_syn1}
N -2470 -7640 -2460 -7640 {
lab=vbias}
N -2470 -7120 -2460 -7120 {
lab=vbias}
N -2180 -7820 -2180 -7800 {
lab=#net7}
N -2180 -7740 -2180 -7730 {
lab=#net8}
N -2180 -7300 -2180 -7280 {
lab=#net9}
N -2180 -7220 -2180 -7210 {
lab=#net10}
N -2020 -7780 -2020 -7770 {
lab=GND}
N -2020 -7890 -2020 -7880 {
lab=vdd_syn1}
N -1960 -7700 -1950 -7700 {
lab=GND}
N -1960 -7670 -1960 -7660 {
lab=p1}
N -2080 -7850 -2080 -7840 {
lab=vpres1}
N -1960 -7850 -1960 -7840 {
lab=vpos1}
N -2020 -7260 -2020 -7250 {
lab=GND}
N -2020 -7370 -2020 -7360 {
lab=vdd_syn1}
N -1960 -7180 -1950 -7180 {
lab=GND}
N -1960 -7150 -1960 -7140 {
lab=p1}
N -2080 -7330 -2080 -7320 {
lab=vpres2}
N -1960 -7330 -1960 -7320 {
lab=vpos2}
N -2010 -7180 -2000 -7180 {
lab=ctrl_pos}
N -2010 -7700 -2000 -7700 {
lab=ctrl_pos}
N -1960 -7820 -1960 -7800 {
lab=#net11}
N -1960 -7740 -1960 -7730 {
lab=#net12}
N -1960 -7300 -1960 -7280 {
lab=#net13}
N -1960 -7220 -1960 -7210 {
lab=#net14}
N -2410 -6930 -2410 -6920 {
lab=GND}
N -2410 -6590 -2410 -6580 {
lab=GND}
N -2360 -6640 -2360 -6630 {
lab=vpres3}
N -2470 -6660 -2460 -6660 {
lab=ctrl1}
N -2410 -6760 -2410 -6750 {
lab=GND}
N -2460 -6800 -2460 -6790 {
lab=vpre3}
N -2470 -6840 -2470 -6830 {
lab=ctrl2}
N -2470 -6830 -2460 -6830 {
lab=ctrl2}
N -2470 -6680 -2470 -6660 {
lab=ctrl1}
N -2410 -6870 -2410 -6840 {
lab=vdd_tg}
N -2410 -7040 -2410 -7010 {
lab=vdd_delay}
N -2410 -6710 -2410 -6670 {
lab=vdd_sw}
N -2470 -6970 -2470 -6960 {
lab=vpre3}
N -2350 -6970 -2350 -6960 {
lab=vpos3}
N -2360 -6810 -2360 -6800 {
lab=vpres3}
N -2470 -6630 -2460 -6630 {
lab=uw}
N -2470 -6600 -2460 -6600 {
lab=vbias}
N -2410 -6410 -2410 -6400 {
lab=GND}
N -2410 -6070 -2410 -6060 {
lab=GND}
N -2360 -6120 -2360 -6110 {
lab=vpres4}
N -2470 -6140 -2460 -6140 {
lab=ctrl1}
N -2410 -6240 -2410 -6230 {
lab=GND}
N -2460 -6280 -2460 -6270 {
lab=vpre4}
N -2470 -6320 -2470 -6310 {
lab=ctrl2}
N -2470 -6310 -2460 -6310 {
lab=ctrl2}
N -2470 -6160 -2470 -6140 {
lab=ctrl1}
N -2410 -6350 -2410 -6320 {
lab=vdd_tg}
N -2410 -6520 -2410 -6490 {
lab=vdd_delay}
N -2410 -6190 -2410 -6150 {
lab=vdd_sw}
N -2470 -6450 -2470 -6440 {
lab=vpre4}
N -2350 -6450 -2350 -6440 {
lab=vpos4}
N -2360 -6290 -2360 -6280 {
lab=vpres4}
N -2470 -6110 -2460 -6110 {
lab=uw}
N -2470 -6080 -2460 -6080 {
lab=vbias}
N -2410 -5890 -2410 -5880 {
lab=GND}
N -2410 -5550 -2410 -5540 {
lab=GND}
N -2360 -5600 -2360 -5590 {
lab=vpres5}
N -2470 -5620 -2460 -5620 {
lab=ctrl1}
N -2410 -5720 -2410 -5710 {
lab=GND}
N -2460 -5760 -2460 -5750 {
lab=vpre5}
N -2470 -5800 -2470 -5790 {
lab=ctrl2}
N -2470 -5790 -2460 -5790 {
lab=ctrl2}
N -2470 -5640 -2470 -5620 {
lab=ctrl1}
N -2410 -5830 -2410 -5800 {
lab=vdd_tg}
N -2410 -6000 -2410 -5970 {
lab=vdd_delay}
N -2410 -5670 -2410 -5630 {
lab=vdd_sw}
N -2470 -5930 -2470 -5920 {
lab=vpre5}
N -2350 -5930 -2350 -5920 {
lab=vpos5}
N -2360 -5770 -2360 -5760 {
lab=vpres5}
N -2470 -5590 -2460 -5590 {
lab=uw}
N -2470 -5560 -2460 -5560 {
lab=vbias}
N -2410 -5370 -2410 -5360 {
lab=GND}
N -2410 -5030 -2410 -5020 {
lab=GND}
N -2360 -5080 -2360 -5070 {
lab=vpres6}
N -2470 -5100 -2460 -5100 {
lab=ctrl1}
N -2410 -5200 -2410 -5190 {
lab=GND}
N -2460 -5240 -2460 -5230 {
lab=vpre6}
N -2470 -5280 -2470 -5270 {
lab=ctrl2}
N -2470 -5270 -2460 -5270 {
lab=ctrl2}
N -2470 -5120 -2470 -5100 {
lab=ctrl1}
N -2410 -5310 -2410 -5280 {
lab=vdd_tg}
N -2410 -5480 -2410 -5450 {
lab=vdd_delay}
N -2410 -5150 -2410 -5110 {
lab=vdd_sw}
N -2470 -5410 -2470 -5400 {
lab=vpre6}
N -2350 -5410 -2350 -5400 {
lab=vpos6}
N -2360 -5250 -2360 -5240 {
lab=vpres6}
N -2470 -5070 -2460 -5070 {
lab=uw}
N -2470 -5040 -2460 -5040 {
lab=vbias}
N -2410 -4850 -2410 -4840 {
lab=GND}
N -2410 -4510 -2410 -4500 {
lab=GND}
N -2360 -4560 -2360 -4550 {
lab=vpres7}
N -2470 -4580 -2460 -4580 {
lab=ctrl1}
N -2410 -4680 -2410 -4670 {
lab=GND}
N -2460 -4720 -2460 -4710 {
lab=vpre7}
N -2470 -4760 -2470 -4750 {
lab=ctrl2}
N -2470 -4750 -2460 -4750 {
lab=ctrl2}
N -2470 -4600 -2470 -4580 {
lab=ctrl1}
N -2410 -4790 -2410 -4760 {
lab=vdd_tg}
N -2410 -4960 -2410 -4930 {
lab=vdd_delay}
N -2410 -4630 -2410 -4590 {
lab=vdd_sw}
N -2470 -4890 -2470 -4880 {
lab=vpre7}
N -2350 -4890 -2350 -4880 {
lab=vpos7}
N -2360 -4730 -2360 -4720 {
lab=vpres7}
N -2470 -4550 -2460 -4550 {
lab=uw}
N -2470 -4520 -2460 -4520 {
lab=vbias}
N -2410 -4330 -2410 -4320 {
lab=GND}
N -2410 -3990 -2410 -3980 {
lab=GND}
N -2360 -4040 -2360 -4030 {
lab=vpres8}
N -2470 -4060 -2460 -4060 {
lab=ctrl1}
N -2410 -4160 -2410 -4150 {
lab=GND}
N -2460 -4200 -2460 -4190 {
lab=vpre8}
N -2470 -4240 -2470 -4230 {
lab=ctrl2}
N -2470 -4230 -2460 -4230 {
lab=ctrl2}
N -2470 -4080 -2470 -4060 {
lab=ctrl1}
N -2410 -4270 -2410 -4240 {
lab=vdd_tg}
N -2410 -4440 -2410 -4410 {
lab=vdd_delay}
N -2410 -4110 -2410 -4070 {
lab=vdd_sw}
N -2470 -4370 -2470 -4360 {
lab=vpre8}
N -2350 -4370 -2350 -4360 {
lab=vpos8}
N -2360 -4210 -2360 -4200 {
lab=vpres8}
N -2470 -4030 -2460 -4030 {
lab=uw}
N -2470 -4000 -2460 -4000 {
lab=vbias}
N -2410 -3810 -2410 -3800 {
lab=GND}
N -2410 -3470 -2410 -3460 {
lab=GND}
N -2360 -3520 -2360 -3510 {
lab=vpres9}
N -2470 -3540 -2460 -3540 {
lab=ctrl1}
N -2410 -3640 -2410 -3630 {
lab=GND}
N -2460 -3680 -2460 -3670 {
lab=vpre9}
N -2470 -3720 -2470 -3710 {
lab=ctrl2}
N -2470 -3710 -2460 -3710 {
lab=ctrl2}
N -2470 -3560 -2470 -3540 {
lab=ctrl1}
N -2410 -3750 -2410 -3720 {
lab=vdd_tg}
N -2410 -3920 -2410 -3890 {
lab=vdd_delay}
N -2410 -3590 -2410 -3550 {
lab=vdd_sw}
N -2470 -3850 -2470 -3840 {
lab=vpre9}
N -2350 -3850 -2350 -3840 {
lab=vpos9}
N -2360 -3690 -2360 -3680 {
lab=vpres9}
N -2470 -3510 -2460 -3510 {
lab=uw}
N -2470 -3480 -2460 -3480 {
lab=vbias}
N -2240 -6740 -2240 -6730 {
lab=GND}
N -2240 -6850 -2240 -6840 {
lab=vdd_syn0}
N -2180 -6660 -2170 -6660 {
lab=GND}
N -2180 -6630 -2180 -6620 {
lab=p0}
N -2300 -6810 -2300 -6800 {
lab=vpres3}
N -2180 -6810 -2180 -6800 {
lab=vpos3}
N -2230 -6660 -2220 -6660 {
lab=ctrl_pos}
N -2180 -6780 -2180 -6760 {
lab=#net15}
N -2180 -6700 -2180 -6690 {
lab=#net16}
N -2020 -6740 -2020 -6730 {
lab=GND}
N -2020 -6850 -2020 -6840 {
lab=vdd_syn1}
N -1960 -6660 -1950 -6660 {
lab=GND}
N -1960 -6630 -1960 -6620 {
lab=p1}
N -2080 -6810 -2080 -6800 {
lab=vpres3}
N -1960 -6810 -1960 -6800 {
lab=vpos3}
N -2010 -6660 -2000 -6660 {
lab=ctrl_pos}
N -1960 -6780 -1960 -6760 {
lab=#net17}
N -1960 -6700 -1960 -6690 {
lab=#net18}
N -2240 -6220 -2240 -6210 {
lab=GND}
N -2240 -6330 -2240 -6320 {
lab=vdd_syn0}
N -2180 -6140 -2170 -6140 {
lab=GND}
N -2180 -6110 -2180 -6100 {
lab=p0}
N -2300 -6290 -2300 -6280 {
lab=vpres4}
N -2180 -6290 -2180 -6280 {
lab=vpos4}
N -2230 -6140 -2220 -6140 {
lab=ctrl_pos}
N -2180 -6260 -2180 -6240 {
lab=#net19}
N -2180 -6180 -2180 -6170 {
lab=#net20}
N -2020 -6220 -2020 -6210 {
lab=GND}
N -2020 -6330 -2020 -6320 {
lab=vdd_syn1}
N -1960 -6140 -1950 -6140 {
lab=GND}
N -1960 -6110 -1960 -6100 {
lab=p1}
N -2080 -6290 -2080 -6280 {
lab=vpres4}
N -1960 -6290 -1960 -6280 {
lab=vpos4}
N -2010 -6140 -2000 -6140 {
lab=ctrl_pos}
N -1960 -6260 -1960 -6240 {
lab=#net21}
N -1960 -6180 -1960 -6170 {
lab=#net22}
N -2240 -5700 -2240 -5690 {
lab=GND}
N -2240 -5810 -2240 -5800 {
lab=vdd_syn0}
N -2180 -5620 -2170 -5620 {
lab=GND}
N -2180 -5590 -2180 -5580 {
lab=p0}
N -2300 -5770 -2300 -5760 {
lab=vpres5}
N -2180 -5770 -2180 -5760 {
lab=vpos5}
N -2230 -5620 -2220 -5620 {
lab=ctrl_pos}
N -2180 -5740 -2180 -5720 {
lab=#net23}
N -2180 -5660 -2180 -5650 {
lab=#net24}
N -2020 -5700 -2020 -5690 {
lab=GND}
N -2020 -5810 -2020 -5800 {
lab=vdd_syn1}
N -1960 -5620 -1950 -5620 {
lab=GND}
N -1960 -5590 -1960 -5580 {
lab=p1}
N -2080 -5770 -2080 -5760 {
lab=vpres5}
N -1960 -5770 -1960 -5760 {
lab=vpos5}
N -2010 -5620 -2000 -5620 {
lab=ctrl_pos}
N -1960 -5740 -1960 -5720 {
lab=#net25}
N -1960 -5660 -1960 -5650 {
lab=#net26}
N -2240 -5180 -2240 -5170 {
lab=GND}
N -2240 -5290 -2240 -5280 {
lab=vdd_syn0}
N -2180 -5100 -2170 -5100 {
lab=GND}
N -2180 -5070 -2180 -5060 {
lab=p0}
N -2300 -5250 -2300 -5240 {
lab=vpres6}
N -2180 -5250 -2180 -5240 {
lab=vpos6}
N -2230 -5100 -2220 -5100 {
lab=ctrl_pos}
N -2180 -5220 -2180 -5200 {
lab=#net27}
N -2180 -5140 -2180 -5130 {
lab=#net28}
N -2020 -5180 -2020 -5170 {
lab=GND}
N -2020 -5290 -2020 -5280 {
lab=vdd_syn1}
N -1960 -5100 -1950 -5100 {
lab=GND}
N -1960 -5070 -1960 -5060 {
lab=p1}
N -2080 -5250 -2080 -5240 {
lab=vpres6}
N -1960 -5250 -1960 -5240 {
lab=vpos6}
N -2010 -5100 -2000 -5100 {
lab=ctrl_pos}
N -1960 -5220 -1960 -5200 {
lab=#net29}
N -1960 -5140 -1960 -5130 {
lab=#net30}
N -2240 -4660 -2240 -4650 {
lab=GND}
N -2240 -4770 -2240 -4760 {
lab=vdd_syn0}
N -2180 -4580 -2170 -4580 {
lab=GND}
N -2180 -4550 -2180 -4540 {
lab=p0}
N -2300 -4730 -2300 -4720 {
lab=vpres7}
N -2180 -4730 -2180 -4720 {
lab=vpos7}
N -2230 -4580 -2220 -4580 {
lab=ctrl_pos}
N -2180 -4700 -2180 -4680 {
lab=#net31}
N -2180 -4620 -2180 -4610 {
lab=#net32}
N -2020 -4660 -2020 -4650 {
lab=GND}
N -2020 -4770 -2020 -4760 {
lab=vdd_syn1}
N -1960 -4580 -1950 -4580 {
lab=GND}
N -1960 -4550 -1960 -4540 {
lab=p1}
N -2080 -4730 -2080 -4720 {
lab=vpres7}
N -1960 -4730 -1960 -4720 {
lab=vpos7}
N -2010 -4580 -2000 -4580 {
lab=ctrl_pos}
N -1960 -4700 -1960 -4680 {
lab=#net33}
N -1960 -4620 -1960 -4610 {
lab=#net34}
N -2240 -4140 -2240 -4130 {
lab=GND}
N -2240 -4250 -2240 -4240 {
lab=vdd_syn0}
N -2180 -4060 -2170 -4060 {
lab=GND}
N -2180 -4030 -2180 -4020 {
lab=p0}
N -2300 -4210 -2300 -4200 {
lab=vpres8}
N -2180 -4210 -2180 -4200 {
lab=vpos8}
N -2230 -4060 -2220 -4060 {
lab=ctrl_pos}
N -2180 -4180 -2180 -4160 {
lab=#net35}
N -2180 -4100 -2180 -4090 {
lab=#net36}
N -2020 -4140 -2020 -4130 {
lab=GND}
N -2020 -4250 -2020 -4240 {
lab=vdd_syn1}
N -1960 -4060 -1950 -4060 {
lab=GND}
N -1960 -4030 -1960 -4020 {
lab=p1}
N -2080 -4210 -2080 -4200 {
lab=vpres8}
N -1960 -4210 -1960 -4200 {
lab=vpos8}
N -2010 -4060 -2000 -4060 {
lab=ctrl_pos}
N -1960 -4180 -1960 -4160 {
lab=#net37}
N -1960 -4100 -1960 -4090 {
lab=#net38}
N -2240 -3620 -2240 -3610 {
lab=GND}
N -2240 -3730 -2240 -3720 {
lab=vdd_syn0}
N -2180 -3540 -2170 -3540 {
lab=GND}
N -2180 -3510 -2180 -3500 {
lab=p0}
N -2300 -3690 -2300 -3680 {
lab=vpres9}
N -2180 -3690 -2180 -3680 {
lab=vpos9}
N -2230 -3540 -2220 -3540 {
lab=ctrl_pos}
N -2180 -3660 -2180 -3640 {
lab=#net39}
N -2180 -3580 -2180 -3570 {
lab=#net40}
N -2020 -3620 -2020 -3610 {
lab=GND}
N -2020 -3730 -2020 -3720 {
lab=vdd_syn1}
N -1960 -3540 -1950 -3540 {
lab=GND}
N -1960 -3510 -1960 -3500 {
lab=p1}
N -2080 -3690 -2080 -3680 {
lab=vpres9}
N -1960 -3690 -1960 -3680 {
lab=vpos9}
N -2010 -3540 -2000 -3540 {
lab=ctrl_pos}
N -1960 -3660 -1960 -3640 {
lab=#net41}
N -1960 -3580 -1960 -3570 {
lab=#net42}
N -2660 -6210 -2660 -6190 {
lab=GND}
N -2660 -6370 -2660 -6350 {
lab=vdd_pre}
N -3040 -6200 -3040 -6180 {
lab=GND}
N -2840 -6300 -2840 -6280 {
lab=vc4}
N -2840 -6330 -2830 -6330 {
lab=vdd_in}
N -2830 -6360 -2830 -6330 {
lab=vdd_in}
N -2840 -6360 -2830 -6360 {
lab=vdd_in}
N -2920 -6330 -2880 -6330 {
lab=#net43}
N -2960 -6360 -2840 -6360 {
lab=vdd_in}
N -2970 -6330 -2960 -6330 {
lab=vdd_in}
N -2970 -6360 -2970 -6330 {
lab=vdd_in}
N -2970 -6360 -2960 -6360 {
lab=vdd_in}
N -2960 -6300 -2960 -6280 {
lab=#net43}
N -2960 -6280 -2900 -6280 {
lab=#net43}
N -2900 -6330 -2900 -6280 {
lab=#net43}
N -3040 -6280 -3040 -6260 {
lab=#net44}
N -2520 -6280 -2510 -6280 {
lab=vpre4}
N -2980 -6280 -2960 -6280 {
lab=#net43}
N -2660 -6730 -2660 -6710 {
lab=GND}
N -2660 -6890 -2660 -6870 {
lab=vdd_pre}
N -3040 -6720 -3040 -6700 {
lab=GND}
N -2840 -6820 -2840 -6800 {
lab=vc3}
N -2840 -6850 -2830 -6850 {
lab=vdd_in}
N -2830 -6880 -2830 -6850 {
lab=vdd_in}
N -2840 -6880 -2830 -6880 {
lab=vdd_in}
N -2920 -6850 -2880 -6850 {
lab=#net45}
N -2960 -6880 -2840 -6880 {
lab=vdd_in}
N -2970 -6850 -2960 -6850 {
lab=vdd_in}
N -2970 -6880 -2970 -6850 {
lab=vdd_in}
N -2970 -6880 -2960 -6880 {
lab=vdd_in}
N -2960 -6820 -2960 -6800 {
lab=#net45}
N -2960 -6800 -2900 -6800 {
lab=#net45}
N -2900 -6850 -2900 -6800 {
lab=#net45}
N -3040 -6800 -3040 -6780 {
lab=#net46}
N -2520 -6800 -2510 -6800 {
lab=vpre3}
N -2980 -6800 -2960 -6800 {
lab=#net45}
N -2840 -6800 -2760 -6800 {
lab=vc3}
N -2760 -6840 -2750 -6840 {
lab=vlky}
N -2760 -6760 -2750 -6760 {
lab=vb_pre}
N -2760 -6320 -2750 -6320 {
lab=vlky}
N -2840 -6280 -2760 -6280 {
lab=vc4}
N -2760 -6240 -2750 -6240 {
lab=vb_pre}
N -2660 -5170 -2660 -5150 {
lab=GND}
N -2660 -5330 -2660 -5310 {
lab=vdd_pre}
N -3040 -5160 -3040 -5140 {
lab=GND}
N -2840 -5260 -2840 -5240 {
lab=vc6}
N -2840 -5290 -2830 -5290 {
lab=vdd_in}
N -2830 -5320 -2830 -5290 {
lab=vdd_in}
N -2840 -5320 -2830 -5320 {
lab=vdd_in}
N -2920 -5290 -2880 -5290 {
lab=#net47}
N -2960 -5320 -2840 -5320 {
lab=vdd_in}
N -2970 -5290 -2960 -5290 {
lab=vdd_in}
N -2970 -5320 -2970 -5290 {
lab=vdd_in}
N -2970 -5320 -2960 -5320 {
lab=vdd_in}
N -2960 -5260 -2960 -5240 {
lab=#net47}
N -2960 -5240 -2900 -5240 {
lab=#net47}
N -2900 -5290 -2900 -5240 {
lab=#net47}
N -3040 -5240 -3040 -5220 {
lab=#net48}
N -2520 -5240 -2510 -5240 {
lab=vpre6}
N -2980 -5240 -2960 -5240 {
lab=#net47}
N -2660 -5690 -2660 -5670 {
lab=GND}
N -2660 -5850 -2660 -5830 {
lab=vdd_pre}
N -3040 -5680 -3040 -5660 {
lab=GND}
N -2840 -5780 -2840 -5760 {
lab=vc5}
N -2840 -5810 -2830 -5810 {
lab=vdd_in}
N -2830 -5840 -2830 -5810 {
lab=vdd_in}
N -2840 -5840 -2830 -5840 {
lab=vdd_in}
N -2920 -5810 -2880 -5810 {
lab=#net49}
N -2960 -5840 -2840 -5840 {
lab=vdd_in}
N -2970 -5810 -2960 -5810 {
lab=vdd_in}
N -2970 -5840 -2970 -5810 {
lab=vdd_in}
N -2970 -5840 -2960 -5840 {
lab=vdd_in}
N -2960 -5780 -2960 -5760 {
lab=#net49}
N -2960 -5760 -2900 -5760 {
lab=#net49}
N -2900 -5810 -2900 -5760 {
lab=#net49}
N -3040 -5760 -3040 -5740 {
lab=#net50}
N -2520 -5760 -2510 -5760 {
lab=vpre5}
N -2980 -5760 -2960 -5760 {
lab=#net49}
N -2840 -5760 -2760 -5760 {
lab=vc5}
N -2760 -5800 -2750 -5800 {
lab=vlky}
N -2760 -5720 -2750 -5720 {
lab=vb_pre}
N -2760 -5280 -2750 -5280 {
lab=vlky}
N -2840 -5240 -2760 -5240 {
lab=vc6}
N -2760 -5200 -2750 -5200 {
lab=vb_pre}
N -2660 -4130 -2660 -4110 {
lab=GND}
N -2660 -4290 -2660 -4270 {
lab=vdd_pre}
N -3040 -4120 -3040 -4100 {
lab=GND}
N -2840 -4220 -2840 -4200 {
lab=vc8}
N -2840 -4250 -2830 -4250 {
lab=vdd_in}
N -2830 -4280 -2830 -4250 {
lab=vdd_in}
N -2840 -4280 -2830 -4280 {
lab=vdd_in}
N -2920 -4250 -2880 -4250 {
lab=#net51}
N -2960 -4280 -2840 -4280 {
lab=vdd_in}
N -2970 -4250 -2960 -4250 {
lab=vdd_in}
N -2970 -4280 -2970 -4250 {
lab=vdd_in}
N -2970 -4280 -2960 -4280 {
lab=vdd_in}
N -2960 -4220 -2960 -4200 {
lab=#net51}
N -2960 -4200 -2900 -4200 {
lab=#net51}
N -2900 -4250 -2900 -4200 {
lab=#net51}
N -3040 -4200 -3040 -4180 {
lab=#net52}
N -2520 -4200 -2510 -4200 {
lab=vpre8}
N -2980 -4200 -2960 -4200 {
lab=#net51}
N -2660 -4650 -2660 -4630 {
lab=GND}
N -2660 -4810 -2660 -4790 {
lab=vdd_pre}
N -3040 -4640 -3040 -4620 {
lab=GND}
N -2840 -4740 -2840 -4720 {
lab=vc7}
N -2840 -4770 -2830 -4770 {
lab=vdd_in}
N -2830 -4800 -2830 -4770 {
lab=vdd_in}
N -2840 -4800 -2830 -4800 {
lab=vdd_in}
N -2920 -4770 -2880 -4770 {
lab=#net53}
N -2960 -4800 -2840 -4800 {
lab=vdd_in}
N -2970 -4770 -2960 -4770 {
lab=vdd_in}
N -2970 -4800 -2970 -4770 {
lab=vdd_in}
N -2970 -4800 -2960 -4800 {
lab=vdd_in}
N -2960 -4740 -2960 -4720 {
lab=#net53}
N -2960 -4720 -2900 -4720 {
lab=#net53}
N -2900 -4770 -2900 -4720 {
lab=#net53}
N -3040 -4720 -3040 -4700 {
lab=#net54}
N -2520 -4720 -2510 -4720 {
lab=vpre7}
N -2980 -4720 -2960 -4720 {
lab=#net53}
N -2840 -4720 -2760 -4720 {
lab=vc7}
N -2760 -4760 -2750 -4760 {
lab=vlky}
N -2760 -4680 -2750 -4680 {
lab=vb_pre}
N -2760 -4240 -2750 -4240 {
lab=vlky}
N -2840 -4200 -2760 -4200 {
lab=vc8}
N -2760 -4160 -2750 -4160 {
lab=vb_pre}
N -2660 -3610 -2660 -3590 {
lab=GND}
N -2660 -3770 -2660 -3750 {
lab=vdd_pre}
N -3040 -3600 -3040 -3580 {
lab=GND}
N -2840 -3700 -2840 -3680 {
lab=vc9}
N -2840 -3730 -2830 -3730 {
lab=vdd_in}
N -2830 -3760 -2830 -3730 {
lab=vdd_in}
N -2840 -3760 -2830 -3760 {
lab=vdd_in}
N -2920 -3730 -2880 -3730 {
lab=#net55}
N -2960 -3760 -2840 -3760 {
lab=vdd_in}
N -2970 -3730 -2960 -3730 {
lab=vdd_in}
N -2970 -3760 -2970 -3730 {
lab=vdd_in}
N -2970 -3760 -2960 -3760 {
lab=vdd_in}
N -2960 -3700 -2960 -3680 {
lab=#net55}
N -2960 -3680 -2900 -3680 {
lab=#net55}
N -2900 -3730 -2900 -3680 {
lab=#net55}
N -3040 -3680 -3040 -3660 {
lab=#net56}
N -2520 -3680 -2510 -3680 {
lab=vpre9}
N -2980 -3680 -2960 -3680 {
lab=#net55}
N -2760 -3720 -2750 -3720 {
lab=vlky}
N -2840 -3680 -2760 -3680 {
lab=vc9}
N -2760 -3640 -2750 -3640 {
lab=vb_pre}
N -660 -3070 -650 -3070 {
lab=N0}
N -660 -3110 -650 -3110 {
lab=N1}
N -1300 -3410 -1300 -3390 {
lab=GND}
N -1300 -3490 -1300 -3470 {
lab=vdd_syn3}
N -2410 -3290 -2410 -3280 {
lab=GND}
N -2410 -2950 -2410 -2940 {
lab=GND}
N -2360 -3000 -2360 -2990 {
lab=vpres10}
N -2470 -3020 -2460 -3020 {
lab=ctrl1}
N -2410 -3120 -2410 -3110 {
lab=GND}
N -2460 -3160 -2460 -3150 {
lab=vpre10}
N -2470 -3200 -2470 -3190 {
lab=ctrl2}
N -2470 -3190 -2460 -3190 {
lab=ctrl2}
N -2470 -3040 -2470 -3020 {
lab=ctrl1}
N -2410 -3230 -2410 -3200 {
lab=vdd_tg}
N -2410 -3400 -2410 -3370 {
lab=vdd_delay}
N -2410 -3070 -2410 -3030 {
lab=vdd_sw}
N -2470 -3330 -2470 -3320 {
lab=vpre10}
N -2350 -3330 -2350 -3320 {
lab=vpos10}
N -2360 -3170 -2360 -3160 {
lab=vpres10}
N -2470 -2990 -2460 -2990 {
lab=uw}
N -2470 -2960 -2460 -2960 {
lab=vbias}
N -2410 -2770 -2410 -2760 {
lab=GND}
N -2410 -2430 -2410 -2420 {
lab=GND}
N -2360 -2480 -2360 -2470 {
lab=vpres11}
N -2470 -2500 -2460 -2500 {
lab=ctrl1}
N -2410 -2600 -2410 -2590 {
lab=GND}
N -2460 -2640 -2460 -2630 {
lab=vpre11}
N -2470 -2680 -2470 -2670 {
lab=ctrl2}
N -2470 -2670 -2460 -2670 {
lab=ctrl2}
N -2470 -2520 -2470 -2500 {
lab=ctrl1}
N -2410 -2710 -2410 -2680 {
lab=vdd_tg}
N -2410 -2880 -2410 -2850 {
lab=vdd_delay}
N -2410 -2550 -2410 -2510 {
lab=vdd_sw}
N -2470 -2810 -2470 -2800 {
lab=vpre11}
N -2350 -2810 -2350 -2800 {
lab=vpos11}
N -2360 -2650 -2360 -2640 {
lab=vpres11}
N -2470 -2470 -2460 -2470 {
lab=uw}
N -2470 -2440 -2460 -2440 {
lab=vbias}
N -2410 -2250 -2410 -2240 {
lab=GND}
N -2410 -1910 -2410 -1900 {
lab=GND}
N -2360 -1960 -2360 -1950 {
lab=vpres12}
N -2470 -1980 -2460 -1980 {
lab=ctrl1}
N -2410 -2080 -2410 -2070 {
lab=GND}
N -2460 -2120 -2460 -2110 {
lab=vpre12}
N -2470 -2160 -2470 -2150 {
lab=ctrl2}
N -2470 -2150 -2460 -2150 {
lab=ctrl2}
N -2470 -2000 -2470 -1980 {
lab=ctrl1}
N -2410 -2190 -2410 -2160 {
lab=vdd_tg}
N -2410 -2360 -2410 -2330 {
lab=vdd_delay}
N -2410 -2030 -2410 -1990 {
lab=vdd_sw}
N -2470 -2290 -2470 -2280 {
lab=vpre12}
N -2350 -2290 -2350 -2280 {
lab=vpos12}
N -2360 -2130 -2360 -2120 {
lab=vpres12}
N -2470 -1950 -2460 -1950 {
lab=uw}
N -2470 -1920 -2460 -1920 {
lab=vbias}
N -2410 -1730 -2410 -1720 {
lab=GND}
N -2410 -1390 -2410 -1380 {
lab=GND}
N -2360 -1440 -2360 -1430 {
lab=vpres13}
N -2470 -1460 -2460 -1460 {
lab=ctrl1}
N -2410 -1560 -2410 -1550 {
lab=GND}
N -2460 -1600 -2460 -1590 {
lab=vpre13}
N -2470 -1640 -2470 -1630 {
lab=ctrl2}
N -2470 -1630 -2460 -1630 {
lab=ctrl2}
N -2470 -1480 -2470 -1460 {
lab=ctrl1}
N -2410 -1670 -2410 -1640 {
lab=vdd_tg}
N -2410 -1840 -2410 -1810 {
lab=vdd_delay}
N -2410 -1510 -2410 -1470 {
lab=vdd_sw}
N -2470 -1770 -2470 -1760 {
lab=vpre13}
N -2350 -1770 -2350 -1760 {
lab=vpos13}
N -2360 -1610 -2360 -1600 {
lab=vpres13}
N -2470 -1430 -2460 -1430 {
lab=uw}
N -2470 -1400 -2460 -1400 {
lab=vbias}
N -2410 -1210 -2410 -1200 {
lab=GND}
N -2410 -870 -2410 -860 {
lab=GND}
N -2360 -920 -2360 -910 {
lab=vpres14}
N -2470 -940 -2460 -940 {
lab=ctrl1}
N -2410 -1040 -2410 -1030 {
lab=GND}
N -2460 -1080 -2460 -1070 {
lab=vpre14}
N -2470 -1120 -2470 -1110 {
lab=ctrl2}
N -2470 -1110 -2460 -1110 {
lab=ctrl2}
N -2470 -960 -2470 -940 {
lab=ctrl1}
N -2410 -1150 -2410 -1120 {
lab=vdd_tg}
N -2410 -1320 -2410 -1290 {
lab=vdd_delay}
N -2410 -990 -2410 -950 {
lab=vdd_sw}
N -2470 -1250 -2470 -1240 {
lab=vpre14}
N -2350 -1250 -2350 -1240 {
lab=vpos14}
N -2360 -1090 -2360 -1080 {
lab=vpres14}
N -2470 -910 -2460 -910 {
lab=uw}
N -2470 -880 -2460 -880 {
lab=vbias}
N -2410 -690 -2410 -680 {
lab=GND}
N -2410 -350 -2410 -340 {
lab=GND}
N -2360 -400 -2360 -390 {
lab=vpres15}
N -2470 -420 -2460 -420 {
lab=ctrl1}
N -2410 -520 -2410 -510 {
lab=GND}
N -2460 -560 -2460 -550 {
lab=vpre15}
N -2470 -600 -2470 -590 {
lab=ctrl2}
N -2470 -590 -2460 -590 {
lab=ctrl2}
N -2470 -440 -2470 -420 {
lab=ctrl1}
N -2410 -630 -2410 -600 {
lab=vdd_tg}
N -2410 -800 -2410 -770 {
lab=vdd_delay}
N -2410 -470 -2410 -430 {
lab=vdd_sw}
N -2470 -730 -2470 -720 {
lab=vpre15}
N -2350 -730 -2350 -720 {
lab=vpos15}
N -2360 -570 -2360 -560 {
lab=vpres15}
N -2470 -390 -2460 -390 {
lab=uw}
N -2470 -360 -2460 -360 {
lab=vbias}
N -2240 -3100 -2240 -3090 {
lab=GND}
N -2240 -3210 -2240 -3200 {
lab=vdd_syn0}
N -2180 -3020 -2170 -3020 {
lab=GND}
N -2180 -2990 -2180 -2980 {
lab=p0}
N -2300 -3170 -2300 -3160 {
lab=vpres10}
N -2180 -3170 -2180 -3160 {
lab=vpos10}
N -2230 -3020 -2220 -3020 {
lab=ctrl_pos}
N -2180 -3140 -2180 -3120 {
lab=#net57}
N -2180 -3060 -2180 -3050 {
lab=#net58}
N -2020 -3100 -2020 -3090 {
lab=GND}
N -2020 -3210 -2020 -3200 {
lab=vdd_syn1}
N -1960 -3020 -1950 -3020 {
lab=GND}
N -1960 -2990 -1960 -2980 {
lab=p1}
N -2080 -3170 -2080 -3160 {
lab=vpres10}
N -1960 -3170 -1960 -3160 {
lab=vpos10}
N -2010 -3020 -2000 -3020 {
lab=ctrl_pos}
N -1960 -3140 -1960 -3120 {
lab=#net59}
N -1960 -3060 -1960 -3050 {
lab=#net60}
N -2240 -2580 -2240 -2570 {
lab=GND}
N -2240 -2690 -2240 -2680 {
lab=vdd_syn0}
N -2180 -2500 -2170 -2500 {
lab=GND}
N -2180 -2470 -2180 -2460 {
lab=p0}
N -2300 -2650 -2300 -2640 {
lab=vpres11}
N -2180 -2650 -2180 -2640 {
lab=vpos11}
N -2230 -2500 -2220 -2500 {
lab=ctrl_pos}
N -2180 -2620 -2180 -2600 {
lab=#net61}
N -2180 -2540 -2180 -2530 {
lab=#net62}
N -2020 -2580 -2020 -2570 {
lab=GND}
N -2020 -2690 -2020 -2680 {
lab=vdd_syn1}
N -1960 -2500 -1950 -2500 {
lab=GND}
N -1960 -2470 -1960 -2460 {
lab=p1}
N -2080 -2650 -2080 -2640 {
lab=vpres11}
N -1960 -2650 -1960 -2640 {
lab=vpos11}
N -2010 -2500 -2000 -2500 {
lab=ctrl_pos}
N -1960 -2620 -1960 -2600 {
lab=#net63}
N -1960 -2540 -1960 -2530 {
lab=#net64}
N -2240 -2060 -2240 -2050 {
lab=GND}
N -2240 -2170 -2240 -2160 {
lab=vdd_syn0}
N -2180 -1980 -2170 -1980 {
lab=GND}
N -2180 -1950 -2180 -1940 {
lab=p0}
N -2300 -2130 -2300 -2120 {
lab=vpres12}
N -2180 -2130 -2180 -2120 {
lab=vpos12}
N -2230 -1980 -2220 -1980 {
lab=ctrl_pos}
N -2180 -2100 -2180 -2080 {
lab=#net65}
N -2180 -2020 -2180 -2010 {
lab=#net66}
N -2020 -2060 -2020 -2050 {
lab=GND}
N -2020 -2170 -2020 -2160 {
lab=vdd_syn1}
N -1960 -1980 -1950 -1980 {
lab=GND}
N -1960 -1950 -1960 -1940 {
lab=p1}
N -2080 -2130 -2080 -2120 {
lab=vpres12}
N -1960 -2130 -1960 -2120 {
lab=vpos12}
N -2010 -1980 -2000 -1980 {
lab=ctrl_pos}
N -1960 -2100 -1960 -2080 {
lab=#net67}
N -1960 -2020 -1960 -2010 {
lab=#net68}
N -2240 -1540 -2240 -1530 {
lab=GND}
N -2240 -1650 -2240 -1640 {
lab=vdd_syn0}
N -2180 -1460 -2170 -1460 {
lab=GND}
N -2180 -1430 -2180 -1420 {
lab=p0}
N -2300 -1610 -2300 -1600 {
lab=vpres13}
N -2180 -1610 -2180 -1600 {
lab=vpos13}
N -2230 -1460 -2220 -1460 {
lab=ctrl_pos}
N -2180 -1580 -2180 -1560 {
lab=#net69}
N -2180 -1500 -2180 -1490 {
lab=#net70}
N -2020 -1540 -2020 -1530 {
lab=GND}
N -2020 -1650 -2020 -1640 {
lab=vdd_syn1}
N -1960 -1460 -1950 -1460 {
lab=GND}
N -1960 -1430 -1960 -1420 {
lab=p1}
N -2080 -1610 -2080 -1600 {
lab=vpres13}
N -1960 -1610 -1960 -1600 {
lab=vpos13}
N -2010 -1460 -2000 -1460 {
lab=ctrl_pos}
N -1960 -1580 -1960 -1560 {
lab=#net71}
N -1960 -1500 -1960 -1490 {
lab=#net72}
N -2240 -1020 -2240 -1010 {
lab=GND}
N -2240 -1130 -2240 -1120 {
lab=vdd_syn0}
N -2180 -940 -2170 -940 {
lab=GND}
N -2180 -910 -2180 -900 {
lab=p0}
N -2300 -1090 -2300 -1080 {
lab=vpres14}
N -2180 -1090 -2180 -1080 {
lab=vpos14}
N -2230 -940 -2220 -940 {
lab=ctrl_pos}
N -2180 -1060 -2180 -1040 {
lab=#net73}
N -2180 -980 -2180 -970 {
lab=#net74}
N -2020 -1020 -2020 -1010 {
lab=GND}
N -2020 -1130 -2020 -1120 {
lab=vdd_syn1}
N -1960 -940 -1950 -940 {
lab=GND}
N -1960 -910 -1960 -900 {
lab=p1}
N -2080 -1090 -2080 -1080 {
lab=vpres14}
N -1960 -1090 -1960 -1080 {
lab=vpos14}
N -2010 -940 -2000 -940 {
lab=ctrl_pos}
N -1960 -1060 -1960 -1040 {
lab=#net75}
N -1960 -980 -1960 -970 {
lab=#net76}
N -2240 -500 -2240 -490 {
lab=GND}
N -2240 -610 -2240 -600 {
lab=vdd_syn0}
N -2180 -420 -2170 -420 {
lab=GND}
N -2180 -390 -2180 -380 {
lab=p0}
N -2300 -570 -2300 -560 {
lab=vpres15}
N -2180 -570 -2180 -560 {
lab=vpos15}
N -2230 -420 -2220 -420 {
lab=ctrl_pos}
N -2180 -540 -2180 -520 {
lab=#net77}
N -2180 -460 -2180 -450 {
lab=#net78}
N -2020 -500 -2020 -490 {
lab=GND}
N -2020 -610 -2020 -600 {
lab=vdd_syn1}
N -1960 -420 -1950 -420 {
lab=GND}
N -1960 -390 -1960 -380 {
lab=p1}
N -2080 -570 -2080 -560 {
lab=vpres15}
N -1960 -570 -1960 -560 {
lab=vpos15}
N -2010 -420 -2000 -420 {
lab=ctrl_pos}
N -1960 -540 -1960 -520 {
lab=#net79}
N -1960 -460 -1960 -450 {
lab=#net80}
N -2660 -3090 -2660 -3070 {
lab=GND}
N -2660 -3250 -2660 -3230 {
lab=vdd_pre}
N -3040 -3080 -3040 -3060 {
lab=GND}
N -2840 -3180 -2840 -3160 {
lab=vc10}
N -2840 -3210 -2830 -3210 {
lab=vdd_in}
N -2830 -3240 -2830 -3210 {
lab=vdd_in}
N -2840 -3240 -2830 -3240 {
lab=vdd_in}
N -2920 -3210 -2880 -3210 {
lab=#net81}
N -2960 -3240 -2840 -3240 {
lab=vdd_in}
N -2970 -3210 -2960 -3210 {
lab=vdd_in}
N -2970 -3240 -2970 -3210 {
lab=vdd_in}
N -2970 -3240 -2960 -3240 {
lab=vdd_in}
N -2960 -3180 -2960 -3160 {
lab=#net81}
N -2960 -3160 -2900 -3160 {
lab=#net81}
N -2900 -3210 -2900 -3160 {
lab=#net81}
N -3040 -3160 -3040 -3140 {
lab=#net82}
N -2520 -3160 -2510 -3160 {
lab=vpre10}
N -2980 -3160 -2960 -3160 {
lab=#net81}
N -2760 -3200 -2750 -3200 {
lab=vlky}
N -2840 -3160 -2760 -3160 {
lab=vc10}
N -2760 -3120 -2750 -3120 {
lab=vb_pre}
N -2660 -2050 -2660 -2030 {
lab=GND}
N -2660 -2210 -2660 -2190 {
lab=vdd_pre}
N -3040 -2040 -3040 -2020 {
lab=GND}
N -2840 -2140 -2840 -2120 {
lab=vc12}
N -2840 -2170 -2830 -2170 {
lab=vdd_in}
N -2830 -2200 -2830 -2170 {
lab=vdd_in}
N -2840 -2200 -2830 -2200 {
lab=vdd_in}
N -2920 -2170 -2880 -2170 {
lab=#net83}
N -2960 -2200 -2840 -2200 {
lab=vdd_in}
N -2970 -2170 -2960 -2170 {
lab=vdd_in}
N -2970 -2200 -2970 -2170 {
lab=vdd_in}
N -2970 -2200 -2960 -2200 {
lab=vdd_in}
N -2960 -2140 -2960 -2120 {
lab=#net83}
N -2960 -2120 -2900 -2120 {
lab=#net83}
N -2900 -2170 -2900 -2120 {
lab=#net83}
N -3040 -2120 -3040 -2100 {
lab=#net84}
N -2520 -2120 -2510 -2120 {
lab=vpre12}
N -2980 -2120 -2960 -2120 {
lab=#net83}
N -2660 -2570 -2660 -2550 {
lab=GND}
N -2660 -2730 -2660 -2710 {
lab=vdd_pre}
N -3040 -2560 -3040 -2540 {
lab=GND}
N -2840 -2660 -2840 -2640 {
lab=vc11}
N -2840 -2690 -2830 -2690 {
lab=vdd_in}
N -2830 -2720 -2830 -2690 {
lab=vdd_in}
N -2840 -2720 -2830 -2720 {
lab=vdd_in}
N -2920 -2690 -2880 -2690 {
lab=#net85}
N -2960 -2720 -2840 -2720 {
lab=vdd_in}
N -2970 -2690 -2960 -2690 {
lab=vdd_in}
N -2970 -2720 -2970 -2690 {
lab=vdd_in}
N -2970 -2720 -2960 -2720 {
lab=vdd_in}
N -2960 -2660 -2960 -2640 {
lab=#net85}
N -2960 -2640 -2900 -2640 {
lab=#net85}
N -2900 -2690 -2900 -2640 {
lab=#net85}
N -3040 -2640 -3040 -2620 {
lab=#net86}
N -2520 -2640 -2510 -2640 {
lab=vpre11}
N -2980 -2640 -2960 -2640 {
lab=#net85}
N -2840 -2640 -2760 -2640 {
lab=vc11}
N -2760 -2680 -2750 -2680 {
lab=vlky}
N -2760 -2600 -2750 -2600 {
lab=vb_pre}
N -2760 -2160 -2750 -2160 {
lab=vlky}
N -2840 -2120 -2760 -2120 {
lab=vc12}
N -2760 -2080 -2750 -2080 {
lab=vb_pre}
N -2660 -1010 -2660 -990 {
lab=GND}
N -2660 -1170 -2660 -1150 {
lab=vdd_pre}
N -3040 -1000 -3040 -980 {
lab=GND}
N -2840 -1100 -2840 -1080 {
lab=vc14}
N -2840 -1130 -2830 -1130 {
lab=vdd_in}
N -2830 -1160 -2830 -1130 {
lab=vdd_in}
N -2840 -1160 -2830 -1160 {
lab=vdd_in}
N -2920 -1130 -2880 -1130 {
lab=#net87}
N -2960 -1160 -2840 -1160 {
lab=vdd_in}
N -2970 -1130 -2960 -1130 {
lab=vdd_in}
N -2970 -1160 -2970 -1130 {
lab=vdd_in}
N -2970 -1160 -2960 -1160 {
lab=vdd_in}
N -2960 -1100 -2960 -1080 {
lab=#net87}
N -2960 -1080 -2900 -1080 {
lab=#net87}
N -2900 -1130 -2900 -1080 {
lab=#net87}
N -3040 -1080 -3040 -1060 {
lab=#net88}
N -2520 -1080 -2510 -1080 {
lab=vpre14}
N -2980 -1080 -2960 -1080 {
lab=#net87}
N -2660 -1530 -2660 -1510 {
lab=GND}
N -2660 -1690 -2660 -1670 {
lab=vdd_pre}
N -3040 -1520 -3040 -1500 {
lab=GND}
N -2840 -1620 -2840 -1600 {
lab=vc13}
N -2840 -1650 -2830 -1650 {
lab=vdd_in}
N -2830 -1680 -2830 -1650 {
lab=vdd_in}
N -2840 -1680 -2830 -1680 {
lab=vdd_in}
N -2920 -1650 -2880 -1650 {
lab=#net89}
N -2960 -1680 -2840 -1680 {
lab=vdd_in}
N -2970 -1650 -2960 -1650 {
lab=vdd_in}
N -2970 -1680 -2970 -1650 {
lab=vdd_in}
N -2970 -1680 -2960 -1680 {
lab=vdd_in}
N -2960 -1620 -2960 -1600 {
lab=#net89}
N -2960 -1600 -2900 -1600 {
lab=#net89}
N -2900 -1650 -2900 -1600 {
lab=#net89}
N -3040 -1600 -3040 -1580 {
lab=#net90}
N -2520 -1600 -2510 -1600 {
lab=vpre13}
N -2980 -1600 -2960 -1600 {
lab=#net89}
N -2840 -1600 -2760 -1600 {
lab=vc13}
N -2760 -1640 -2750 -1640 {
lab=vlky}
N -2760 -1560 -2750 -1560 {
lab=vb_pre}
N -2760 -1120 -2750 -1120 {
lab=vlky}
N -2840 -1080 -2760 -1080 {
lab=vc14}
N -2760 -1040 -2750 -1040 {
lab=vb_pre}
N -2660 -490 -2660 -470 {
lab=GND}
N -2660 -650 -2660 -630 {
lab=vdd_pre}
N -3040 -480 -3040 -460 {
lab=GND}
N -2840 -580 -2840 -560 {
lab=vc15}
N -2840 -610 -2830 -610 {
lab=vdd_in}
N -2830 -640 -2830 -610 {
lab=vdd_in}
N -2840 -640 -2830 -640 {
lab=vdd_in}
N -2920 -610 -2880 -610 {
lab=#net91}
N -2960 -640 -2840 -640 {
lab=vdd_in}
N -2970 -610 -2960 -610 {
lab=vdd_in}
N -2970 -640 -2970 -610 {
lab=vdd_in}
N -2970 -640 -2960 -640 {
lab=vdd_in}
N -2960 -580 -2960 -560 {
lab=#net91}
N -2960 -560 -2900 -560 {
lab=#net91}
N -2900 -610 -2900 -560 {
lab=#net91}
N -3040 -560 -3040 -540 {
lab=#net92}
N -2520 -560 -2510 -560 {
lab=vpre15}
N -2980 -560 -2960 -560 {
lab=#net91}
N -2760 -600 -2750 -600 {
lab=vlky}
N -2840 -560 -2760 -560 {
lab=vc15}
N -2760 -520 -2750 -520 {
lab=vb_pre}
C {devices/vsource.sym} -1500 -3300 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1500 -3250 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1420 -3300 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1420 -3250 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1420 -3350 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2660 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2760 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -1410 -2480 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1530 -2480 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1280 -2480 0 0 {name=NGSPICE1
only_toplevel=true
value="
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param Lp_delay=3.5
.param Wp_delay=0.45
.param Ln_delay=3.5
.param Wn_delay=0.45
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 1n 240u
  write SNN_15x2_tb.raw
.endc
" }
C {devices/launcher.sym} -1520 -1635 0 0 {name=h1
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x2_tb.raw tran"
}
C {devices/lab_pin.sym} -2840 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} -1240 -3300 0 0 {name=V4 value="PWL(0 1.8 204.9u 1.8 205u 0)"}
C {devices/gnd.sym} -1240 -3250 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1240 -3350 2 0 {name=p16 sig_type=std_logic lab=vdd_delay}
C {devices/gnd.sym} -2240 -7770 0 0 {name=l39 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -7370 0 0 {name=x2021}
C {devices/lab_pin.sym} -2300 -7850 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2180 -7850 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -2410 -7440 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2350 -7480 3 0 {name=p28 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2470 -7480 3 0 {name=p33 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -2180 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -2180 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2470 -7150 0 0 {name=p53 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2220 -250 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2250 -130 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -2180 -290 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -2180 -330 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2180 0 2 0 {name=p61 sig_type=std_logic lab=N0}
C {devices/vsource.sym} -1500 -2880 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1500 -2830 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1500 -2930 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1500 -2740 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 199.9u 1.8 200u 0)"}
C {devices/gnd.sym} -1500 -2690 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1500 -2790 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} -1500 -2600 0 0 {name=V15 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1500 -2550 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1500 -2650 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -3010 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/lab_pin.sym} -2470 -7200 2 0 {name=p74 sig_type=std_logic lab=ctrl1}
C {devices/vsource.sym} -1500 -3020 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1500 -2970 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1500 -3070 2 0 {name=p75 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -7100 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2470 -7360 2 0 {name=p14 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -7270 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} -1320 -3020 0 0 {name=V12 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1320 -2970 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1320 -3070 2 0 {name=p17 sig_type=std_logic lab=ctrl2}
C {devices/vsource.sym} -1340 -3160 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1340 -3110 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1340 -3210 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -1330 -3300 0 0 {name=V3 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1330 -3250 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1330 -3350 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1130 -3300 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1130 -3250 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1130 -3350 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1050 -3300 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1050 -3250 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1050 -3350 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1500 -3160 0 0 {name=V7 value=0.5}
C {devices/gnd.sym} -1500 -3110 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1500 -3210 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1420 -3160 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1420 -3110 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1420 -3210 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2660 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2110 -130 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2020 -7890 1 0 {name=p15 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2410 -7560 0 0 {name=p18 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -7230 0 0 {name=p19 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -7390 0 0 {name=p20 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -1500 -3350 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2900 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2760 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -7790 0 0 {name=I1 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -2240 -7250 0 0 {name=l15 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -7890 0 0 {name=x2011}
C {devices/lab_pin.sym} -2300 -7330 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2180 -7330 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2410 -7960 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -2350 -8000 3 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2470 -8000 3 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2180 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -2180 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2360 -7680 1 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2470 -7670 0 0 {name=p36 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2510 -7840 3 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3010 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/lab_pin.sym} -2470 -7720 2 0 {name=p38 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -7620 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2360 -7850 1 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2460 -7830 3 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2470 -7880 2 0 {name=p42 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2660 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -7370 1 0 {name=p44 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2410 -8080 0 0 {name=p45 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -7910 0 0 {name=p48 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2900 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2230 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2230 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1130 -3020 0 0 {name=V16 value="PWL(0 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1130 -2970 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1130 -3070 2 0 {name=p71 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -970 -3300 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -970 -3250 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -970 -3350 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} -580 -3030 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -580 -3150 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -660 -3110 0 0 {name=p84 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -2250 -250 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} -950 -3020 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -950 -2970 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -950 -3070 2 0 {name=p88 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -510 -3090 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -570 -2940 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} -610 -2920 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -610 -2950 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -610 -2890 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -650 -2940 0 0 {name=p85 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -570 -2800 2 0 {name=p89 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} -610 -2780 3 0 {name=M201
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -610 -2810 2 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -610 -2750 2 0 {name=p90 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -650 -2800 0 0 {name=p93 sig_type=std_logic lab=vinh}
C {devices/vsource.sym} -1270 -3160 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -1270 -3110 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -1270 -3210 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2140 -250 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2000 -250 1 0 {name=p57 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2030 -130 0 0 {name=l22 lab=GND}
C {devices/ammeter.sym} -1960 -290 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -1960 -330 2 0 {name=p58 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -1960 0 2 0 {name=p62 sig_type=std_logic lab=N1}
C {devices/lab_pin.sym} -1890 -130 3 0 {name=p86 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2030 -250 1 0 {name=p98 sig_type=std_logic lab=inh1}
C {devices/lab_pin.sym} -1920 -250 1 0 {name=p99 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -1500 -3440 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1500 -3390 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -1500 -3490 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/vsource.sym} -1400 -3440 0 0 {name=V20 value="PWL(0 1.8 39.9u 1.8 40u 0 119.9u 0 120u 1.8 199.9u 1.8 200u 0 204.9u 0 205u 1.8)"}
C {devices/gnd.sym} -1400 -3390 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} -1400 -3490 2 0 {name=p51 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -7670 0 0 {name=x2013}
C {devices/lab_pin.sym} -2470 -7120 0 0 {name=p49 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -7150 0 0 {name=x2023}
C {devices/lab_pin.sym} -2470 -7640 0 0 {name=p100 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -7320 0 0 {name=x2022}
C {devices/gnd.sym} -2020 -7770 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -2080 -7850 1 0 {name=p52 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1960 -7850 1 0 {name=p54 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1960 -7770 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -7700 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -7700 3 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -1960 -7660 2 0 {name=p55 sig_type=std_logic lab=p1}
C {devices/gnd.sym} -2020 -7250 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -2080 -7330 1 0 {name=p64 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1960 -7330 1 0 {name=p67 sig_type=std_logic lab=vpos2}
C {devices/ammeter.sym} -1960 -7250 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -7180 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -7180 3 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -1960 -7140 2 0 {name=p68 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -7180 0 0 {name=p77 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2010 -7700 0 0 {name=p79 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -6850 0 0 {name=x2031}
C {devices/gnd.sym} -2410 -6920 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -2350 -6960 3 0 {name=p227 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -2470 -6960 3 0 {name=p228 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2470 -6630 0 0 {name=p230 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -6680 2 0 {name=p231 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -6580 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -2360 -6810 1 0 {name=p232 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2470 -6840 2 0 {name=p234 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -6750 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -2410 -7040 0 0 {name=p235 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -6710 0 0 {name=p236 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -6870 0 0 {name=p237 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -6600 0 0 {name=p238 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -6630 0 0 {name=x2033}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -6800 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -6330 0 0 {name=x2041}
C {devices/gnd.sym} -2410 -6400 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -2350 -6440 3 0 {name=p239 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -2360 -6120 1 0 {name=p241 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2470 -6110 0 0 {name=p242 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -6160 2 0 {name=p243 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -6060 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -2360 -6290 1 0 {name=p244 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2460 -6270 3 0 {name=p245 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2470 -6320 2 0 {name=p246 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -6230 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -2410 -6520 0 0 {name=p247 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -6190 0 0 {name=p248 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -6350 0 0 {name=p249 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -6080 0 0 {name=p250 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -6110 0 0 {name=x2043}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -6280 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -5810 0 0 {name=x2051}
C {devices/gnd.sym} -2410 -5880 0 0 {name=l90 lab=GND}
C {devices/lab_pin.sym} -2350 -5920 3 0 {name=p251 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2470 -5590 0 0 {name=p254 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -5640 2 0 {name=p255 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -5540 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} -2460 -5750 3 0 {name=p257 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2470 -5800 2 0 {name=p258 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -5710 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} -2410 -6000 0 0 {name=p259 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -5670 0 0 {name=p260 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -5830 0 0 {name=p261 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -5560 0 0 {name=p262 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -5590 0 0 {name=x2053}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -5760 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -5290 0 0 {name=x2061}
C {devices/gnd.sym} -2410 -5360 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -2350 -5400 3 0 {name=p263 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -2360 -5080 1 0 {name=p265 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2470 -5070 0 0 {name=p266 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -5120 2 0 {name=p267 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -5020 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} -2460 -5230 3 0 {name=p269 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2470 -5280 2 0 {name=p270 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -5190 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -2410 -5480 0 0 {name=p271 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -5150 0 0 {name=p272 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -5310 0 0 {name=p273 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -5040 0 0 {name=p274 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -5070 0 0 {name=x2063}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -5240 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -4770 0 0 {name=x2071}
C {devices/gnd.sym} -2410 -4840 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} -2350 -4880 3 0 {name=p275 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -2360 -4560 1 0 {name=p277 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2470 -4550 0 0 {name=p278 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -4600 2 0 {name=p279 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -4500 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} -2460 -4710 3 0 {name=p281 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2470 -4760 2 0 {name=p282 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -4670 0 0 {name=l98 lab=GND}
C {devices/lab_pin.sym} -2410 -4960 0 0 {name=p283 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -4630 0 0 {name=p284 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -4790 0 0 {name=p285 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -4520 0 0 {name=p286 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -4550 0 0 {name=x2073}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -4720 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -4250 0 0 {name=x2081}
C {devices/gnd.sym} -2410 -4320 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2350 -4360 3 0 {name=p287 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2470 -4360 3 0 {name=p288 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2360 -4040 1 0 {name=p289 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2470 -4030 0 0 {name=p290 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -4080 2 0 {name=p291 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -3980 0 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2470 -4240 2 0 {name=p294 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -4150 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -2410 -4440 0 0 {name=p295 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -4110 0 0 {name=p296 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -4270 0 0 {name=p297 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -4000 0 0 {name=p298 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -4030 0 0 {name=x2083}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -4200 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -3730 0 0 {name=x2091}
C {devices/gnd.sym} -2410 -3800 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} -2350 -3840 3 0 {name=p299 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -2470 -3840 3 0 {name=p300 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2470 -3510 0 0 {name=p302 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -3560 2 0 {name=p303 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -3460 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -2470 -3720 2 0 {name=p306 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -3630 0 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} -2410 -3920 0 0 {name=p307 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -3590 0 0 {name=p308 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -3750 0 0 {name=p309 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -3480 0 0 {name=p310 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -3510 0 0 {name=x2093}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -3680 0 0 {name=x2092}
C {devices/gnd.sym} -2240 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -2180 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -2180 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -6850 1 0 {name=p314 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -6730 0 0 {name=l107 lab=GND}
C {devices/ammeter.sym} -1960 -6730 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -6660 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -6660 3 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} -1960 -6620 2 0 {name=p318 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -6660 0 0 {name=p320 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -2300 -6290 1 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -2180 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -2180 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -6330 1 0 {name=p364 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -6210 0 0 {name=l127 lab=GND}
C {devices/ammeter.sym} -1960 -6210 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -6140 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -6140 3 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -1960 -6100 2 0 {name=p368 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -6140 0 0 {name=p370 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -2300 -5770 1 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2180 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -2180 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -5810 1 0 {name=p414 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -5690 0 0 {name=l147 lab=GND}
C {devices/ammeter.sym} -1960 -5690 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -5620 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -5620 3 0 {name=l148 lab=GND}
C {devices/lab_pin.sym} -1960 -5580 2 0 {name=p418 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -5620 0 0 {name=p420 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -2180 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -2180 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -5290 1 0 {name=p464 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -5170 0 0 {name=l167 lab=GND}
C {devices/ammeter.sym} -1960 -5170 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -5100 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -5100 3 0 {name=l168 lab=GND}
C {devices/lab_pin.sym} -1960 -5060 2 0 {name=p468 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -5100 0 0 {name=p470 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -2180 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -2180 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -4770 1 0 {name=p514 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -4650 0 0 {name=l187 lab=GND}
C {devices/ammeter.sym} -1960 -4650 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -4580 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -4580 3 0 {name=l188 lab=GND}
C {devices/lab_pin.sym} -1960 -4540 2 0 {name=p518 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -4580 0 0 {name=p520 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -2180 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -2180 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -4250 1 0 {name=p564 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -4130 0 0 {name=l207 lab=GND}
C {devices/ammeter.sym} -1960 -4130 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -4060 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -4060 3 0 {name=l208 lab=GND}
C {devices/lab_pin.sym} -1960 -4020 2 0 {name=p568 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -4060 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -2300 -3690 1 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2180 -3690 1 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -2180 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -2180 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -3730 1 0 {name=p614 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -3610 0 0 {name=l227 lab=GND}
C {devices/ammeter.sym} -1960 -3610 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -3540 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -3540 3 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -1960 -3500 2 0 {name=p618 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -3540 0 0 {name=p620 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2660 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -2760 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -6230 0 0 {name=I4 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -3010 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -2660 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -2760 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -6750 0 0 {name=I3 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -3010 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -2660 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -2760 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -5190 0 0 {name=I6 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -3010 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -2660 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -2760 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -5710 0 0 {name=I5 value=0}
C {devices/gnd.sym} -3040 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -3010 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -2660 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -2760 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -4150 0 0 {name=I8 value="PWL(0 0 119.9u 0 120u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u 214.999u 5u 215u 0 224.999u 0 225u 5u)"}
C {devices/gnd.sym} -3040 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -3010 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -2660 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -2760 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -4670 0 0 {name=I7 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -3010 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -2660 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -2760 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -3630 0 0 {name=I9 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -3010 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -2660 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -660 -3070 0 0 {name=p105 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} -2360 -7330 1 0 {name=p2 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2360 -7160 1 0 {name=p24 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2510 -7320 3 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2460 -7310 3 0 {name=p69 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2510 -6800 3 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2460 -6790 3 0 {name=p107 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2300 -6810 1 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2360 -6640 1 0 {name=p109 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2510 -3680 3 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2460 -3670 3 0 {name=p111 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2360 -3690 1 0 {name=p112 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2360 -3520 1 0 {name=p113 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2360 -4210 1 0 {name=p114 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2300 -4210 1 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2460 -4190 3 0 {name=p116 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2510 -4200 3 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2360 -4730 1 0 {name=p118 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2300 -4730 1 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2510 -4720 3 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2470 -4880 3 0 {name=p121 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2360 -5250 1 0 {name=p122 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2300 -5250 1 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2510 -5240 3 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2470 -5400 3 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2360 -5770 1 0 {name=p126 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2360 -5600 1 0 {name=p127 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2510 -5760 3 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2470 -5920 3 0 {name=p129 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2510 -6280 3 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2470 -6440 3 0 {name=p131 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1960 -3690 1 0 {name=p132 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -2080 -3690 1 0 {name=p134 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2180 -4210 1 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1960 -4210 1 0 {name=p161 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2080 -4210 1 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2180 -4730 1 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1960 -4730 1 0 {name=p166 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -2080 -4730 1 0 {name=p168 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2180 -5250 1 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1960 -5250 1 0 {name=p171 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -2080 -5250 1 0 {name=p173 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2080 -5770 1 0 {name=p175 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2180 -5770 1 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1960 -5770 1 0 {name=p178 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2180 -6290 1 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1960 -6290 1 0 {name=p181 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -2080 -6290 1 0 {name=p183 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2180 -6810 1 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -1960 -6810 1 0 {name=p186 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -2080 -6810 1 0 {name=p188 sig_type=std_logic lab=vpres3}
C {devices/vsource.sym} -1300 -3440 0 0 {name=V21 value="PWL(0 1.8 39.9u 1.8 40u 0 199.9u 0 200u 1.8 279.9u 1.8 280u 0 284.9u 0 285u 1.8)"}
C {devices/gnd.sym} -1300 -3390 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -1300 -3490 2 0 {name=p190 sig_type=std_logic lab=vdd_syn3}
C {devices/launcher.sym} -1510 -1715 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2180 -150 1 0 {name=x0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1960 -150 1 0 {name=x1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -3210 0 0 {name=x2101}
C {devices/gnd.sym} -2410 -3280 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -2350 -3320 3 0 {name=p22 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -2360 -3000 1 0 {name=p92 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2470 -2990 0 0 {name=p101 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -3040 2 0 {name=p102 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -2940 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -2470 -3200 2 0 {name=p133 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -3110 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -2410 -3400 0 0 {name=p135 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -3070 0 0 {name=p137 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -3230 0 0 {name=p144 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -2960 0 0 {name=p145 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -2990 0 0 {name=x2103}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -3160 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -2690 0 0 {name=x2111}
C {devices/gnd.sym} -2410 -2760 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -2350 -2800 3 0 {name=p146 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2470 -2470 0 0 {name=p147 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -2520 2 0 {name=p148 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -2420 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -2470 -2680 2 0 {name=p150 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -2590 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -2410 -2880 0 0 {name=p151 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -2550 0 0 {name=p152 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -2710 0 0 {name=p153 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -2440 0 0 {name=p154 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -2470 0 0 {name=x2113}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -2640 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -2170 0 0 {name=x2121}
C {devices/gnd.sym} -2410 -2240 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -2350 -2280 3 0 {name=p155 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -2360 -1960 1 0 {name=p156 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2470 -1950 0 0 {name=p157 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -2000 2 0 {name=p158 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -1900 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -2470 -2160 2 0 {name=p162 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -2070 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -2410 -2360 0 0 {name=p164 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -2030 0 0 {name=p167 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -2190 0 0 {name=p169 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -1920 0 0 {name=p172 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -1950 0 0 {name=x2123}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -2120 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -1650 0 0 {name=x2131}
C {devices/gnd.sym} -2410 -1720 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -2350 -1760 3 0 {name=p174 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -2470 -1430 0 0 {name=p179 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -1480 2 0 {name=p182 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -1380 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -2470 -1640 2 0 {name=p187 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -1550 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -2410 -1840 0 0 {name=p189 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -1510 0 0 {name=p194 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -1670 0 0 {name=p195 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -1400 0 0 {name=p196 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -1430 0 0 {name=x2133}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -1600 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -1130 0 0 {name=x2141}
C {devices/gnd.sym} -2410 -1200 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -2350 -1240 3 0 {name=p197 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -2360 -920 1 0 {name=p199 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2470 -910 0 0 {name=p200 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -960 2 0 {name=p201 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -860 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -2470 -1120 2 0 {name=p202 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -1030 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -2410 -1320 0 0 {name=p203 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -990 0 0 {name=p204 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -1150 0 0 {name=p205 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -880 0 0 {name=p206 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -910 0 0 {name=x2143}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -1080 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -2230 -610 0 0 {name=x2151}
C {devices/gnd.sym} -2410 -680 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -2350 -720 3 0 {name=p207 sig_type=std_logic lab=vpos15}
C {devices/lab_pin.sym} -2470 -390 0 0 {name=p209 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2470 -440 2 0 {name=p210 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -2410 -340 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -2470 -600 2 0 {name=p211 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -2410 -510 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -2410 -800 0 0 {name=p212 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -2410 -470 0 0 {name=p213 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -2410 -630 0 0 {name=p214 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2470 -360 0 0 {name=p215 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -2410 -390 0 0 {name=x2153}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -2410 -560 0 0 {name=x2152}
C {devices/gnd.sym} -2240 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -2180 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -2180 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -3210 1 0 {name=p218 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -3090 0 0 {name=l60 lab=GND}
C {devices/ammeter.sym} -1960 -3090 0 0 {name=Vmeas101 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -3020 0 0 {name=M101
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -3020 3 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -1960 -2980 2 0 {name=p220 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -3020 0 0 {name=p221 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -2180 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -2180 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -2690 1 0 {name=p224 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -2570 0 0 {name=l65 lab=GND}
C {devices/ammeter.sym} -1960 -2570 0 0 {name=Vmeas111 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -2500 0 0 {name=M111
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -2500 3 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -1960 -2460 2 0 {name=p226 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -2500 0 0 {name=p229 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -2180 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -2180 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -2170 1 0 {name=p240 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -2050 0 0 {name=l73 lab=GND}
C {devices/ammeter.sym} -1960 -2050 0 0 {name=Vmeas121 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -1980 0 0 {name=M121
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -1980 3 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -1960 -1940 2 0 {name=p253 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -1980 0 0 {name=p256 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -2180 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -2180 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -1650 1 0 {name=p268 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -1530 0 0 {name=l78 lab=GND}
C {devices/ammeter.sym} -1960 -1530 0 0 {name=Vmeas131 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -1460 0 0 {name=M131
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -1460 3 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -1960 -1420 2 0 {name=p280 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -1460 0 0 {name=p292 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -2180 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -2180 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2020 -1130 1 0 {name=p301 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -2230 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -1010 0 0 {name=l82 lab=GND}
C {devices/ammeter.sym} -1960 -1010 0 0 {name=Vmeas141 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -940 0 0 {name=M141
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -940 3 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -1960 -900 2 0 {name=p305 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -940 0 0 {name=p311 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2240 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -2180 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2200 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2170 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -2180 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2240 -610 1 0 {name=p319 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2230 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2020 -490 0 0 {name=l111 lab=GND}
C {devices/ammeter.sym} -1960 -490 0 0 {name=Vmeas151 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1980 -420 0 0 {name=M151
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1950 -420 3 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} -1960 -380 2 0 {name=p322 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2010 -420 0 0 {name=p323 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2660 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -2760 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -3110 0 0 {name=I10 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -3010 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -2660 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -2760 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -2070 0 0 {name=I12 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -3010 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -2660 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -2760 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -2590 0 0 {name=I11 value=0}
C {devices/gnd.sym} -3040 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -3010 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -2660 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -2760 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -3010 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -2660 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2660 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -2760 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -1550 0 0 {name=I13 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -3010 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -2660 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2760 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2660 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -2760 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -3040 -510 0 0 {name=I15 value="PWL(0 0 39.9u 0 40u 5u 199.9u 5u 200u 0 204.999u 0 205u 5u)"}
C {devices/gnd.sym} -3040 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2860 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2940 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2840 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -3010 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -2660 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2900 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2760 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2510 -560 3 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2360 -570 1 0 {name=p356 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2360 -400 1 0 {name=p357 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2510 -1080 3 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2360 -1610 1 0 {name=p366 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2510 -1600 3 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2470 -2280 3 0 {name=p375 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2360 -2480 1 0 {name=p377 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2510 -2640 3 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2510 -3160 3 0 {name=p380 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2020 -610 1 0 {name=p384 sig_type=std_logic lab=vdd_syn1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2660 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -2460 -550 3 0 {name=p208 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2470 -720 3 0 {name=p355 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2300 -570 1 0 {name=p312 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2080 -570 1 0 {name=p383 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2180 -570 1 0 {name=p405 sig_type=std_logic lab=vpos15}
C {devices/lab_pin.sym} -1960 -570 1 0 {name=p316 sig_type=std_logic lab=vpos15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -7660 0 0 {name=x11}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -7140 0 0 {name=x21}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -6620 0 0 {name=x31}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -6100 0 0 {name=x41}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -5580 0 0 {name=x51}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -5060 0 0 {name=x61}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -4540 0 0 {name=x71}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -4020 0 0 {name=x81}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -3500 0 0 {name=x91}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -2980 0 0 {name=x101}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -2460 0 0 {name=x111}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -1940 0 0 {name=x121}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -1420 0 0 {name=x131}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -900 0 0 {name=x141}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2180 -380 0 0 {name=x150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1960 -380 0 0 {name=x151}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -580 -3090 0 0 {name=x2}
C {devices/lab_pin.sym} -2460 -1070 3 0 {name=p83 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2470 -1240 3 0 {name=p198 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2360 -1090 1 0 {name=p358 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2300 -1090 1 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2080 -1090 1 0 {name=p360 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2180 -1090 1 0 {name=p382 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -1960 -1090 1 0 {name=p390 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -2460 -1590 3 0 {name=p184 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2470 -1760 3 0 {name=p371 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2360 -1440 1 0 {name=p176 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2300 -1610 1 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2080 -1610 1 0 {name=p391 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2180 -1610 1 0 {name=p392 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -1960 -1610 1 0 {name=p393 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -2460 -3150 3 0 {name=p104 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2470 -3320 3 0 {name=p381 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2180 -3170 1 0 {name=p394 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -1960 -3170 1 0 {name=p395 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -2360 -3170 1 0 {name=p103 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2300 -3170 1 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2080 -3170 1 0 {name=p402 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2460 -2630 3 0 {name=p149 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2470 -2800 3 0 {name=p379 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2360 -2650 1 0 {name=p222 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2300 -2650 1 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2080 -2650 1 0 {name=p399 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2180 -2650 1 0 {name=p400 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -1960 -2650 1 0 {name=p401 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2510 -2120 3 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2460 -2110 3 0 {name=p374 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2360 -2130 1 0 {name=p372 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2300 -2130 1 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2080 -2130 1 0 {name=p398 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2180 -2130 1 0 {name=p396 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -1960 -2130 1 0 {name=p397 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -2240 -7890 1 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -7370 1 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -6850 1 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -6330 1 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -5810 1 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -5290 1 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -4770 1 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -4250 1 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -3730 1 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -3210 1 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -2690 1 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -2170 1 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -1650 1 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2240 -1130 1 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
