v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1600 -1200 -800 -800 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 -800 -400 0 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 -1600 -400 -800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="17 18 19"
node="\\"Syn1;vdd_syn1\\"
\\"Syn2;vdd_syn2\\"
\\"Syn3;vdd_syn3\\""}
B 2 0 -2400 800 -2000 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=0.14
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=8}
B 2 -800 -1600 0 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 -1600 -800 -800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -800 -800 0 -400 {flags=graph
y1=-2.1e-08
y2=6.6e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 800 -2400 1600 -2000 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16"
node="p0
p1"}
B 2 0 -2000 800 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 0 -1600 800 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 0 -1200 800 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 800 -2000 1600 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 800 -1200 1600 -800 {flags=graph
y1=0.41
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 0 -800 800 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 0 -400 800 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 800 -800 1600 -400 {flags=graph
y1=-0.23
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 800 -400 1600 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 -800 -1200 0 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000128749
x2=0.00013978
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
N -1580 -2520 -1580 -2500 {
lab=GND}
N -1580 -2600 -1580 -2580 {
lab=vdd_in}
N -1500 -2520 -1500 -2500 {
lab=GND}
N -1500 -2600 -1500 -2580 {
lab=vdd_pre}
N -2220 -7250 -2220 -7230 {
lab=GND}
N -2220 -7410 -2220 -7390 {
lab=vdd_pre}
N -2600 -7240 -2600 -7220 {
lab=GND}
N -2400 -7340 -2400 -7320 {
lab=vc2}
N -2400 -7370 -2390 -7370 {
lab=vdd_in}
N -2390 -7400 -2390 -7370 {
lab=vdd_in}
N -2400 -7400 -2390 -7400 {
lab=vdd_in}
N -2480 -7370 -2440 -7370 {
lab=#net1}
N -2520 -7400 -2400 -7400 {
lab=vdd_in}
N -2530 -7370 -2520 -7370 {
lab=vdd_in}
N -2530 -7400 -2530 -7370 {
lab=vdd_in}
N -2530 -7400 -2520 -7400 {
lab=vdd_in}
N -2520 -7340 -2520 -7320 {
lab=#net1}
N -2520 -7320 -2460 -7320 {
lab=#net1}
N -2460 -7370 -2460 -7320 {
lab=#net1}
N -2600 -7320 -2600 -7300 {
lab=#net2}
N -1320 -2520 -1320 -2500 {
lab=GND}
N -1320 -2600 -1320 -2580 {
lab=vdd_delay}
N -1800 -7780 -1800 -7770 {
lab=GND}
N -1800 -7890 -1800 -7880 {
lab=vdd_syn0}
N -1970 -7450 -1970 -7440 {
lab=GND}
N -1740 -7700 -1730 -7700 {
lab=GND}
N -1740 -7670 -1740 -7660 {
lab=p0}
N -1740 -260 -1740 -250 {
lab=#net3}
N -1740 -330 -1740 -320 {
lab=p0}
N -1740 -10 -1740 0 {
lab=8}
N -1580 -2100 -1580 -2080 {
lab=GND}
N -1580 -2180 -1580 -2160 {
lab=uw}
N -1400 -2100 -1400 -2080 {
lab=GND}
N -1400 -2180 -1400 -2160 {
lab=training}
N -2080 -7320 -2070 -7320 {
lab=vpre2}
N -1810 -150 -1810 -130 {
lab=GND}
N -1670 -150 -1670 -130 {
lab=vdd_pos}
N -1140 -2100 -1140 -2080 {
lab=GND}
N -1140 -2180 -1140 -2160 {
lab=inference}
N -2540 -7320 -2520 -7320 {
lab=#net1}
N -1580 -2240 -1580 -2220 {
lab=GND}
N -1580 -2320 -1580 -2300 {
lab=ctrl1}
N -1970 -7110 -1970 -7100 {
lab=GND}
N -1920 -7160 -1920 -7150 {
lab=vpres2}
N -2030 -7180 -2020 -7180 {
lab=ctrl1}
N -1970 -7280 -1970 -7270 {
lab=GND}
N -2020 -7320 -2020 -7310 {
lab=vpre2}
N -2030 -7360 -2030 -7350 {
lab=ctrl2}
N -2030 -7350 -2020 -7350 {
lab=ctrl2}
N -1400 -2240 -1400 -2220 {
lab=GND}
N -1400 -2320 -1400 -2300 {
lab=ctrl2}
N -2030 -7200 -2030 -7180 {
lab=ctrl1}
N -1420 -2380 -1420 -2360 {
lab=GND}
N -1420 -2460 -1420 -2440 {
lab=vbias}
N -1410 -2520 -1410 -2500 {
lab=GND}
N -1410 -2600 -1410 -2580 {
lab=vdd_pos}
N -1210 -2520 -1210 -2500 {
lab=GND}
N -1210 -2600 -1210 -2580 {
lab=vdd_sw}
N -1130 -2520 -1130 -2500 {
lab=GND}
N -1130 -2600 -1130 -2580 {
lab=vdd_tg}
N -1580 -2380 -1580 -2360 {
lab=GND}
N -1580 -2460 -1580 -2440 {
lab=vb_pre}
N -1500 -2380 -1500 -2360 {
lab=GND}
N -1500 -2460 -1500 -2440 {
lab=vb_pos}
N -1970 -7390 -1970 -7360 {
lab=vdd_tg}
N -1970 -7560 -1970 -7530 {
lab=vdd_delay}
N -1970 -7230 -1970 -7190 {
lab=vdd_sw}
N -2030 -7490 -2030 -7480 {
lab=vpre2}
N -1910 -7490 -1910 -7480 {
lab=vpos2}
N -1920 -7330 -1920 -7320 {
lab=vpres2}
N -1860 -7850 -1860 -7840 {
lab=vpres1}
N -1740 -7850 -1740 -7840 {
lab=vpos1}
N -2030 -7150 -2020 -7150 {
lab=uw}
N -2220 -7770 -2220 -7750 {
lab=GND}
N -2220 -7930 -2220 -7910 {
lab=vdd_pre}
N -2600 -7760 -2600 -7740 {
lab=GND}
N -2400 -7860 -2400 -7840 {
lab=vc1}
N -2400 -7890 -2390 -7890 {
lab=vdd_in}
N -2390 -7920 -2390 -7890 {
lab=vdd_in}
N -2400 -7920 -2390 -7920 {
lab=vdd_in}
N -2480 -7890 -2440 -7890 {
lab=#net4}
N -2520 -7920 -2400 -7920 {
lab=vdd_in}
N -2530 -7890 -2520 -7890 {
lab=vdd_in}
N -2530 -7920 -2530 -7890 {
lab=vdd_in}
N -2530 -7920 -2520 -7920 {
lab=vdd_in}
N -2520 -7860 -2520 -7840 {
lab=#net4}
N -2520 -7840 -2460 -7840 {
lab=#net4}
N -2460 -7890 -2460 -7840 {
lab=#net4}
N -2600 -7840 -2600 -7820 {
lab=#net5}
N -1800 -7260 -1800 -7250 {
lab=GND}
N -1800 -7370 -1800 -7360 {
lab=vdd_syn0}
N -1970 -7970 -1970 -7960 {
lab=GND}
N -1740 -7180 -1730 -7180 {
lab=GND}
N -1740 -7150 -1740 -7140 {
lab=p0}
N -2080 -7840 -2070 -7840 {
lab=vpre1}
N -2540 -7840 -2520 -7840 {
lab=#net4}
N -1970 -7630 -1970 -7620 {
lab=GND}
N -1920 -7680 -1920 -7670 {
lab=vpres1}
N -2030 -7700 -2020 -7700 {
lab=ctrl1}
N -1970 -7800 -1970 -7790 {
lab=GND}
N -2020 -7840 -2020 -7830 {
lab=vpre1}
N -2030 -7880 -2030 -7870 {
lab=ctrl2}
N -2030 -7870 -2020 -7870 {
lab=ctrl2}
N -2030 -7720 -2030 -7700 {
lab=ctrl1}
N -1970 -7910 -1970 -7880 {
lab=vdd_tg}
N -1970 -8080 -1970 -8050 {
lab=vdd_delay}
N -1970 -7750 -1970 -7710 {
lab=vdd_sw}
N -2030 -8010 -2030 -8000 {
lab=vpre1}
N -1910 -8010 -1910 -8000 {
lab=vpos1}
N -1920 -7850 -1920 -7840 {
lab=vpres1}
N -1860 -7330 -1860 -7320 {
lab=vpres2}
N -1740 -7330 -1740 -7320 {
lab=vpos2}
N -2030 -7670 -2020 -7670 {
lab=uw}
N -1790 -7180 -1780 -7180 {
lab=ctrl_pos}
N -1790 -7700 -1780 -7700 {
lab=ctrl_pos}
N -1210 -2240 -1210 -2220 {
lab=GND}
N -1210 -2320 -1210 -2300 {
lab=ctrl_pos}
N -1050 -2520 -1050 -2500 {
lab=GND}
N -1050 -2600 -1050 -2580 {
lab=vdd_inh}
N -940 -1850 -940 -1840 {
lab=vdd_inh}
N -1030 -2240 -1030 -2220 {
lab=GND}
N -1030 -2320 -1030 -2300 {
lab=vinh}
N -940 -1740 -940 -1730 {
lab=GND}
N -880 -1790 -870 -1790 {
lab=inh_d}
N -940 -1640 -930 -1640 {
lab=inh0}
N -970 -1650 -970 -1640 {
lab=GND}
N -970 -1600 -970 -1590 {
lab=inh_d}
N -1010 -1640 -1000 -1640 {
lab=vinh}
N -1350 -2380 -1350 -2360 {
lab=GND}
N -1350 -2460 -1350 -2440 {
lab=vlky}
N -2400 -7840 -2320 -7840 {
lab=vc1}
N -2320 -7880 -2310 -7880 {
lab=vlky}
N -2320 -7800 -2310 -7800 {
lab=vb_pre}
N -2320 -7360 -2310 -7360 {
lab=vlky}
N -2400 -7320 -2320 -7320 {
lab=vc2}
N -2320 -7280 -2310 -7280 {
lab=vb_pre}
N -1810 -250 -1810 -240 {
lab=inh0}
N -1780 -250 -1780 -240 {
lab=vb_pos}
N -1700 -250 -1700 -240 {
lab=vlky}
N -1580 -2660 -1580 -2640 {
lab=GND}
N -1580 -2740 -1580 -2720 {
lab=vdd_syn0}
N -2030 -7640 -2020 -7640 {
lab=vbias}
N -2030 -7120 -2020 -7120 {
lab=vbias}
N -1740 -7820 -1740 -7800 {
lab=#net6}
N -1740 -7740 -1740 -7730 {
lab=#net7}
N -1740 -7300 -1740 -7280 {
lab=#net8}
N -1740 -7220 -1740 -7210 {
lab=#net9}
N -1970 -6930 -1970 -6920 {
lab=GND}
N -1970 -6590 -1970 -6580 {
lab=GND}
N -1920 -6640 -1920 -6630 {
lab=vpres3}
N -2030 -6660 -2020 -6660 {
lab=ctrl1}
N -1970 -6760 -1970 -6750 {
lab=GND}
N -2020 -6800 -2020 -6790 {
lab=vpre3}
N -2030 -6840 -2030 -6830 {
lab=ctrl2}
N -2030 -6830 -2020 -6830 {
lab=ctrl2}
N -2030 -6680 -2030 -6660 {
lab=ctrl1}
N -1970 -6870 -1970 -6840 {
lab=vdd_tg}
N -1970 -7040 -1970 -7010 {
lab=vdd_delay}
N -1970 -6710 -1970 -6670 {
lab=vdd_sw}
N -2030 -6970 -2030 -6960 {
lab=vpre3}
N -1910 -6970 -1910 -6960 {
lab=vpos3}
N -1920 -6810 -1920 -6800 {
lab=vpres3}
N -2030 -6630 -2020 -6630 {
lab=uw}
N -2030 -6600 -2020 -6600 {
lab=vbias}
N -1970 -6410 -1970 -6400 {
lab=GND}
N -1970 -6070 -1970 -6060 {
lab=GND}
N -1920 -6120 -1920 -6110 {
lab=vpres4}
N -2030 -6140 -2020 -6140 {
lab=ctrl1}
N -1970 -6240 -1970 -6230 {
lab=GND}
N -2020 -6280 -2020 -6270 {
lab=vpre4}
N -2030 -6320 -2030 -6310 {
lab=ctrl2}
N -2030 -6310 -2020 -6310 {
lab=ctrl2}
N -2030 -6160 -2030 -6140 {
lab=ctrl1}
N -1970 -6350 -1970 -6320 {
lab=vdd_tg}
N -1970 -6520 -1970 -6490 {
lab=vdd_delay}
N -1970 -6190 -1970 -6150 {
lab=vdd_sw}
N -2030 -6450 -2030 -6440 {
lab=vpre4}
N -1910 -6450 -1910 -6440 {
lab=vpos4}
N -1920 -6290 -1920 -6280 {
lab=vpres4}
N -2030 -6110 -2020 -6110 {
lab=uw}
N -2030 -6080 -2020 -6080 {
lab=vbias}
N -1970 -5890 -1970 -5880 {
lab=GND}
N -1970 -5550 -1970 -5540 {
lab=GND}
N -1920 -5600 -1920 -5590 {
lab=vpres5}
N -2030 -5620 -2020 -5620 {
lab=ctrl1}
N -1970 -5720 -1970 -5710 {
lab=GND}
N -2020 -5760 -2020 -5750 {
lab=vpre5}
N -2030 -5800 -2030 -5790 {
lab=ctrl2}
N -2030 -5790 -2020 -5790 {
lab=ctrl2}
N -2030 -5640 -2030 -5620 {
lab=ctrl1}
N -1970 -5830 -1970 -5800 {
lab=vdd_tg}
N -1970 -6000 -1970 -5970 {
lab=vdd_delay}
N -1970 -5670 -1970 -5630 {
lab=vdd_sw}
N -2030 -5930 -2030 -5920 {
lab=vpre5}
N -1910 -5930 -1910 -5920 {
lab=vpos5}
N -1920 -5770 -1920 -5760 {
lab=vpres5}
N -2030 -5590 -2020 -5590 {
lab=uw}
N -2030 -5560 -2020 -5560 {
lab=vbias}
N -1970 -5370 -1970 -5360 {
lab=GND}
N -1970 -5030 -1970 -5020 {
lab=GND}
N -1920 -5080 -1920 -5070 {
lab=vpres6}
N -2030 -5100 -2020 -5100 {
lab=ctrl1}
N -1970 -5200 -1970 -5190 {
lab=GND}
N -2020 -5240 -2020 -5230 {
lab=vpre6}
N -2030 -5280 -2030 -5270 {
lab=ctrl2}
N -2030 -5270 -2020 -5270 {
lab=ctrl2}
N -2030 -5120 -2030 -5100 {
lab=ctrl1}
N -1970 -5310 -1970 -5280 {
lab=vdd_tg}
N -1970 -5480 -1970 -5450 {
lab=vdd_delay}
N -1970 -5150 -1970 -5110 {
lab=vdd_sw}
N -2030 -5410 -2030 -5400 {
lab=vpre6}
N -1910 -5410 -1910 -5400 {
lab=vpos6}
N -1920 -5250 -1920 -5240 {
lab=vpres6}
N -2030 -5070 -2020 -5070 {
lab=uw}
N -2030 -5040 -2020 -5040 {
lab=vbias}
N -1970 -4850 -1970 -4840 {
lab=GND}
N -1970 -4510 -1970 -4500 {
lab=GND}
N -1920 -4560 -1920 -4550 {
lab=vpres7}
N -2030 -4580 -2020 -4580 {
lab=ctrl1}
N -1970 -4680 -1970 -4670 {
lab=GND}
N -2020 -4720 -2020 -4710 {
lab=vpre7}
N -2030 -4760 -2030 -4750 {
lab=ctrl2}
N -2030 -4750 -2020 -4750 {
lab=ctrl2}
N -2030 -4600 -2030 -4580 {
lab=ctrl1}
N -1970 -4790 -1970 -4760 {
lab=vdd_tg}
N -1970 -4960 -1970 -4930 {
lab=vdd_delay}
N -1970 -4630 -1970 -4590 {
lab=vdd_sw}
N -2030 -4890 -2030 -4880 {
lab=vpre7}
N -1910 -4890 -1910 -4880 {
lab=vpos7}
N -1920 -4730 -1920 -4720 {
lab=vpres7}
N -2030 -4550 -2020 -4550 {
lab=uw}
N -2030 -4520 -2020 -4520 {
lab=vbias}
N -1970 -4330 -1970 -4320 {
lab=GND}
N -1970 -3990 -1970 -3980 {
lab=GND}
N -1920 -4040 -1920 -4030 {
lab=vpres8}
N -2030 -4060 -2020 -4060 {
lab=ctrl1}
N -1970 -4160 -1970 -4150 {
lab=GND}
N -2020 -4200 -2020 -4190 {
lab=vpre8}
N -2030 -4240 -2030 -4230 {
lab=ctrl2}
N -2030 -4230 -2020 -4230 {
lab=ctrl2}
N -2030 -4080 -2030 -4060 {
lab=ctrl1}
N -1970 -4270 -1970 -4240 {
lab=vdd_tg}
N -1970 -4440 -1970 -4410 {
lab=vdd_delay}
N -1970 -4110 -1970 -4070 {
lab=vdd_sw}
N -2030 -4370 -2030 -4360 {
lab=vpre8}
N -1910 -4370 -1910 -4360 {
lab=vpos8}
N -1920 -4210 -1920 -4200 {
lab=vpres8}
N -2030 -4030 -2020 -4030 {
lab=uw}
N -2030 -4000 -2020 -4000 {
lab=vbias}
N -1970 -3810 -1970 -3800 {
lab=GND}
N -1970 -3470 -1970 -3460 {
lab=GND}
N -1920 -3520 -1920 -3510 {
lab=vpres9}
N -2030 -3540 -2020 -3540 {
lab=ctrl1}
N -1970 -3640 -1970 -3630 {
lab=GND}
N -2020 -3680 -2020 -3670 {
lab=vpre9}
N -2030 -3720 -2030 -3710 {
lab=ctrl2}
N -2030 -3710 -2020 -3710 {
lab=ctrl2}
N -2030 -3560 -2030 -3540 {
lab=ctrl1}
N -1970 -3750 -1970 -3720 {
lab=vdd_tg}
N -1970 -3920 -1970 -3890 {
lab=vdd_delay}
N -1970 -3590 -1970 -3550 {
lab=vdd_sw}
N -2030 -3850 -2030 -3840 {
lab=vpre9}
N -1910 -3850 -1910 -3840 {
lab=vpos9}
N -1920 -3690 -1920 -3680 {
lab=vpres9}
N -2030 -3510 -2020 -3510 {
lab=uw}
N -2030 -3480 -2020 -3480 {
lab=vbias}
N -1800 -6740 -1800 -6730 {
lab=GND}
N -1800 -6850 -1800 -6840 {
lab=vdd_syn0}
N -1740 -6660 -1730 -6660 {
lab=GND}
N -1740 -6630 -1740 -6620 {
lab=p0}
N -1860 -6810 -1860 -6800 {
lab=vpres3}
N -1740 -6810 -1740 -6800 {
lab=vpos3}
N -1790 -6660 -1780 -6660 {
lab=ctrl_pos}
N -1740 -6780 -1740 -6760 {
lab=#net10}
N -1740 -6700 -1740 -6690 {
lab=#net11}
N -1800 -6220 -1800 -6210 {
lab=GND}
N -1800 -6330 -1800 -6320 {
lab=vdd_syn0}
N -1740 -6140 -1730 -6140 {
lab=GND}
N -1740 -6110 -1740 -6100 {
lab=p0}
N -1860 -6290 -1860 -6280 {
lab=vpres4}
N -1740 -6290 -1740 -6280 {
lab=vpos4}
N -1790 -6140 -1780 -6140 {
lab=ctrl_pos}
N -1740 -6260 -1740 -6240 {
lab=#net12}
N -1740 -6180 -1740 -6170 {
lab=#net13}
N -1800 -5700 -1800 -5690 {
lab=GND}
N -1800 -5810 -1800 -5800 {
lab=vdd_syn0}
N -1740 -5620 -1730 -5620 {
lab=GND}
N -1740 -5590 -1740 -5580 {
lab=p0}
N -1860 -5770 -1860 -5760 {
lab=vpres5}
N -1740 -5770 -1740 -5760 {
lab=vpos5}
N -1790 -5620 -1780 -5620 {
lab=ctrl_pos}
N -1740 -5740 -1740 -5720 {
lab=#net14}
N -1740 -5660 -1740 -5650 {
lab=#net15}
N -1800 -5180 -1800 -5170 {
lab=GND}
N -1800 -5290 -1800 -5280 {
lab=vdd_syn0}
N -1740 -5100 -1730 -5100 {
lab=GND}
N -1740 -5070 -1740 -5060 {
lab=p0}
N -1860 -5250 -1860 -5240 {
lab=vpres6}
N -1740 -5250 -1740 -5240 {
lab=vpos6}
N -1790 -5100 -1780 -5100 {
lab=ctrl_pos}
N -1740 -5220 -1740 -5200 {
lab=#net16}
N -1740 -5140 -1740 -5130 {
lab=#net17}
N -1800 -4660 -1800 -4650 {
lab=GND}
N -1800 -4770 -1800 -4760 {
lab=vdd_syn0}
N -1740 -4580 -1730 -4580 {
lab=GND}
N -1740 -4550 -1740 -4540 {
lab=p0}
N -1860 -4730 -1860 -4720 {
lab=vpres7}
N -1740 -4730 -1740 -4720 {
lab=vpos7}
N -1790 -4580 -1780 -4580 {
lab=ctrl_pos}
N -1740 -4700 -1740 -4680 {
lab=#net18}
N -1740 -4620 -1740 -4610 {
lab=#net19}
N -1800 -4140 -1800 -4130 {
lab=GND}
N -1800 -4250 -1800 -4240 {
lab=vdd_syn0}
N -1740 -4060 -1730 -4060 {
lab=GND}
N -1740 -4030 -1740 -4020 {
lab=p0}
N -1860 -4210 -1860 -4200 {
lab=vpres8}
N -1740 -4210 -1740 -4200 {
lab=vpos8}
N -1790 -4060 -1780 -4060 {
lab=ctrl_pos}
N -1740 -4180 -1740 -4160 {
lab=#net20}
N -1740 -4100 -1740 -4090 {
lab=#net21}
N -1800 -3620 -1800 -3610 {
lab=GND}
N -1800 -3730 -1800 -3720 {
lab=vdd_syn0}
N -1740 -3540 -1730 -3540 {
lab=GND}
N -1740 -3510 -1740 -3500 {
lab=p0}
N -1860 -3690 -1860 -3680 {
lab=vpres9}
N -1740 -3690 -1740 -3680 {
lab=vpos9}
N -1790 -3540 -1780 -3540 {
lab=ctrl_pos}
N -1740 -3660 -1740 -3640 {
lab=#net22}
N -1740 -3580 -1740 -3570 {
lab=#net23}
N -2220 -6210 -2220 -6190 {
lab=GND}
N -2220 -6370 -2220 -6350 {
lab=vdd_pre}
N -2600 -6200 -2600 -6180 {
lab=GND}
N -2400 -6300 -2400 -6280 {
lab=vc4}
N -2400 -6330 -2390 -6330 {
lab=vdd_in}
N -2390 -6360 -2390 -6330 {
lab=vdd_in}
N -2400 -6360 -2390 -6360 {
lab=vdd_in}
N -2480 -6330 -2440 -6330 {
lab=#net24}
N -2520 -6360 -2400 -6360 {
lab=vdd_in}
N -2530 -6330 -2520 -6330 {
lab=vdd_in}
N -2530 -6360 -2530 -6330 {
lab=vdd_in}
N -2530 -6360 -2520 -6360 {
lab=vdd_in}
N -2520 -6300 -2520 -6280 {
lab=#net24}
N -2520 -6280 -2460 -6280 {
lab=#net24}
N -2460 -6330 -2460 -6280 {
lab=#net24}
N -2600 -6280 -2600 -6260 {
lab=#net25}
N -2080 -6280 -2070 -6280 {
lab=vpre4}
N -2540 -6280 -2520 -6280 {
lab=#net24}
N -2220 -6730 -2220 -6710 {
lab=GND}
N -2220 -6890 -2220 -6870 {
lab=vdd_pre}
N -2600 -6720 -2600 -6700 {
lab=GND}
N -2400 -6820 -2400 -6800 {
lab=vc3}
N -2400 -6850 -2390 -6850 {
lab=vdd_in}
N -2390 -6880 -2390 -6850 {
lab=vdd_in}
N -2400 -6880 -2390 -6880 {
lab=vdd_in}
N -2480 -6850 -2440 -6850 {
lab=#net26}
N -2520 -6880 -2400 -6880 {
lab=vdd_in}
N -2530 -6850 -2520 -6850 {
lab=vdd_in}
N -2530 -6880 -2530 -6850 {
lab=vdd_in}
N -2530 -6880 -2520 -6880 {
lab=vdd_in}
N -2520 -6820 -2520 -6800 {
lab=#net26}
N -2520 -6800 -2460 -6800 {
lab=#net26}
N -2460 -6850 -2460 -6800 {
lab=#net26}
N -2600 -6800 -2600 -6780 {
lab=#net27}
N -2080 -6800 -2070 -6800 {
lab=vpre3}
N -2540 -6800 -2520 -6800 {
lab=#net26}
N -2400 -6800 -2320 -6800 {
lab=vc3}
N -2320 -6840 -2310 -6840 {
lab=vlky}
N -2320 -6760 -2310 -6760 {
lab=vb_pre}
N -2320 -6320 -2310 -6320 {
lab=vlky}
N -2400 -6280 -2320 -6280 {
lab=vc4}
N -2320 -6240 -2310 -6240 {
lab=vb_pre}
N -2220 -5170 -2220 -5150 {
lab=GND}
N -2220 -5330 -2220 -5310 {
lab=vdd_pre}
N -2600 -5160 -2600 -5140 {
lab=GND}
N -2400 -5260 -2400 -5240 {
lab=vc6}
N -2400 -5290 -2390 -5290 {
lab=vdd_in}
N -2390 -5320 -2390 -5290 {
lab=vdd_in}
N -2400 -5320 -2390 -5320 {
lab=vdd_in}
N -2480 -5290 -2440 -5290 {
lab=#net28}
N -2520 -5320 -2400 -5320 {
lab=vdd_in}
N -2530 -5290 -2520 -5290 {
lab=vdd_in}
N -2530 -5320 -2530 -5290 {
lab=vdd_in}
N -2530 -5320 -2520 -5320 {
lab=vdd_in}
N -2520 -5260 -2520 -5240 {
lab=#net28}
N -2520 -5240 -2460 -5240 {
lab=#net28}
N -2460 -5290 -2460 -5240 {
lab=#net28}
N -2600 -5240 -2600 -5220 {
lab=#net29}
N -2080 -5240 -2070 -5240 {
lab=vpre6}
N -2540 -5240 -2520 -5240 {
lab=#net28}
N -2220 -5690 -2220 -5670 {
lab=GND}
N -2220 -5850 -2220 -5830 {
lab=vdd_pre}
N -2600 -5680 -2600 -5660 {
lab=GND}
N -2400 -5780 -2400 -5760 {
lab=vc5}
N -2400 -5810 -2390 -5810 {
lab=vdd_in}
N -2390 -5840 -2390 -5810 {
lab=vdd_in}
N -2400 -5840 -2390 -5840 {
lab=vdd_in}
N -2480 -5810 -2440 -5810 {
lab=#net30}
N -2520 -5840 -2400 -5840 {
lab=vdd_in}
N -2530 -5810 -2520 -5810 {
lab=vdd_in}
N -2530 -5840 -2530 -5810 {
lab=vdd_in}
N -2530 -5840 -2520 -5840 {
lab=vdd_in}
N -2520 -5780 -2520 -5760 {
lab=#net30}
N -2520 -5760 -2460 -5760 {
lab=#net30}
N -2460 -5810 -2460 -5760 {
lab=#net30}
N -2600 -5760 -2600 -5740 {
lab=#net31}
N -2080 -5760 -2070 -5760 {
lab=vpre5}
N -2540 -5760 -2520 -5760 {
lab=#net30}
N -2400 -5760 -2320 -5760 {
lab=vc5}
N -2320 -5800 -2310 -5800 {
lab=vlky}
N -2320 -5720 -2310 -5720 {
lab=vb_pre}
N -2320 -5280 -2310 -5280 {
lab=vlky}
N -2400 -5240 -2320 -5240 {
lab=vc6}
N -2320 -5200 -2310 -5200 {
lab=vb_pre}
N -2220 -4130 -2220 -4110 {
lab=GND}
N -2220 -4290 -2220 -4270 {
lab=vdd_pre}
N -2600 -4120 -2600 -4100 {
lab=GND}
N -2400 -4220 -2400 -4200 {
lab=vc8}
N -2400 -4250 -2390 -4250 {
lab=vdd_in}
N -2390 -4280 -2390 -4250 {
lab=vdd_in}
N -2400 -4280 -2390 -4280 {
lab=vdd_in}
N -2480 -4250 -2440 -4250 {
lab=#net32}
N -2520 -4280 -2400 -4280 {
lab=vdd_in}
N -2530 -4250 -2520 -4250 {
lab=vdd_in}
N -2530 -4280 -2530 -4250 {
lab=vdd_in}
N -2530 -4280 -2520 -4280 {
lab=vdd_in}
N -2520 -4220 -2520 -4200 {
lab=#net32}
N -2520 -4200 -2460 -4200 {
lab=#net32}
N -2460 -4250 -2460 -4200 {
lab=#net32}
N -2600 -4200 -2600 -4180 {
lab=#net33}
N -2080 -4200 -2070 -4200 {
lab=vpre8}
N -2540 -4200 -2520 -4200 {
lab=#net32}
N -2220 -4650 -2220 -4630 {
lab=GND}
N -2220 -4810 -2220 -4790 {
lab=vdd_pre}
N -2600 -4640 -2600 -4620 {
lab=GND}
N -2400 -4740 -2400 -4720 {
lab=vc7}
N -2400 -4770 -2390 -4770 {
lab=vdd_in}
N -2390 -4800 -2390 -4770 {
lab=vdd_in}
N -2400 -4800 -2390 -4800 {
lab=vdd_in}
N -2480 -4770 -2440 -4770 {
lab=#net34}
N -2520 -4800 -2400 -4800 {
lab=vdd_in}
N -2530 -4770 -2520 -4770 {
lab=vdd_in}
N -2530 -4800 -2530 -4770 {
lab=vdd_in}
N -2530 -4800 -2520 -4800 {
lab=vdd_in}
N -2520 -4740 -2520 -4720 {
lab=#net34}
N -2520 -4720 -2460 -4720 {
lab=#net34}
N -2460 -4770 -2460 -4720 {
lab=#net34}
N -2600 -4720 -2600 -4700 {
lab=#net35}
N -2080 -4720 -2070 -4720 {
lab=vpre7}
N -2540 -4720 -2520 -4720 {
lab=#net34}
N -2400 -4720 -2320 -4720 {
lab=vc7}
N -2320 -4760 -2310 -4760 {
lab=vlky}
N -2320 -4680 -2310 -4680 {
lab=vb_pre}
N -2320 -4240 -2310 -4240 {
lab=vlky}
N -2400 -4200 -2320 -4200 {
lab=vc8}
N -2320 -4160 -2310 -4160 {
lab=vb_pre}
N -2220 -3610 -2220 -3590 {
lab=GND}
N -2220 -3770 -2220 -3750 {
lab=vdd_pre}
N -2600 -3600 -2600 -3580 {
lab=GND}
N -2400 -3700 -2400 -3680 {
lab=vc9}
N -2400 -3730 -2390 -3730 {
lab=vdd_in}
N -2390 -3760 -2390 -3730 {
lab=vdd_in}
N -2400 -3760 -2390 -3760 {
lab=vdd_in}
N -2480 -3730 -2440 -3730 {
lab=#net36}
N -2520 -3760 -2400 -3760 {
lab=vdd_in}
N -2530 -3730 -2520 -3730 {
lab=vdd_in}
N -2530 -3760 -2530 -3730 {
lab=vdd_in}
N -2530 -3760 -2520 -3760 {
lab=vdd_in}
N -2520 -3700 -2520 -3680 {
lab=#net36}
N -2520 -3680 -2460 -3680 {
lab=#net36}
N -2460 -3730 -2460 -3680 {
lab=#net36}
N -2600 -3680 -2600 -3660 {
lab=#net37}
N -2080 -3680 -2070 -3680 {
lab=vpre9}
N -2540 -3680 -2520 -3680 {
lab=#net36}
N -2320 -3720 -2310 -3720 {
lab=vlky}
N -2400 -3680 -2320 -3680 {
lab=vc9}
N -2320 -3640 -2310 -3640 {
lab=vb_pre}
N -1020 -1770 -1010 -1770 {
lab=8}
N -1970 -3290 -1970 -3280 {
lab=GND}
N -1970 -2950 -1970 -2940 {
lab=GND}
N -1920 -3000 -1920 -2990 {
lab=vpres10}
N -2030 -3020 -2020 -3020 {
lab=ctrl1}
N -1970 -3120 -1970 -3110 {
lab=GND}
N -2020 -3160 -2020 -3150 {
lab=vpre10}
N -2030 -3200 -2030 -3190 {
lab=ctrl2}
N -2030 -3190 -2020 -3190 {
lab=ctrl2}
N -2030 -3040 -2030 -3020 {
lab=ctrl1}
N -1970 -3230 -1970 -3200 {
lab=vdd_tg}
N -1970 -3400 -1970 -3370 {
lab=vdd_delay}
N -1970 -3070 -1970 -3030 {
lab=vdd_sw}
N -2030 -3330 -2030 -3320 {
lab=vpre10}
N -1910 -3330 -1910 -3320 {
lab=vpos10}
N -1920 -3170 -1920 -3160 {
lab=vpres10}
N -2030 -2990 -2020 -2990 {
lab=uw}
N -2030 -2960 -2020 -2960 {
lab=vbias}
N -1970 -2770 -1970 -2760 {
lab=GND}
N -1970 -2430 -1970 -2420 {
lab=GND}
N -1920 -2480 -1920 -2470 {
lab=vpres11}
N -2030 -2500 -2020 -2500 {
lab=ctrl1}
N -1970 -2600 -1970 -2590 {
lab=GND}
N -2020 -2640 -2020 -2630 {
lab=vpre11}
N -2030 -2680 -2030 -2670 {
lab=ctrl2}
N -2030 -2670 -2020 -2670 {
lab=ctrl2}
N -2030 -2520 -2030 -2500 {
lab=ctrl1}
N -1970 -2710 -1970 -2680 {
lab=vdd_tg}
N -1970 -2880 -1970 -2850 {
lab=vdd_delay}
N -1970 -2550 -1970 -2510 {
lab=vdd_sw}
N -2030 -2810 -2030 -2800 {
lab=vpre11}
N -1910 -2810 -1910 -2800 {
lab=vpos11}
N -1920 -2650 -1920 -2640 {
lab=vpres11}
N -2030 -2470 -2020 -2470 {
lab=uw}
N -2030 -2440 -2020 -2440 {
lab=vbias}
N -1970 -2250 -1970 -2240 {
lab=GND}
N -1970 -1910 -1970 -1900 {
lab=GND}
N -1920 -1960 -1920 -1950 {
lab=vpres12}
N -2030 -1980 -2020 -1980 {
lab=ctrl1}
N -1970 -2080 -1970 -2070 {
lab=GND}
N -2020 -2120 -2020 -2110 {
lab=vpre12}
N -2030 -2160 -2030 -2150 {
lab=ctrl2}
N -2030 -2150 -2020 -2150 {
lab=ctrl2}
N -2030 -2000 -2030 -1980 {
lab=ctrl1}
N -1970 -2190 -1970 -2160 {
lab=vdd_tg}
N -1970 -2360 -1970 -2330 {
lab=vdd_delay}
N -1970 -2030 -1970 -1990 {
lab=vdd_sw}
N -2030 -2290 -2030 -2280 {
lab=vpre12}
N -1910 -2290 -1910 -2280 {
lab=vpos12}
N -1920 -2130 -1920 -2120 {
lab=vpres12}
N -2030 -1950 -2020 -1950 {
lab=uw}
N -2030 -1920 -2020 -1920 {
lab=vbias}
N -1970 -1730 -1970 -1720 {
lab=GND}
N -1970 -1390 -1970 -1380 {
lab=GND}
N -1920 -1440 -1920 -1430 {
lab=vpres13}
N -2030 -1460 -2020 -1460 {
lab=ctrl1}
N -1970 -1560 -1970 -1550 {
lab=GND}
N -2020 -1600 -2020 -1590 {
lab=vpre13}
N -2030 -1640 -2030 -1630 {
lab=ctrl2}
N -2030 -1630 -2020 -1630 {
lab=ctrl2}
N -2030 -1480 -2030 -1460 {
lab=ctrl1}
N -1970 -1670 -1970 -1640 {
lab=vdd_tg}
N -1970 -1840 -1970 -1810 {
lab=vdd_delay}
N -1970 -1510 -1970 -1470 {
lab=vdd_sw}
N -2030 -1770 -2030 -1760 {
lab=vpre13}
N -1910 -1770 -1910 -1760 {
lab=vpos13}
N -1920 -1610 -1920 -1600 {
lab=vpres13}
N -2030 -1430 -2020 -1430 {
lab=uw}
N -2030 -1400 -2020 -1400 {
lab=vbias}
N -1970 -1210 -1970 -1200 {
lab=GND}
N -1970 -870 -1970 -860 {
lab=GND}
N -1920 -920 -1920 -910 {
lab=vpres14}
N -2030 -940 -2020 -940 {
lab=ctrl1}
N -1970 -1040 -1970 -1030 {
lab=GND}
N -2020 -1080 -2020 -1070 {
lab=vpre14}
N -2030 -1120 -2030 -1110 {
lab=ctrl2}
N -2030 -1110 -2020 -1110 {
lab=ctrl2}
N -2030 -960 -2030 -940 {
lab=ctrl1}
N -1970 -1150 -1970 -1120 {
lab=vdd_tg}
N -1970 -1320 -1970 -1290 {
lab=vdd_delay}
N -1970 -990 -1970 -950 {
lab=vdd_sw}
N -2030 -1250 -2030 -1240 {
lab=vpre14}
N -1910 -1250 -1910 -1240 {
lab=vpos14}
N -1920 -1090 -1920 -1080 {
lab=vpres14}
N -2030 -910 -2020 -910 {
lab=uw}
N -2030 -880 -2020 -880 {
lab=vbias}
N -1970 -690 -1970 -680 {
lab=GND}
N -1970 -350 -1970 -340 {
lab=GND}
N -1920 -400 -1920 -390 {
lab=vpres15}
N -2030 -420 -2020 -420 {
lab=ctrl1}
N -1970 -520 -1970 -510 {
lab=GND}
N -2020 -560 -2020 -550 {
lab=vpre15}
N -2030 -600 -2030 -590 {
lab=ctrl2}
N -2030 -590 -2020 -590 {
lab=ctrl2}
N -2030 -440 -2030 -420 {
lab=ctrl1}
N -1970 -630 -1970 -600 {
lab=vdd_tg}
N -1970 -800 -1970 -770 {
lab=vdd_delay}
N -1970 -470 -1970 -430 {
lab=vdd_sw}
N -2030 -730 -2030 -720 {
lab=vpre15}
N -1910 -730 -1910 -720 {
lab=vpos15}
N -1920 -570 -1920 -560 {
lab=vpres15}
N -2030 -390 -2020 -390 {
lab=uw}
N -2030 -360 -2020 -360 {
lab=vbias}
N -1800 -3100 -1800 -3090 {
lab=GND}
N -1800 -3210 -1800 -3200 {
lab=vdd_syn0}
N -1740 -3020 -1730 -3020 {
lab=GND}
N -1740 -2990 -1740 -2980 {
lab=p0}
N -1860 -3170 -1860 -3160 {
lab=vpres10}
N -1740 -3170 -1740 -3160 {
lab=vpos10}
N -1790 -3020 -1780 -3020 {
lab=ctrl_pos}
N -1740 -3140 -1740 -3120 {
lab=#net38}
N -1740 -3060 -1740 -3050 {
lab=#net39}
N -1800 -2580 -1800 -2570 {
lab=GND}
N -1800 -2690 -1800 -2680 {
lab=vdd_syn0}
N -1740 -2500 -1730 -2500 {
lab=GND}
N -1740 -2470 -1740 -2460 {
lab=p0}
N -1860 -2650 -1860 -2640 {
lab=vpres11}
N -1740 -2650 -1740 -2640 {
lab=vpos11}
N -1790 -2500 -1780 -2500 {
lab=ctrl_pos}
N -1740 -2620 -1740 -2600 {
lab=#net40}
N -1740 -2540 -1740 -2530 {
lab=#net41}
N -1800 -2060 -1800 -2050 {
lab=GND}
N -1800 -2170 -1800 -2160 {
lab=vdd_syn0}
N -1740 -1980 -1730 -1980 {
lab=GND}
N -1740 -1950 -1740 -1940 {
lab=p0}
N -1860 -2130 -1860 -2120 {
lab=vpres12}
N -1740 -2130 -1740 -2120 {
lab=vpos12}
N -1790 -1980 -1780 -1980 {
lab=ctrl_pos}
N -1740 -2100 -1740 -2080 {
lab=#net42}
N -1740 -2020 -1740 -2010 {
lab=#net43}
N -1800 -1540 -1800 -1530 {
lab=GND}
N -1800 -1650 -1800 -1640 {
lab=vdd_syn0}
N -1740 -1460 -1730 -1460 {
lab=GND}
N -1740 -1430 -1740 -1420 {
lab=p0}
N -1860 -1610 -1860 -1600 {
lab=vpres13}
N -1740 -1610 -1740 -1600 {
lab=vpos13}
N -1790 -1460 -1780 -1460 {
lab=ctrl_pos}
N -1740 -1580 -1740 -1560 {
lab=#net44}
N -1740 -1500 -1740 -1490 {
lab=#net45}
N -1800 -1020 -1800 -1010 {
lab=GND}
N -1800 -1130 -1800 -1120 {
lab=vdd_syn0}
N -1740 -940 -1730 -940 {
lab=GND}
N -1740 -910 -1740 -900 {
lab=p0}
N -1860 -1090 -1860 -1080 {
lab=vpres14}
N -1740 -1090 -1740 -1080 {
lab=vpos14}
N -1790 -940 -1780 -940 {
lab=ctrl_pos}
N -1740 -1060 -1740 -1040 {
lab=#net46}
N -1740 -980 -1740 -970 {
lab=#net47}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn0}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p0}
N -1860 -570 -1860 -560 {
lab=vpres15}
N -1740 -570 -1740 -560 {
lab=vpos15}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net48}
N -1740 -460 -1740 -450 {
lab=#net49}
N -2220 -3090 -2220 -3070 {
lab=GND}
N -2220 -3250 -2220 -3230 {
lab=vdd_pre}
N -2600 -3080 -2600 -3060 {
lab=GND}
N -2400 -3180 -2400 -3160 {
lab=vc10}
N -2400 -3210 -2390 -3210 {
lab=vdd_in}
N -2390 -3240 -2390 -3210 {
lab=vdd_in}
N -2400 -3240 -2390 -3240 {
lab=vdd_in}
N -2480 -3210 -2440 -3210 {
lab=#net50}
N -2520 -3240 -2400 -3240 {
lab=vdd_in}
N -2530 -3210 -2520 -3210 {
lab=vdd_in}
N -2530 -3240 -2530 -3210 {
lab=vdd_in}
N -2530 -3240 -2520 -3240 {
lab=vdd_in}
N -2520 -3180 -2520 -3160 {
lab=#net50}
N -2520 -3160 -2460 -3160 {
lab=#net50}
N -2460 -3210 -2460 -3160 {
lab=#net50}
N -2600 -3160 -2600 -3140 {
lab=#net51}
N -2080 -3160 -2070 -3160 {
lab=vpre10}
N -2540 -3160 -2520 -3160 {
lab=#net50}
N -2320 -3200 -2310 -3200 {
lab=vlky}
N -2400 -3160 -2320 -3160 {
lab=vc10}
N -2320 -3120 -2310 -3120 {
lab=vb_pre}
N -2220 -2050 -2220 -2030 {
lab=GND}
N -2220 -2210 -2220 -2190 {
lab=vdd_pre}
N -2600 -2040 -2600 -2020 {
lab=GND}
N -2400 -2140 -2400 -2120 {
lab=vc12}
N -2400 -2170 -2390 -2170 {
lab=vdd_in}
N -2390 -2200 -2390 -2170 {
lab=vdd_in}
N -2400 -2200 -2390 -2200 {
lab=vdd_in}
N -2480 -2170 -2440 -2170 {
lab=#net52}
N -2520 -2200 -2400 -2200 {
lab=vdd_in}
N -2530 -2170 -2520 -2170 {
lab=vdd_in}
N -2530 -2200 -2530 -2170 {
lab=vdd_in}
N -2530 -2200 -2520 -2200 {
lab=vdd_in}
N -2520 -2140 -2520 -2120 {
lab=#net52}
N -2520 -2120 -2460 -2120 {
lab=#net52}
N -2460 -2170 -2460 -2120 {
lab=#net52}
N -2600 -2120 -2600 -2100 {
lab=#net53}
N -2080 -2120 -2070 -2120 {
lab=vpre12}
N -2540 -2120 -2520 -2120 {
lab=#net52}
N -2220 -2570 -2220 -2550 {
lab=GND}
N -2220 -2730 -2220 -2710 {
lab=vdd_pre}
N -2600 -2560 -2600 -2540 {
lab=GND}
N -2400 -2660 -2400 -2640 {
lab=vc11}
N -2400 -2690 -2390 -2690 {
lab=vdd_in}
N -2390 -2720 -2390 -2690 {
lab=vdd_in}
N -2400 -2720 -2390 -2720 {
lab=vdd_in}
N -2480 -2690 -2440 -2690 {
lab=#net54}
N -2520 -2720 -2400 -2720 {
lab=vdd_in}
N -2530 -2690 -2520 -2690 {
lab=vdd_in}
N -2530 -2720 -2530 -2690 {
lab=vdd_in}
N -2530 -2720 -2520 -2720 {
lab=vdd_in}
N -2520 -2660 -2520 -2640 {
lab=#net54}
N -2520 -2640 -2460 -2640 {
lab=#net54}
N -2460 -2690 -2460 -2640 {
lab=#net54}
N -2600 -2640 -2600 -2620 {
lab=#net55}
N -2080 -2640 -2070 -2640 {
lab=vpre11}
N -2540 -2640 -2520 -2640 {
lab=#net54}
N -2400 -2640 -2320 -2640 {
lab=vc11}
N -2320 -2680 -2310 -2680 {
lab=vlky}
N -2320 -2600 -2310 -2600 {
lab=vb_pre}
N -2320 -2160 -2310 -2160 {
lab=vlky}
N -2400 -2120 -2320 -2120 {
lab=vc12}
N -2320 -2080 -2310 -2080 {
lab=vb_pre}
N -2220 -1010 -2220 -990 {
lab=GND}
N -2220 -1170 -2220 -1150 {
lab=vdd_pre}
N -2600 -1000 -2600 -980 {
lab=GND}
N -2400 -1100 -2400 -1080 {
lab=vc14}
N -2400 -1130 -2390 -1130 {
lab=vdd_in}
N -2390 -1160 -2390 -1130 {
lab=vdd_in}
N -2400 -1160 -2390 -1160 {
lab=vdd_in}
N -2480 -1130 -2440 -1130 {
lab=#net56}
N -2520 -1160 -2400 -1160 {
lab=vdd_in}
N -2530 -1130 -2520 -1130 {
lab=vdd_in}
N -2530 -1160 -2530 -1130 {
lab=vdd_in}
N -2530 -1160 -2520 -1160 {
lab=vdd_in}
N -2520 -1100 -2520 -1080 {
lab=#net56}
N -2520 -1080 -2460 -1080 {
lab=#net56}
N -2460 -1130 -2460 -1080 {
lab=#net56}
N -2600 -1080 -2600 -1060 {
lab=#net57}
N -2080 -1080 -2070 -1080 {
lab=vpre14}
N -2540 -1080 -2520 -1080 {
lab=#net56}
N -2220 -1530 -2220 -1510 {
lab=GND}
N -2220 -1690 -2220 -1670 {
lab=vdd_pre}
N -2600 -1520 -2600 -1500 {
lab=GND}
N -2400 -1620 -2400 -1600 {
lab=vc13}
N -2400 -1650 -2390 -1650 {
lab=vdd_in}
N -2390 -1680 -2390 -1650 {
lab=vdd_in}
N -2400 -1680 -2390 -1680 {
lab=vdd_in}
N -2480 -1650 -2440 -1650 {
lab=#net58}
N -2520 -1680 -2400 -1680 {
lab=vdd_in}
N -2530 -1650 -2520 -1650 {
lab=vdd_in}
N -2530 -1680 -2530 -1650 {
lab=vdd_in}
N -2530 -1680 -2520 -1680 {
lab=vdd_in}
N -2520 -1620 -2520 -1600 {
lab=#net58}
N -2520 -1600 -2460 -1600 {
lab=#net58}
N -2460 -1650 -2460 -1600 {
lab=#net58}
N -2600 -1600 -2600 -1580 {
lab=#net59}
N -2080 -1600 -2070 -1600 {
lab=vpre13}
N -2540 -1600 -2520 -1600 {
lab=#net58}
N -2400 -1600 -2320 -1600 {
lab=vc13}
N -2320 -1640 -2310 -1640 {
lab=vlky}
N -2320 -1560 -2310 -1560 {
lab=vb_pre}
N -2320 -1120 -2310 -1120 {
lab=vlky}
N -2400 -1080 -2320 -1080 {
lab=vc14}
N -2320 -1040 -2310 -1040 {
lab=vb_pre}
N -2220 -490 -2220 -470 {
lab=GND}
N -2220 -650 -2220 -630 {
lab=vdd_pre}
N -2600 -480 -2600 -460 {
lab=GND}
N -2400 -580 -2400 -560 {
lab=vc15}
N -2400 -610 -2390 -610 {
lab=vdd_in}
N -2390 -640 -2390 -610 {
lab=vdd_in}
N -2400 -640 -2390 -640 {
lab=vdd_in}
N -2480 -610 -2440 -610 {
lab=#net60}
N -2520 -640 -2400 -640 {
lab=vdd_in}
N -2530 -610 -2520 -610 {
lab=vdd_in}
N -2530 -640 -2530 -610 {
lab=vdd_in}
N -2530 -640 -2520 -640 {
lab=vdd_in}
N -2520 -580 -2520 -560 {
lab=#net60}
N -2520 -560 -2460 -560 {
lab=#net60}
N -2460 -610 -2460 -560 {
lab=#net60}
N -2600 -560 -2600 -540 {
lab=#net61}
N -2080 -560 -2070 -560 {
lab=vpre15}
N -2540 -560 -2520 -560 {
lab=#net60}
N -2320 -600 -2310 -600 {
lab=vlky}
N -2400 -560 -2320 -560 {
lab=vc15}
N -2320 -520 -2310 -520 {
lab=vb_pre}
N -1020 -1810 -1020 -1800 {
lab=GND}
N -1020 -1810 -1010 -1810 {
lab=GND}
C {devices/vsource.sym} -1580 -2550 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1580 -2500 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1500 -2550 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1500 -2500 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1500 -2600 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2220 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2320 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2600 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -1490 -2020 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1610 -2020 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1360 -2020 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param Lp_delay=3.5
.param Wp_delay=0.45
.param Ln_delay=3.5
.param Wn_delay=0.45
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 1n 140u
  write SNN_15x1_tbv1.raw
.endc
" }
C {devices/launcher.sym} -1520 -1635 0 0 {name=h1
descr="load 1" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tbv1.raw tran"
}
C {devices/lab_pin.sym} -2400 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} -1320 -2550 0 0 {name=V4 value="PWL(0 1.8 124.9u 1.8 125u 0)"}
C {devices/gnd.sym} -1320 -2500 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1320 -2600 2 0 {name=p16 sig_type=std_logic lab=vdd_delay}
C {devices/gnd.sym} -1800 -7770 0 0 {name=l39 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -7370 0 0 {name=x2021}
C {devices/lab_pin.sym} -1860 -7850 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1740 -7850 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/gnd.sym} -1970 -7440 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -1910 -7480 3 0 {name=p28 sig_type=std_logic lab=vpos2}
C {devices/lab_pin.sym} -2030 -7480 3 0 {name=p33 sig_type=std_logic lab=vpre2}
C {devices/ammeter.sym} -1740 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -1740 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2030 -7150 0 0 {name=p53 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -1780 -250 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -130 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -1740 -290 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -1740 -330 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1740 0 2 0 {name=p61 sig_type=std_logic lab=8}
C {devices/vsource.sym} -1580 -2130 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2080 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1580 -2180 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1400 -2130 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} -1400 -2080 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1400 -2180 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} -1140 -2130 0 0 {name=V15 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1140 -2080 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1140 -2180 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -2570 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/lab_pin.sym} -2030 -7200 2 0 {name=p74 sig_type=std_logic lab=ctrl1}
C {devices/vsource.sym} -1580 -2270 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2220 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1580 -2320 2 0 {name=p75 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -7100 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2030 -7360 2 0 {name=p14 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -7270 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} -1400 -2270 0 0 {name=V12 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1400 -2220 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1400 -2320 2 0 {name=p17 sig_type=std_logic lab=ctrl2}
C {devices/vsource.sym} -1420 -2410 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1420 -2360 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1420 -2460 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -1410 -2550 0 0 {name=V3 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1410 -2500 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1410 -2600 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1210 -2550 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1210 -2500 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1210 -2600 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1130 -2550 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1130 -2500 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1130 -2600 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1580 -2410 0 0 {name=V7 value=0.7
*0.55}
C {devices/gnd.sym} -1580 -2360 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1580 -2460 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1500 -2410 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1500 -2360 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1500 -2460 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2220 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1670 -130 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1970 -7560 0 0 {name=p18 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -7230 0 0 {name=p19 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -7390 0 0 {name=p20 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -1580 -2600 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2460 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2320 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -7790 0 0 {name=I1 value=0}
C {devices/gnd.sym} -2600 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -1800 -7250 0 0 {name=l15 lab=GND}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -7890 0 0 {name=x2011}
C {devices/lab_pin.sym} -1860 -7330 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1740 -7330 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -1970 -7960 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -1910 -8000 3 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2030 -8000 3 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -1740 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -1740 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1920 -7680 1 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2030 -7670 0 0 {name=p36 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2070 -7840 3 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2570 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/lab_pin.sym} -2030 -7720 2 0 {name=p38 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -7620 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -1920 -7850 1 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2020 -7830 3 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2030 -7880 2 0 {name=p42 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2220 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1970 -8080 0 0 {name=p45 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -7910 0 0 {name=p48 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2460 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1790 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1790 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1210 -2270 0 0 {name=V16 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1210 -2220 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1210 -2320 2 0 {name=p71 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1050 -2550 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -1050 -2500 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -1050 -2600 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} -940 -1730 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -940 -1850 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -1810 -250 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} -1030 -2270 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -1030 -2220 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -1030 -2320 2 0 {name=p88 sig_type=std_logic lab=vinh}
C {devices/lab_pin.sym} -870 -1790 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -930 -1640 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} -970 -1620 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -970 -1650 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -970 -1590 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -1010 -1640 0 0 {name=p85 sig_type=std_logic lab=vinh}
C {devices/vsource.sym} -1350 -2410 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -1350 -2360 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -1350 -2460 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1700 -250 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -1580 -2690 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1580 -2640 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -1580 -2740 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -7670 0 0 {name=x2013}
C {devices/lab_pin.sym} -2030 -7120 0 0 {name=p49 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -7150 0 0 {name=x2023}
C {devices/lab_pin.sym} -2030 -7640 0 0 {name=p100 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -7320 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -6850 0 0 {name=x2031}
C {devices/gnd.sym} -1970 -6920 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -1910 -6960 3 0 {name=p227 sig_type=std_logic lab=vpos3}
C {devices/lab_pin.sym} -2030 -6960 3 0 {name=p228 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2030 -6630 0 0 {name=p230 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -6680 2 0 {name=p231 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -6580 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -1920 -6810 1 0 {name=p232 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2030 -6840 2 0 {name=p234 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -6750 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -1970 -7040 0 0 {name=p235 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -6710 0 0 {name=p236 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -6870 0 0 {name=p237 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -6600 0 0 {name=p238 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -6630 0 0 {name=x2033}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -6800 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -6330 0 0 {name=x2041}
C {devices/gnd.sym} -1970 -6400 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -1910 -6440 3 0 {name=p239 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1920 -6120 1 0 {name=p241 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2030 -6110 0 0 {name=p242 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -6160 2 0 {name=p243 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -6060 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -1920 -6290 1 0 {name=p244 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2020 -6270 3 0 {name=p245 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2030 -6320 2 0 {name=p246 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -6230 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} -1970 -6520 0 0 {name=p247 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -6190 0 0 {name=p248 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -6350 0 0 {name=p249 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -6080 0 0 {name=p250 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -6110 0 0 {name=x2043}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -6280 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -5810 0 0 {name=x2051}
C {devices/gnd.sym} -1970 -5880 0 0 {name=l90 lab=GND}
C {devices/lab_pin.sym} -1910 -5920 3 0 {name=p251 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2030 -5590 0 0 {name=p254 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -5640 2 0 {name=p255 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -5540 0 0 {name=l91 lab=GND}
C {devices/lab_pin.sym} -2020 -5750 3 0 {name=p257 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2030 -5800 2 0 {name=p258 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -5710 0 0 {name=l92 lab=GND}
C {devices/lab_pin.sym} -1970 -6000 0 0 {name=p259 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -5670 0 0 {name=p260 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -5830 0 0 {name=p261 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -5560 0 0 {name=p262 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -5590 0 0 {name=x2053}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -5760 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -5290 0 0 {name=x2061}
C {devices/gnd.sym} -1970 -5360 0 0 {name=l93 lab=GND}
C {devices/lab_pin.sym} -1910 -5400 3 0 {name=p263 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1920 -5080 1 0 {name=p265 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2030 -5070 0 0 {name=p266 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -5120 2 0 {name=p267 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -5020 0 0 {name=l94 lab=GND}
C {devices/lab_pin.sym} -2020 -5230 3 0 {name=p269 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2030 -5280 2 0 {name=p270 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -5190 0 0 {name=l95 lab=GND}
C {devices/lab_pin.sym} -1970 -5480 0 0 {name=p271 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -5150 0 0 {name=p272 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -5310 0 0 {name=p273 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -5040 0 0 {name=p274 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -5070 0 0 {name=x2063}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -5240 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -4770 0 0 {name=x2071}
C {devices/gnd.sym} -1970 -4840 0 0 {name=l96 lab=GND}
C {devices/lab_pin.sym} -1910 -4880 3 0 {name=p275 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1920 -4560 1 0 {name=p277 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2030 -4550 0 0 {name=p278 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -4600 2 0 {name=p279 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -4500 0 0 {name=l97 lab=GND}
C {devices/lab_pin.sym} -2020 -4710 3 0 {name=p281 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2030 -4760 2 0 {name=p282 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -4670 0 0 {name=l98 lab=GND}
C {devices/lab_pin.sym} -1970 -4960 0 0 {name=p283 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -4630 0 0 {name=p284 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -4790 0 0 {name=p285 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -4520 0 0 {name=p286 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -4550 0 0 {name=x2073}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -4720 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -4250 0 0 {name=x2081}
C {devices/gnd.sym} -1970 -4320 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -1910 -4360 3 0 {name=p287 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2030 -4360 3 0 {name=p288 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1920 -4040 1 0 {name=p289 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2030 -4030 0 0 {name=p290 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -4080 2 0 {name=p291 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -3980 0 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2030 -4240 2 0 {name=p294 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -4150 0 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} -1970 -4440 0 0 {name=p295 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -4110 0 0 {name=p296 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -4270 0 0 {name=p297 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -4000 0 0 {name=p298 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -4030 0 0 {name=x2083}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -4200 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -3730 0 0 {name=x2091}
C {devices/gnd.sym} -1970 -3800 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} -1910 -3840 3 0 {name=p299 sig_type=std_logic lab=vpos9}
C {devices/lab_pin.sym} -2030 -3840 3 0 {name=p300 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2030 -3510 0 0 {name=p302 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -3560 2 0 {name=p303 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -3460 0 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} -2030 -3720 2 0 {name=p306 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -3630 0 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} -1970 -3920 0 0 {name=p307 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -3590 0 0 {name=p308 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -3750 0 0 {name=p309 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -3480 0 0 {name=p310 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -3510 0 0 {name=x2093}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -3680 0 0 {name=x2092}
C {devices/gnd.sym} -1800 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -1740 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -1740 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -1860 -6290 1 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -1740 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -1740 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -1860 -5770 1 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -1740 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -1740 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -1740 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -1740 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -1740 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -1740 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -1740 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -1740 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -1860 -3690 1 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1740 -3690 1 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -1740 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -1740 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2220 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -2320 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -6230 0 0 {name=I4 value=0}
C {devices/gnd.sym} -2600 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -2570 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -2220 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -2320 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -6750 0 0 {name=I3 value=0}
C {devices/gnd.sym} -2600 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -2570 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -2220 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -2320 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -5190 0 0 {name=I6 value=0}
C {devices/gnd.sym} -2600 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -2570 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -2220 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -2320 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -5710 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2600 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -2570 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -2220 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -2320 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -4150 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2600 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -2570 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -2220 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -2320 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -4670 0 0 {name=I7 value=0}
C {devices/gnd.sym} -2600 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -2570 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -2220 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -2320 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -3630 0 0 {name=I9 value=0}
C {devices/gnd.sym} -2600 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -2570 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -2220 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1020 -1770 0 0 {name=p105 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} -1920 -7330 1 0 {name=p2 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1920 -7160 1 0 {name=p24 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2070 -7320 3 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2020 -7310 3 0 {name=p69 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2070 -6800 3 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2020 -6790 3 0 {name=p107 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1860 -6810 1 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1920 -6640 1 0 {name=p109 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2070 -3680 3 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2020 -3670 3 0 {name=p111 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1920 -3690 1 0 {name=p112 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1920 -3520 1 0 {name=p113 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1920 -4210 1 0 {name=p114 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1860 -4210 1 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2020 -4190 3 0 {name=p116 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2070 -4200 3 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1920 -4730 1 0 {name=p118 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1860 -4730 1 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2070 -4720 3 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2030 -4880 3 0 {name=p121 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1920 -5250 1 0 {name=p122 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1860 -5250 1 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2070 -5240 3 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2030 -5400 3 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -1920 -5770 1 0 {name=p126 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1920 -5600 1 0 {name=p127 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2070 -5760 3 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2030 -5920 3 0 {name=p129 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2070 -6280 3 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2030 -6440 3 0 {name=p131 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1740 -4210 1 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1740 -4730 1 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1740 -5250 1 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1740 -5770 1 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1740 -6290 1 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1740 -6810 1 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/launcher.sym} -1510 -1715 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -150 1 0 {name=x0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -3210 0 0 {name=x2101}
C {devices/gnd.sym} -1970 -3280 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -1910 -3320 3 0 {name=p22 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -1920 -3000 1 0 {name=p92 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2030 -2990 0 0 {name=p101 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -3040 2 0 {name=p102 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -2940 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -2030 -3200 2 0 {name=p133 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -3110 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -1970 -3400 0 0 {name=p135 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -3070 0 0 {name=p137 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -3230 0 0 {name=p144 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -2960 0 0 {name=p145 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -2990 0 0 {name=x2103}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -3160 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -2690 0 0 {name=x2111}
C {devices/gnd.sym} -1970 -2760 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -1910 -2800 3 0 {name=p146 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2030 -2470 0 0 {name=p147 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -2520 2 0 {name=p148 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -2420 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -2030 -2680 2 0 {name=p150 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -2590 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -1970 -2880 0 0 {name=p151 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -2550 0 0 {name=p152 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -2710 0 0 {name=p153 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -2440 0 0 {name=p154 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -2470 0 0 {name=x2113}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -2640 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -2170 0 0 {name=x2121}
C {devices/gnd.sym} -1970 -2240 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -1910 -2280 3 0 {name=p155 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -1920 -1960 1 0 {name=p156 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2030 -1950 0 0 {name=p157 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -2000 2 0 {name=p158 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -1900 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -2030 -2160 2 0 {name=p162 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -2070 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -1970 -2360 0 0 {name=p164 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -2030 0 0 {name=p167 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -2190 0 0 {name=p169 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -1920 0 0 {name=p172 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -1950 0 0 {name=x2123}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -2120 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -1650 0 0 {name=x2131}
C {devices/gnd.sym} -1970 -1720 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -1910 -1760 3 0 {name=p174 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -2030 -1430 0 0 {name=p179 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -1480 2 0 {name=p182 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -1380 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -2030 -1640 2 0 {name=p187 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -1550 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -1970 -1840 0 0 {name=p189 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -1510 0 0 {name=p194 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -1670 0 0 {name=p195 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -1400 0 0 {name=p196 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -1430 0 0 {name=x2133}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -1600 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -1130 0 0 {name=x2141}
C {devices/gnd.sym} -1970 -1200 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -1910 -1240 3 0 {name=p197 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -1920 -920 1 0 {name=p199 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2030 -910 0 0 {name=p200 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -960 2 0 {name=p201 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -860 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -2030 -1120 2 0 {name=p202 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -1030 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -1970 -1320 0 0 {name=p203 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -990 0 0 {name=p204 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -1150 0 0 {name=p205 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -880 0 0 {name=p206 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -910 0 0 {name=x2143}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -1080 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/delay/delay.sym} -1790 -610 0 0 {name=x2151}
C {devices/gnd.sym} -1970 -680 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -1910 -720 3 0 {name=p207 sig_type=std_logic lab=vpos15}
C {devices/lab_pin.sym} -2030 -390 0 0 {name=p209 sig_type=std_logic lab=uw}
C {devices/lab_pin.sym} -2030 -440 2 0 {name=p210 sig_type=std_logic lab=ctrl1}
C {devices/gnd.sym} -1970 -340 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -2030 -600 2 0 {name=p211 sig_type=std_logic lab=ctrl2}
C {devices/gnd.sym} -1970 -510 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -1970 -800 0 0 {name=p212 sig_type=std_logic lab=vdd_delay}
C {devices/lab_pin.sym} -1970 -470 0 0 {name=p213 sig_type=std_logic lab=vdd_sw}
C {devices/lab_pin.sym} -1970 -630 0 0 {name=p214 sig_type=std_logic lab=vdd_tg}
C {devices/lab_pin.sym} -2030 -360 0 0 {name=p215 sig_type=std_logic lab=vbias}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/sw.sym} -1970 -390 0 0 {name=x2153}
C {/home/ricardo/RATT_repos/Proyectos_xschem/switch/t_gate.sym} -1970 -560 0 0 {name=x2152}
C {devices/gnd.sym} -1800 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -1740 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1740 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -1740 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -1740 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -1740 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -1740 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -1740 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -1740 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -1740 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -1740 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1800 -610 1 0 {name=p319 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2220 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -2320 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -3110 0 0 {name=I10 value=0}
C {devices/gnd.sym} -2600 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -2570 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -2220 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -2320 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -2070 0 0 {name=I12 value=0}
C {devices/gnd.sym} -2600 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -2570 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -2220 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -2320 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -2590 0 0 {name=I11 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2600 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -2570 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -2220 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -2320 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2600 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -2570 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -2220 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2220 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -2320 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -1550 0 0 {name=I13 value=0}
C {devices/gnd.sym} -2600 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -2570 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -2220 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2320 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2220 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -2320 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2600 -510 0 0 {name=I15 value=0}
C {devices/gnd.sym} -2600 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2420 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2500 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2400 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -2570 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -2220 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2460 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2320 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2070 -560 3 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -1920 -570 1 0 {name=p356 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1920 -400 1 0 {name=p357 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2070 -1080 3 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -1920 -1610 1 0 {name=p366 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2070 -1600 3 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2030 -2280 3 0 {name=p375 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1920 -2480 1 0 {name=p377 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2070 -2640 3 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2070 -3160 3 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2220 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -2020 -550 3 0 {name=p208 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2030 -720 3 0 {name=p355 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -1860 -570 1 0 {name=p312 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1740 -570 1 0 {name=p405 sig_type=std_logic lab=vpos15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -940 -1790 0 0 {name=x2}
C {devices/lab_pin.sym} -2020 -1070 3 0 {name=p83 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2030 -1240 3 0 {name=p198 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -1920 -1090 1 0 {name=p358 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1860 -1090 1 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1740 -1090 1 0 {name=p382 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -2020 -1590 3 0 {name=p184 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2030 -1760 3 0 {name=p371 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -1920 -1440 1 0 {name=p176 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1860 -1610 1 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1740 -1610 1 0 {name=p392 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -2020 -3150 3 0 {name=p104 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2030 -3320 3 0 {name=p381 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -1740 -3170 1 0 {name=p394 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -1920 -3170 1 0 {name=p103 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1860 -3170 1 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2020 -2630 3 0 {name=p149 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2030 -2800 3 0 {name=p379 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -1920 -2650 1 0 {name=p222 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1860 -2650 1 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1740 -2650 1 0 {name=p400 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2070 -2120 3 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2020 -2110 3 0 {name=p374 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1920 -2130 1 0 {name=p372 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1860 -2130 1 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1740 -2130 1 0 {name=p396 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -1800 -7890 1 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -7370 1 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6850 1 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6330 1 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5810 1 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5290 1 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4770 1 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4250 1 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3730 1 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3210 1 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2690 1 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2170 1 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1650 1 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1130 1 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -1020 -1800 0 0 {name=l7 lab=GND}
C {devices/launcher.sym} -1520 -1575 0 0 {name=h3
descr="load 8" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tb.raw tran"
}
