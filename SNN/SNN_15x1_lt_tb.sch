v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -1200 800 -800 {flags=graph
y1=-0.053
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 800 -400 1600 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 3200 -2400 4000 -2000 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=1}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 0 -800 800 -400 {flags=graph
y1=3
y2=4.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 800 -800 1600 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 2400 -2400 3200 -2000 {flags=graph
y1=-1.4e-06
y2=0.12
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16"
node="p0
p1"}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 2400 -1200 3200 -800 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 3200 -2000 4000 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 3200 -1600 4000 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 3200 -1200 4000 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 2400 -800 3200 -400 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 2400 -400 3200 0 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 3200 -800 4000 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 3200 -400 4000 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 800 -1200 1600 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
B 2 0 -400 800 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-0.031
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpre1; vpres1\\"
\\"vpre2; vpres2\\"
\\"vpre3; vpres3\\"
\\"vpre4; vpres4\\"
\\"vpre5; vpres5\\"
\\"vpre6; vpres6\\"
\\"vpre7; vpres7\\"
\\"vpre8; vpres8\\"
\\"vpre9; vpres9\\""}
N 20 -2620 20 -2600 {
lab=GND}
N 20 -2700 20 -2680 {
lab=vdd_in}
N 100 -2620 100 -2600 {
lab=GND}
N 100 -2700 100 -2680 {
lab=vdd_pre}
N -3660 -7250 -3660 -7230 {
lab=GND}
N -3660 -7410 -3660 -7390 {
lab=vdd_pre}
N -4040 -7240 -4040 -7220 {
lab=GND}
N -3840 -7340 -3840 -7320 {
lab=vc2}
N -3840 -7370 -3830 -7370 {
lab=vdd_in}
N -3830 -7400 -3830 -7370 {
lab=vdd_in}
N -3840 -7400 -3830 -7400 {
lab=vdd_in}
N -3920 -7370 -3880 -7370 {
lab=#net1}
N -3960 -7400 -3840 -7400 {
lab=vdd_in}
N -3970 -7370 -3960 -7370 {
lab=vdd_in}
N -3970 -7400 -3970 -7370 {
lab=vdd_in}
N -3970 -7400 -3960 -7400 {
lab=vdd_in}
N -3960 -7340 -3960 -7320 {
lab=#net1}
N -3960 -7320 -3900 -7320 {
lab=#net1}
N -3900 -7370 -3900 -7320 {
lab=#net1}
N -4040 -7320 -4040 -7300 {
lab=#net2}
N 280 -2620 280 -2600 {
lab=GND}
N 280 -2700 280 -2680 {
lab=vdd_stdp}
N -2980 -7780 -2980 -7770 {
lab=GND}
N -2980 -7890 -2980 -7880 {
lab=vdd_syn0}
N -2920 -7700 -2910 -7700 {
lab=GND}
N -2920 -7670 -2920 -7660 {
lab=p0}
N -2920 -270 -2920 -260 {
lab=#net3}
N -2920 -340 -2920 -330 {
lab=p0}
N -2920 -20 -2920 -10 {
lab=1}
N 20 -2200 20 -2180 {
lab=GND}
N 20 -2280 20 -2260 {
lab=uw}
N 200 -2200 200 -2180 {
lab=GND}
N 200 -2280 200 -2260 {
lab=training}
N -3520 -7320 -3510 -7320 {
lab=vpre2}
N -2990 -160 -2990 -140 {
lab=GND}
N -2850 -160 -2850 -140 {
lab=vdd_pos}
N 460 -2200 460 -2180 {
lab=GND}
N 460 -2280 460 -2260 {
lab=inference}
N -3980 -7320 -3960 -7320 {
lab=#net1}
N 20 -2340 20 -2320 {
lab=GND}
N 20 -2420 20 -2400 {
lab=ctrl_wu}
N 100 -2340 100 -2320 {
lab=GND}
N 100 -2420 100 -2400 {
lab=ctrl_tr}
N 180 -2480 180 -2460 {
lab=GND}
N 180 -2560 180 -2540 {
lab=vb_wu}
N 190 -2620 190 -2600 {
lab=GND}
N 190 -2700 190 -2680 {
lab=vdd_pos}
N 380 -2620 380 -2600 {
lab=GND}
N 380 -2700 380 -2680 {
lab=vdd_wu}
N 460 -2620 460 -2600 {
lab=GND}
N 460 -2700 460 -2680 {
lab=vdd_tr}
N 20 -2480 20 -2460 {
lab=GND}
N 20 -2560 20 -2540 {
lab=vb_pre}
N 100 -2480 100 -2460 {
lab=GND}
N 100 -2560 100 -2540 {
lab=vb_pos}
N -3050 -7840 -3040 -7840 {
lab=vpres1}
N -2920 -7840 -2910 -7840 {
lab=vpos1}
N -3660 -7770 -3660 -7750 {
lab=GND}
N -3660 -7930 -3660 -7910 {
lab=vdd_pre}
N -4040 -7760 -4040 -7740 {
lab=GND}
N -3840 -7860 -3840 -7840 {
lab=vc1}
N -3840 -7890 -3830 -7890 {
lab=vdd_in}
N -3830 -7920 -3830 -7890 {
lab=vdd_in}
N -3840 -7920 -3830 -7920 {
lab=vdd_in}
N -3920 -7890 -3880 -7890 {
lab=#net4}
N -3960 -7920 -3840 -7920 {
lab=vdd_in}
N -3970 -7890 -3960 -7890 {
lab=vdd_in}
N -3970 -7920 -3970 -7890 {
lab=vdd_in}
N -3970 -7920 -3960 -7920 {
lab=vdd_in}
N -3960 -7860 -3960 -7840 {
lab=#net4}
N -3960 -7840 -3900 -7840 {
lab=#net4}
N -3900 -7890 -3900 -7840 {
lab=#net4}
N -4040 -7840 -4040 -7820 {
lab=#net5}
N -2980 -7260 -2980 -7250 {
lab=GND}
N -2980 -7370 -2980 -7360 {
lab=vdd_syn0}
N -3290 -7950 -3290 -7940 {
lab=GND}
N -2920 -7180 -2910 -7180 {
lab=GND}
N -2920 -7150 -2920 -7140 {
lab=p0}
N -3520 -7840 -3510 -7840 {
lab=vpre1}
N -3980 -7840 -3960 -7840 {
lab=#net4}
N -3290 -7650 -3290 -7640 {
lab=GND}
N -3240 -7690 -3230 -7690 {
lab=vpres1}
N -3290 -7800 -3290 -7790 {
lab=GND}
N -3240 -7990 -3230 -7990 {
lab=vpos1}
N -3240 -7840 -3230 -7840 {
lab=vpres1}
N -3050 -7320 -3040 -7320 {
lab=vpres2}
N -2920 -7320 -2910 -7320 {
lab=vpos2}
N -2970 -7180 -2960 -7180 {
lab=ctrl_pos}
N -2970 -7700 -2960 -7700 {
lab=ctrl_pos}
N 180 -2340 180 -2320 {
lab=GND}
N 180 -2420 180 -2400 {
lab=ctrl_inf}
N 620 -2620 620 -2600 {
lab=GND}
N 620 -2700 620 -2680 {
lab=vdd_inh}
N 660 -1950 660 -1940 {
lab=vdd_inh}
N 340 -2340 340 -2320 {
lab=GND}
N 340 -2420 340 -2400 {
lab=ctrl_vinh}
N 660 -1840 660 -1830 {
lab=GND}
N 720 -1890 730 -1890 {
lab=inh_d}
N 660 -1740 670 -1740 {
lab=inh0}
N 630 -1750 630 -1740 {
lab=GND}
N 630 -1700 630 -1690 {
lab=inh_d}
N 590 -1740 600 -1740 {
lab=ctrl_vinh}
N 340 -2480 340 -2460 {
lab=GND}
N 340 -2560 340 -2540 {
lab=vlky}
N -3840 -7840 -3760 -7840 {
lab=vc1}
N -3760 -7880 -3750 -7880 {
lab=vlky}
N -3760 -7800 -3750 -7800 {
lab=vb_pre}
N -3760 -7360 -3750 -7360 {
lab=vlky}
N -3840 -7320 -3760 -7320 {
lab=vc2}
N -3760 -7280 -3750 -7280 {
lab=vb_pre}
N -2990 -260 -2990 -250 {
lab=inh0}
N -2960 -260 -2960 -250 {
lab=vb_pos}
N -2880 -260 -2880 -250 {
lab=vlky}
N 700 -2620 700 -2600 {
lab=GND}
N 700 -2700 700 -2680 {
lab=vdd_syn0}
N -3350 -7660 -3340 -7660 {
lab=vb_wu}
N -2920 -7820 -2920 -7800 {
lab=#net6}
N -2920 -7740 -2920 -7730 {
lab=#net7}
N -2920 -7300 -2920 -7280 {
lab=#net8}
N -2920 -7220 -2920 -7210 {
lab=#net9}
N -2980 -6740 -2980 -6730 {
lab=GND}
N -2980 -6850 -2980 -6840 {
lab=vdd_syn0}
N -2920 -6660 -2910 -6660 {
lab=GND}
N -2920 -6630 -2920 -6620 {
lab=p0}
N -3050 -6800 -3040 -6800 {
lab=vpres3}
N -2920 -6800 -2910 -6800 {
lab=vpos3}
N -2970 -6660 -2960 -6660 {
lab=ctrl_pos}
N -2920 -6780 -2920 -6760 {
lab=#net10}
N -2920 -6700 -2920 -6690 {
lab=#net11}
N -2980 -6220 -2980 -6210 {
lab=GND}
N -2980 -6330 -2980 -6320 {
lab=vdd_syn0}
N -2920 -6140 -2910 -6140 {
lab=GND}
N -2920 -6110 -2920 -6100 {
lab=p0}
N -3050 -6280 -3040 -6280 {
lab=vpres4}
N -2920 -6280 -2910 -6280 {
lab=vpos4}
N -2970 -6140 -2960 -6140 {
lab=ctrl_pos}
N -2920 -6260 -2920 -6240 {
lab=#net12}
N -2920 -6180 -2920 -6170 {
lab=#net13}
N -2980 -5700 -2980 -5690 {
lab=GND}
N -2980 -5810 -2980 -5800 {
lab=vdd_syn0}
N -2920 -5620 -2910 -5620 {
lab=GND}
N -2920 -5590 -2920 -5580 {
lab=p0}
N -3050 -5760 -3040 -5760 {
lab=vpres5}
N -2920 -5760 -2910 -5760 {
lab=vpos5}
N -2970 -5620 -2960 -5620 {
lab=ctrl_pos}
N -2920 -5740 -2920 -5720 {
lab=#net14}
N -2920 -5660 -2920 -5650 {
lab=#net15}
N -2980 -5180 -2980 -5170 {
lab=GND}
N -2980 -5290 -2980 -5280 {
lab=vdd_syn0}
N -2920 -5100 -2910 -5100 {
lab=GND}
N -2920 -5070 -2920 -5060 {
lab=p0}
N -3050 -5240 -3040 -5240 {
lab=vpres6}
N -2920 -5240 -2910 -5240 {
lab=vpos6}
N -2970 -5100 -2960 -5100 {
lab=ctrl_pos}
N -2920 -5220 -2920 -5200 {
lab=#net16}
N -2920 -5140 -2920 -5130 {
lab=#net17}
N -2980 -4660 -2980 -4650 {
lab=GND}
N -2980 -4770 -2980 -4760 {
lab=vdd_syn0}
N -2920 -4580 -2910 -4580 {
lab=GND}
N -2920 -4550 -2920 -4540 {
lab=p0}
N -3050 -4720 -3040 -4720 {
lab=vpres7}
N -2920 -4720 -2910 -4720 {
lab=vpos7}
N -2970 -4580 -2960 -4580 {
lab=ctrl_pos}
N -2920 -4700 -2920 -4680 {
lab=#net18}
N -2920 -4620 -2920 -4610 {
lab=#net19}
N -2980 -4140 -2980 -4130 {
lab=GND}
N -2980 -4250 -2980 -4240 {
lab=vdd_syn0}
N -2920 -4060 -2910 -4060 {
lab=GND}
N -2920 -4030 -2920 -4020 {
lab=p0}
N -3050 -4200 -3040 -4200 {
lab=vpres8}
N -2920 -4200 -2910 -4200 {
lab=vpos8}
N -2970 -4060 -2960 -4060 {
lab=ctrl_pos}
N -2920 -4180 -2920 -4160 {
lab=#net20}
N -2920 -4100 -2920 -4090 {
lab=#net21}
N -2980 -3620 -2980 -3610 {
lab=GND}
N -2980 -3730 -2980 -3720 {
lab=vdd_syn0}
N -2920 -3540 -2910 -3540 {
lab=GND}
N -2920 -3510 -2920 -3500 {
lab=p0}
N -3050 -3680 -3040 -3680 {
lab=vpres9}
N -2920 -3680 -2910 -3680 {
lab=vpos9}
N -2970 -3540 -2960 -3540 {
lab=ctrl_pos}
N -2920 -3660 -2920 -3640 {
lab=#net22}
N -2920 -3580 -2920 -3570 {
lab=#net23}
N -3660 -6210 -3660 -6190 {
lab=GND}
N -3660 -6370 -3660 -6350 {
lab=vdd_pre}
N -4040 -6200 -4040 -6180 {
lab=GND}
N -3840 -6300 -3840 -6280 {
lab=vc4}
N -3840 -6330 -3830 -6330 {
lab=vdd_in}
N -3830 -6360 -3830 -6330 {
lab=vdd_in}
N -3840 -6360 -3830 -6360 {
lab=vdd_in}
N -3920 -6330 -3880 -6330 {
lab=#net24}
N -3960 -6360 -3840 -6360 {
lab=vdd_in}
N -3970 -6330 -3960 -6330 {
lab=vdd_in}
N -3970 -6360 -3970 -6330 {
lab=vdd_in}
N -3970 -6360 -3960 -6360 {
lab=vdd_in}
N -3960 -6300 -3960 -6280 {
lab=#net24}
N -3960 -6280 -3900 -6280 {
lab=#net24}
N -3900 -6330 -3900 -6280 {
lab=#net24}
N -4040 -6280 -4040 -6260 {
lab=#net25}
N -3520 -6280 -3510 -6280 {
lab=vpre4}
N -3980 -6280 -3960 -6280 {
lab=#net24}
N -3660 -6730 -3660 -6710 {
lab=GND}
N -3660 -6890 -3660 -6870 {
lab=vdd_pre}
N -4040 -6720 -4040 -6700 {
lab=GND}
N -3840 -6820 -3840 -6800 {
lab=vc3}
N -3840 -6850 -3830 -6850 {
lab=vdd_in}
N -3830 -6880 -3830 -6850 {
lab=vdd_in}
N -3840 -6880 -3830 -6880 {
lab=vdd_in}
N -3920 -6850 -3880 -6850 {
lab=#net26}
N -3960 -6880 -3840 -6880 {
lab=vdd_in}
N -3970 -6850 -3960 -6850 {
lab=vdd_in}
N -3970 -6880 -3970 -6850 {
lab=vdd_in}
N -3970 -6880 -3960 -6880 {
lab=vdd_in}
N -3960 -6820 -3960 -6800 {
lab=#net26}
N -3960 -6800 -3900 -6800 {
lab=#net26}
N -3900 -6850 -3900 -6800 {
lab=#net26}
N -4040 -6800 -4040 -6780 {
lab=#net27}
N -3520 -6800 -3510 -6800 {
lab=vpre3}
N -3980 -6800 -3960 -6800 {
lab=#net26}
N -3840 -6800 -3760 -6800 {
lab=vc3}
N -3760 -6840 -3750 -6840 {
lab=vlky}
N -3760 -6760 -3750 -6760 {
lab=vb_pre}
N -3760 -6320 -3750 -6320 {
lab=vlky}
N -3840 -6280 -3760 -6280 {
lab=vc4}
N -3760 -6240 -3750 -6240 {
lab=vb_pre}
N -3660 -5170 -3660 -5150 {
lab=GND}
N -3660 -5330 -3660 -5310 {
lab=vdd_pre}
N -4040 -5160 -4040 -5140 {
lab=GND}
N -3840 -5260 -3840 -5240 {
lab=vc6}
N -3840 -5290 -3830 -5290 {
lab=vdd_in}
N -3830 -5320 -3830 -5290 {
lab=vdd_in}
N -3840 -5320 -3830 -5320 {
lab=vdd_in}
N -3920 -5290 -3880 -5290 {
lab=#net28}
N -3960 -5320 -3840 -5320 {
lab=vdd_in}
N -3970 -5290 -3960 -5290 {
lab=vdd_in}
N -3970 -5320 -3970 -5290 {
lab=vdd_in}
N -3970 -5320 -3960 -5320 {
lab=vdd_in}
N -3960 -5260 -3960 -5240 {
lab=#net28}
N -3960 -5240 -3900 -5240 {
lab=#net28}
N -3900 -5290 -3900 -5240 {
lab=#net28}
N -4040 -5240 -4040 -5220 {
lab=#net29}
N -3520 -5240 -3510 -5240 {
lab=vpre6}
N -3980 -5240 -3960 -5240 {
lab=#net28}
N -3660 -5690 -3660 -5670 {
lab=GND}
N -3660 -5850 -3660 -5830 {
lab=vdd_pre}
N -4040 -5680 -4040 -5660 {
lab=GND}
N -3840 -5780 -3840 -5760 {
lab=vc5}
N -3840 -5810 -3830 -5810 {
lab=vdd_in}
N -3830 -5840 -3830 -5810 {
lab=vdd_in}
N -3840 -5840 -3830 -5840 {
lab=vdd_in}
N -3920 -5810 -3880 -5810 {
lab=#net30}
N -3960 -5840 -3840 -5840 {
lab=vdd_in}
N -3970 -5810 -3960 -5810 {
lab=vdd_in}
N -3970 -5840 -3970 -5810 {
lab=vdd_in}
N -3970 -5840 -3960 -5840 {
lab=vdd_in}
N -3960 -5780 -3960 -5760 {
lab=#net30}
N -3960 -5760 -3900 -5760 {
lab=#net30}
N -3900 -5810 -3900 -5760 {
lab=#net30}
N -4040 -5760 -4040 -5740 {
lab=#net31}
N -3520 -5760 -3510 -5760 {
lab=vpre5}
N -3980 -5760 -3960 -5760 {
lab=#net30}
N -3840 -5760 -3760 -5760 {
lab=vc5}
N -3760 -5800 -3750 -5800 {
lab=vlky}
N -3760 -5720 -3750 -5720 {
lab=vb_pre}
N -3760 -5280 -3750 -5280 {
lab=vlky}
N -3840 -5240 -3760 -5240 {
lab=vc6}
N -3760 -5200 -3750 -5200 {
lab=vb_pre}
N -3660 -4130 -3660 -4110 {
lab=GND}
N -3660 -4290 -3660 -4270 {
lab=vdd_pre}
N -4040 -4120 -4040 -4100 {
lab=GND}
N -3840 -4220 -3840 -4200 {
lab=vc8}
N -3840 -4250 -3830 -4250 {
lab=vdd_in}
N -3830 -4280 -3830 -4250 {
lab=vdd_in}
N -3840 -4280 -3830 -4280 {
lab=vdd_in}
N -3920 -4250 -3880 -4250 {
lab=#net32}
N -3960 -4280 -3840 -4280 {
lab=vdd_in}
N -3970 -4250 -3960 -4250 {
lab=vdd_in}
N -3970 -4280 -3970 -4250 {
lab=vdd_in}
N -3970 -4280 -3960 -4280 {
lab=vdd_in}
N -3960 -4220 -3960 -4200 {
lab=#net32}
N -3960 -4200 -3900 -4200 {
lab=#net32}
N -3900 -4250 -3900 -4200 {
lab=#net32}
N -4040 -4200 -4040 -4180 {
lab=#net33}
N -3520 -4200 -3510 -4200 {
lab=vpre8}
N -3980 -4200 -3960 -4200 {
lab=#net32}
N -3660 -4650 -3660 -4630 {
lab=GND}
N -3660 -4810 -3660 -4790 {
lab=vdd_pre}
N -4040 -4640 -4040 -4620 {
lab=GND}
N -3840 -4740 -3840 -4720 {
lab=vc7}
N -3840 -4770 -3830 -4770 {
lab=vdd_in}
N -3830 -4800 -3830 -4770 {
lab=vdd_in}
N -3840 -4800 -3830 -4800 {
lab=vdd_in}
N -3920 -4770 -3880 -4770 {
lab=#net34}
N -3960 -4800 -3840 -4800 {
lab=vdd_in}
N -3970 -4770 -3960 -4770 {
lab=vdd_in}
N -3970 -4800 -3970 -4770 {
lab=vdd_in}
N -3970 -4800 -3960 -4800 {
lab=vdd_in}
N -3960 -4740 -3960 -4720 {
lab=#net34}
N -3960 -4720 -3900 -4720 {
lab=#net34}
N -3900 -4770 -3900 -4720 {
lab=#net34}
N -4040 -4720 -4040 -4700 {
lab=#net35}
N -3520 -4720 -3510 -4720 {
lab=vpre7}
N -3980 -4720 -3960 -4720 {
lab=#net34}
N -3840 -4720 -3760 -4720 {
lab=vc7}
N -3760 -4760 -3750 -4760 {
lab=vlky}
N -3760 -4680 -3750 -4680 {
lab=vb_pre}
N -3760 -4240 -3750 -4240 {
lab=vlky}
N -3840 -4200 -3760 -4200 {
lab=vc8}
N -3760 -4160 -3750 -4160 {
lab=vb_pre}
N -3660 -3610 -3660 -3590 {
lab=GND}
N -3660 -3770 -3660 -3750 {
lab=vdd_pre}
N -4040 -3600 -4040 -3580 {
lab=GND}
N -3840 -3700 -3840 -3680 {
lab=vc9}
N -3840 -3730 -3830 -3730 {
lab=vdd_in}
N -3830 -3760 -3830 -3730 {
lab=vdd_in}
N -3840 -3760 -3830 -3760 {
lab=vdd_in}
N -3920 -3730 -3880 -3730 {
lab=#net36}
N -3960 -3760 -3840 -3760 {
lab=vdd_in}
N -3970 -3730 -3960 -3730 {
lab=vdd_in}
N -3970 -3760 -3970 -3730 {
lab=vdd_in}
N -3970 -3760 -3960 -3760 {
lab=vdd_in}
N -3960 -3700 -3960 -3680 {
lab=#net36}
N -3960 -3680 -3900 -3680 {
lab=#net36}
N -3900 -3730 -3900 -3680 {
lab=#net36}
N -4040 -3680 -4040 -3660 {
lab=#net37}
N -3520 -3680 -3510 -3680 {
lab=vpre9}
N -3980 -3680 -3960 -3680 {
lab=#net36}
N -3760 -3720 -3750 -3720 {
lab=vlky}
N -3840 -3680 -3760 -3680 {
lab=vc9}
N -3760 -3640 -3750 -3640 {
lab=vb_pre}
N 580 -1870 590 -1870 {
lab=1}
N -2980 -3100 -2980 -3090 {
lab=GND}
N -2980 -3210 -2980 -3200 {
lab=vdd_syn0}
N -2920 -3020 -2910 -3020 {
lab=GND}
N -2920 -2990 -2920 -2980 {
lab=p0}
N -3050 -3160 -3040 -3160 {
lab=vpres10}
N -2920 -3160 -2910 -3160 {
lab=vpos10}
N -2970 -3020 -2960 -3020 {
lab=ctrl_pos}
N -2920 -3140 -2920 -3120 {
lab=#net38}
N -2920 -3060 -2920 -3050 {
lab=#net39}
N -2980 -2580 -2980 -2570 {
lab=GND}
N -2980 -2690 -2980 -2680 {
lab=vdd_syn0}
N -2920 -2500 -2910 -2500 {
lab=GND}
N -2920 -2470 -2920 -2460 {
lab=p0}
N -3050 -2640 -3040 -2640 {
lab=vpres11}
N -2920 -2640 -2910 -2640 {
lab=vpos11}
N -2970 -2500 -2960 -2500 {
lab=ctrl_pos}
N -2920 -2620 -2920 -2600 {
lab=#net40}
N -2920 -2540 -2920 -2530 {
lab=#net41}
N -2980 -2060 -2980 -2050 {
lab=GND}
N -2980 -2170 -2980 -2160 {
lab=vdd_syn0}
N -2920 -1980 -2910 -1980 {
lab=GND}
N -2920 -1950 -2920 -1940 {
lab=p0}
N -3050 -2120 -3040 -2120 {
lab=vpres12}
N -2920 -2120 -2910 -2120 {
lab=vpos12}
N -2970 -1980 -2960 -1980 {
lab=ctrl_pos}
N -2920 -2100 -2920 -2080 {
lab=#net42}
N -2920 -2020 -2920 -2010 {
lab=#net43}
N -2980 -1540 -2980 -1530 {
lab=GND}
N -2980 -1650 -2980 -1640 {
lab=vdd_syn0}
N -2920 -1460 -2910 -1460 {
lab=GND}
N -2920 -1430 -2920 -1420 {
lab=p0}
N -3050 -1600 -3040 -1600 {
lab=vpres13}
N -2920 -1600 -2910 -1600 {
lab=vpos13}
N -2970 -1460 -2960 -1460 {
lab=ctrl_pos}
N -2920 -1580 -2920 -1560 {
lab=#net44}
N -2920 -1500 -2920 -1490 {
lab=#net45}
N -2980 -1020 -2980 -1010 {
lab=GND}
N -2980 -1130 -2980 -1120 {
lab=vdd_syn0}
N -2920 -940 -2910 -940 {
lab=GND}
N -2920 -910 -2920 -900 {
lab=p0}
N -2970 -940 -2960 -940 {
lab=ctrl_pos}
N -2920 -1060 -2920 -1040 {
lab=#net46}
N -2920 -980 -2920 -970 {
lab=#net47}
N -2980 -500 -2980 -490 {
lab=GND}
N -2980 -610 -2980 -600 {
lab=vdd_syn0}
N -2920 -420 -2910 -420 {
lab=GND}
N -2920 -390 -2920 -380 {
lab=p0}
N -2920 -560 -2910 -560 {
lab=vpos15}
N -2970 -420 -2960 -420 {
lab=ctrl_pos}
N -2920 -540 -2920 -520 {
lab=#net48}
N -2920 -460 -2920 -450 {
lab=#net49}
N -3660 -3090 -3660 -3070 {
lab=GND}
N -3660 -3250 -3660 -3230 {
lab=vdd_pre}
N -4040 -3080 -4040 -3060 {
lab=GND}
N -3840 -3180 -3840 -3160 {
lab=vc10}
N -3840 -3210 -3830 -3210 {
lab=vdd_in}
N -3830 -3240 -3830 -3210 {
lab=vdd_in}
N -3840 -3240 -3830 -3240 {
lab=vdd_in}
N -3920 -3210 -3880 -3210 {
lab=#net50}
N -3960 -3240 -3840 -3240 {
lab=vdd_in}
N -3970 -3210 -3960 -3210 {
lab=vdd_in}
N -3970 -3240 -3970 -3210 {
lab=vdd_in}
N -3970 -3240 -3960 -3240 {
lab=vdd_in}
N -3960 -3180 -3960 -3160 {
lab=#net50}
N -3960 -3160 -3900 -3160 {
lab=#net50}
N -3900 -3210 -3900 -3160 {
lab=#net50}
N -4040 -3160 -4040 -3140 {
lab=#net51}
N -3520 -3160 -3510 -3160 {
lab=vpre10}
N -3980 -3160 -3960 -3160 {
lab=#net50}
N -3760 -3200 -3750 -3200 {
lab=vlky}
N -3840 -3160 -3760 -3160 {
lab=vc10}
N -3760 -3120 -3750 -3120 {
lab=vb_pre}
N -3660 -2050 -3660 -2030 {
lab=GND}
N -3660 -2210 -3660 -2190 {
lab=vdd_pre}
N -4040 -2040 -4040 -2020 {
lab=GND}
N -3840 -2140 -3840 -2120 {
lab=vc12}
N -3840 -2170 -3830 -2170 {
lab=vdd_in}
N -3830 -2200 -3830 -2170 {
lab=vdd_in}
N -3840 -2200 -3830 -2200 {
lab=vdd_in}
N -3920 -2170 -3880 -2170 {
lab=#net52}
N -3960 -2200 -3840 -2200 {
lab=vdd_in}
N -3970 -2170 -3960 -2170 {
lab=vdd_in}
N -3970 -2200 -3970 -2170 {
lab=vdd_in}
N -3970 -2200 -3960 -2200 {
lab=vdd_in}
N -3960 -2140 -3960 -2120 {
lab=#net52}
N -3960 -2120 -3900 -2120 {
lab=#net52}
N -3900 -2170 -3900 -2120 {
lab=#net52}
N -4040 -2120 -4040 -2100 {
lab=#net53}
N -3520 -2120 -3510 -2120 {
lab=vpre12}
N -3980 -2120 -3960 -2120 {
lab=#net52}
N -3660 -2570 -3660 -2550 {
lab=GND}
N -3660 -2730 -3660 -2710 {
lab=vdd_pre}
N -4040 -2560 -4040 -2540 {
lab=GND}
N -3840 -2660 -3840 -2640 {
lab=vc11}
N -3840 -2690 -3830 -2690 {
lab=vdd_in}
N -3830 -2720 -3830 -2690 {
lab=vdd_in}
N -3840 -2720 -3830 -2720 {
lab=vdd_in}
N -3920 -2690 -3880 -2690 {
lab=#net54}
N -3960 -2720 -3840 -2720 {
lab=vdd_in}
N -3970 -2690 -3960 -2690 {
lab=vdd_in}
N -3970 -2720 -3970 -2690 {
lab=vdd_in}
N -3970 -2720 -3960 -2720 {
lab=vdd_in}
N -3960 -2660 -3960 -2640 {
lab=#net54}
N -3960 -2640 -3900 -2640 {
lab=#net54}
N -3900 -2690 -3900 -2640 {
lab=#net54}
N -4040 -2640 -4040 -2620 {
lab=#net55}
N -3520 -2640 -3510 -2640 {
lab=vpre11}
N -3980 -2640 -3960 -2640 {
lab=#net54}
N -3840 -2640 -3760 -2640 {
lab=vc11}
N -3760 -2680 -3750 -2680 {
lab=vlky}
N -3760 -2600 -3750 -2600 {
lab=vb_pre}
N -3760 -2160 -3750 -2160 {
lab=vlky}
N -3840 -2120 -3760 -2120 {
lab=vc12}
N -3760 -2080 -3750 -2080 {
lab=vb_pre}
N -3660 -1010 -3660 -990 {
lab=GND}
N -3660 -1170 -3660 -1150 {
lab=vdd_pre}
N -4040 -1000 -4040 -980 {
lab=GND}
N -3840 -1100 -3840 -1080 {
lab=vc14}
N -3840 -1130 -3830 -1130 {
lab=vdd_in}
N -3830 -1160 -3830 -1130 {
lab=vdd_in}
N -3840 -1160 -3830 -1160 {
lab=vdd_in}
N -3920 -1130 -3880 -1130 {
lab=#net56}
N -3960 -1160 -3840 -1160 {
lab=vdd_in}
N -3970 -1130 -3960 -1130 {
lab=vdd_in}
N -3970 -1160 -3970 -1130 {
lab=vdd_in}
N -3970 -1160 -3960 -1160 {
lab=vdd_in}
N -3960 -1100 -3960 -1080 {
lab=#net56}
N -3960 -1080 -3900 -1080 {
lab=#net56}
N -3900 -1130 -3900 -1080 {
lab=#net56}
N -4040 -1080 -4040 -1060 {
lab=#net57}
N -3520 -1080 -3510 -1080 {
lab=vpre14}
N -3980 -1080 -3960 -1080 {
lab=#net56}
N -3660 -1530 -3660 -1510 {
lab=GND}
N -3660 -1690 -3660 -1670 {
lab=vdd_pre}
N -4040 -1520 -4040 -1500 {
lab=GND}
N -3840 -1620 -3840 -1600 {
lab=vc13}
N -3840 -1650 -3830 -1650 {
lab=vdd_in}
N -3830 -1680 -3830 -1650 {
lab=vdd_in}
N -3840 -1680 -3830 -1680 {
lab=vdd_in}
N -3920 -1650 -3880 -1650 {
lab=#net58}
N -3960 -1680 -3840 -1680 {
lab=vdd_in}
N -3970 -1650 -3960 -1650 {
lab=vdd_in}
N -3970 -1680 -3970 -1650 {
lab=vdd_in}
N -3970 -1680 -3960 -1680 {
lab=vdd_in}
N -3960 -1620 -3960 -1600 {
lab=#net58}
N -3960 -1600 -3900 -1600 {
lab=#net58}
N -3900 -1650 -3900 -1600 {
lab=#net58}
N -4040 -1600 -4040 -1580 {
lab=#net59}
N -3520 -1600 -3510 -1600 {
lab=vpre13}
N -3980 -1600 -3960 -1600 {
lab=#net58}
N -3840 -1600 -3760 -1600 {
lab=vc13}
N -3760 -1640 -3750 -1640 {
lab=vlky}
N -3760 -1560 -3750 -1560 {
lab=vb_pre}
N -3760 -1120 -3750 -1120 {
lab=vlky}
N -3840 -1080 -3760 -1080 {
lab=vc14}
N -3760 -1040 -3750 -1040 {
lab=vb_pre}
N -3660 -490 -3660 -470 {
lab=GND}
N -3660 -650 -3660 -630 {
lab=vdd_pre}
N -4040 -480 -4040 -460 {
lab=GND}
N -3840 -580 -3840 -560 {
lab=vc15}
N -3840 -610 -3830 -610 {
lab=vdd_in}
N -3830 -640 -3830 -610 {
lab=vdd_in}
N -3840 -640 -3830 -640 {
lab=vdd_in}
N -3920 -610 -3880 -610 {
lab=#net60}
N -3960 -640 -3840 -640 {
lab=vdd_in}
N -3970 -610 -3960 -610 {
lab=vdd_in}
N -3970 -640 -3970 -610 {
lab=vdd_in}
N -3970 -640 -3960 -640 {
lab=vdd_in}
N -3960 -580 -3960 -560 {
lab=#net60}
N -3960 -560 -3900 -560 {
lab=#net60}
N -3900 -610 -3900 -560 {
lab=#net60}
N -4040 -560 -4040 -540 {
lab=#net61}
N -3520 -560 -3510 -560 {
lab=vpre15}
N -3980 -560 -3960 -560 {
lab=#net60}
N -3760 -600 -3750 -600 {
lab=vlky}
N -3840 -560 -3760 -560 {
lab=vc15}
N -3760 -520 -3750 -520 {
lab=vb_pre}
N 580 -1910 580 -1900 {
lab=GND}
N 580 -1910 590 -1910 {
lab=GND}
N -3350 -8020 -3340 -8020 {
lab=ctrl_tr}
N -3350 -7870 -3340 -7870 {
lab=ctrl_inf}
N -3290 -7750 -3290 -7730 {
lab=vdd_wu}
N -3290 -7900 -3290 -7880 {
lab=vdd_inf}
N -3290 -8050 -3290 -8030 {
lab=vdd_tr}
N -3350 -7720 -3340 -7720 {
lab=ctrl_wu}
N -3340 -7720 -3340 -7690 {
lab=ctrl_wu}
N 260 -2340 260 -2320 {
lab=GND}
N 260 -2420 260 -2400 {
lab=ctrl_pos}
N -3290 -7430 -3290 -7420 {
lab=GND}
N -3290 -7130 -3290 -7120 {
lab=GND}
N -3240 -7170 -3230 -7170 {
lab=vpres2}
N -3290 -7280 -3290 -7270 {
lab=GND}
N -3350 -7470 -3340 -7470 {
lab=vpre2}
N -3240 -7470 -3230 -7470 {
lab=vpos2}
N -3240 -7320 -3230 -7320 {
lab=vpres2}
N -3350 -7140 -3340 -7140 {
lab=vb_wu}
N -3350 -7500 -3340 -7500 {
lab=ctrl_tr}
N -3350 -7350 -3340 -7350 {
lab=ctrl_inf}
N -3290 -7230 -3290 -7210 {
lab=vdd_wu}
N -3290 -7380 -3290 -7360 {
lab=vdd_inf}
N -3290 -7530 -3290 -7510 {
lab=vdd_tr}
N -3350 -7200 -3340 -7200 {
lab=ctrl_wu}
N -3340 -7200 -3340 -7170 {
lab=ctrl_wu}
N -3290 -6910 -3290 -6900 {
lab=GND}
N -3290 -6610 -3290 -6600 {
lab=GND}
N -3240 -6650 -3230 -6650 {
lab=vpres3}
N -3290 -6760 -3290 -6750 {
lab=GND}
N -3350 -6800 -3340 -6800 {
lab=vpre3}
N -3350 -6950 -3340 -6950 {
lab=vpre3}
N -3240 -6950 -3230 -6950 {
lab=vpos3}
N -3240 -6800 -3230 -6800 {
lab=vpres3}
N -3350 -6620 -3340 -6620 {
lab=vb_wu}
N -3350 -6980 -3340 -6980 {
lab=ctrl_tr}
N -3350 -6830 -3340 -6830 {
lab=ctrl_inf}
N -3290 -6710 -3290 -6690 {
lab=vdd_wu}
N -3290 -6860 -3290 -6840 {
lab=vdd_inf}
N -3290 -7010 -3290 -6990 {
lab=vdd_tr}
N -3350 -6680 -3340 -6680 {
lab=ctrl_wu}
N -3340 -6680 -3340 -6650 {
lab=ctrl_wu}
N -3290 -6390 -3290 -6380 {
lab=GND}
N -3290 -6090 -3290 -6080 {
lab=GND}
N -3240 -6130 -3230 -6130 {
lab=vpres4}
N -3290 -6240 -3290 -6230 {
lab=GND}
N -3350 -6280 -3340 -6280 {
lab=vpre4}
N -3350 -6430 -3340 -6430 {
lab=vpre4}
N -3240 -6430 -3230 -6430 {
lab=vpos4}
N -3240 -6280 -3230 -6280 {
lab=vpres4}
N -3350 -6100 -3340 -6100 {
lab=vb_wu}
N -3350 -6460 -3340 -6460 {
lab=ctrl_tr}
N -3350 -6310 -3340 -6310 {
lab=ctrl_inf}
N -3290 -6190 -3290 -6170 {
lab=vdd_wu}
N -3290 -6340 -3290 -6320 {
lab=vdd_inf}
N -3290 -6490 -3290 -6470 {
lab=vdd_tr}
N -3350 -6160 -3340 -6160 {
lab=ctrl_wu}
N -3340 -6160 -3340 -6130 {
lab=ctrl_wu}
N -3290 -5870 -3290 -5860 {
lab=GND}
N -3290 -5570 -3290 -5560 {
lab=GND}
N -3240 -5610 -3230 -5610 {
lab=vpres5}
N -3290 -5720 -3290 -5710 {
lab=GND}
N -3350 -5760 -3340 -5760 {
lab=vpre5}
N -3350 -5910 -3340 -5910 {
lab=vpre5}
N -3240 -5910 -3230 -5910 {
lab=vpos5}
N -3240 -5760 -3230 -5760 {
lab=vpres5}
N -3350 -5580 -3340 -5580 {
lab=vb_wu}
N -3350 -5940 -3340 -5940 {
lab=ctrl_tr}
N -3350 -5790 -3340 -5790 {
lab=ctrl_inf}
N -3290 -5670 -3290 -5650 {
lab=vdd_wu}
N -3290 -5820 -3290 -5800 {
lab=vdd_inf}
N -3290 -5970 -3290 -5950 {
lab=vdd_tr}
N -3350 -5640 -3340 -5640 {
lab=ctrl_wu}
N -3340 -5640 -3340 -5610 {
lab=ctrl_wu}
N -3290 -5350 -3290 -5340 {
lab=GND}
N -3290 -5050 -3290 -5040 {
lab=GND}
N -3240 -5090 -3230 -5090 {
lab=vpres6}
N -3290 -5200 -3290 -5190 {
lab=GND}
N -3350 -5240 -3340 -5240 {
lab=vpre6}
N -3350 -5390 -3340 -5390 {
lab=vpre6}
N -3240 -5390 -3230 -5390 {
lab=vpos6}
N -3240 -5240 -3230 -5240 {
lab=vpres6}
N -3350 -5060 -3340 -5060 {
lab=vb_wu}
N -3350 -5420 -3340 -5420 {
lab=ctrl_tr}
N -3350 -5270 -3340 -5270 {
lab=ctrl_inf}
N -3290 -5150 -3290 -5130 {
lab=vdd_wu}
N -3290 -5300 -3290 -5280 {
lab=vdd_inf}
N -3290 -5450 -3290 -5430 {
lab=vdd_tr}
N -3350 -5120 -3340 -5120 {
lab=ctrl_wu}
N -3340 -5120 -3340 -5090 {
lab=ctrl_wu}
N -3290 -4830 -3290 -4820 {
lab=GND}
N -3290 -4530 -3290 -4520 {
lab=GND}
N -3240 -4570 -3230 -4570 {
lab=vpres7}
N -3290 -4680 -3290 -4670 {
lab=GND}
N -3350 -4720 -3340 -4720 {
lab=vpre7}
N -3350 -4870 -3340 -4870 {
lab=vpre7}
N -3240 -4870 -3230 -4870 {
lab=vpos7}
N -3240 -4720 -3230 -4720 {
lab=vpres7}
N -3350 -4540 -3340 -4540 {
lab=vb_wu}
N -3350 -4900 -3340 -4900 {
lab=ctrl_tr}
N -3350 -4750 -3340 -4750 {
lab=ctrl_inf}
N -3290 -4630 -3290 -4610 {
lab=vdd_wu}
N -3290 -4780 -3290 -4760 {
lab=vdd_inf}
N -3290 -4930 -3290 -4910 {
lab=vdd_tr}
N -3350 -4600 -3340 -4600 {
lab=ctrl_wu}
N -3340 -4600 -3340 -4570 {
lab=ctrl_wu}
N -3290 -4310 -3290 -4300 {
lab=GND}
N -3290 -4010 -3290 -4000 {
lab=GND}
N -3240 -4050 -3230 -4050 {
lab=vpres8}
N -3290 -4160 -3290 -4150 {
lab=GND}
N -3350 -4200 -3340 -4200 {
lab=vpre8}
N -3350 -4350 -3340 -4350 {
lab=vpre8}
N -3240 -4350 -3230 -4350 {
lab=vpos8}
N -3240 -4200 -3230 -4200 {
lab=vpres8}
N -3350 -4020 -3340 -4020 {
lab=vb_wu}
N -3350 -4380 -3340 -4380 {
lab=ctrl_tr}
N -3350 -4230 -3340 -4230 {
lab=ctrl_inf}
N -3290 -4110 -3290 -4090 {
lab=vdd_wu}
N -3290 -4260 -3290 -4240 {
lab=vdd_inf}
N -3290 -4410 -3290 -4390 {
lab=vdd_tr}
N -3350 -4080 -3340 -4080 {
lab=ctrl_wu}
N -3340 -4080 -3340 -4050 {
lab=ctrl_wu}
N -3290 -3790 -3290 -3780 {
lab=GND}
N -3290 -3490 -3290 -3480 {
lab=GND}
N -3240 -3530 -3230 -3530 {
lab=vpres9}
N -3290 -3640 -3290 -3630 {
lab=GND}
N -3350 -3680 -3340 -3680 {
lab=vpre9}
N -3350 -3830 -3340 -3830 {
lab=vpre9}
N -3240 -3830 -3230 -3830 {
lab=vpos9}
N -3240 -3680 -3230 -3680 {
lab=vpres9}
N -3350 -3500 -3340 -3500 {
lab=vb_wu}
N -3350 -3860 -3340 -3860 {
lab=ctrl_tr}
N -3350 -3710 -3340 -3710 {
lab=ctrl_inf}
N -3290 -3590 -3290 -3570 {
lab=vdd_wu}
N -3290 -3740 -3290 -3720 {
lab=vdd_inf}
N -3290 -3890 -3290 -3870 {
lab=vdd_tr}
N -3350 -3560 -3340 -3560 {
lab=ctrl_wu}
N -3340 -3560 -3340 -3530 {
lab=ctrl_wu}
N -3290 -3270 -3290 -3260 {
lab=GND}
N -3290 -2970 -3290 -2960 {
lab=GND}
N -3240 -3010 -3230 -3010 {
lab=vpres10}
N -3290 -3120 -3290 -3110 {
lab=GND}
N -3350 -3160 -3340 -3160 {
lab=vpre10}
N -3350 -3310 -3340 -3310 {
lab=vpre10}
N -3240 -3310 -3230 -3310 {
lab=vpos10}
N -3240 -3160 -3230 -3160 {
lab=vpres10}
N -3350 -2980 -3340 -2980 {
lab=vb_wu}
N -3350 -3340 -3340 -3340 {
lab=ctrl_tr}
N -3350 -3190 -3340 -3190 {
lab=ctrl_inf}
N -3290 -3070 -3290 -3050 {
lab=vdd_wu}
N -3290 -3220 -3290 -3200 {
lab=vdd_inf}
N -3290 -3370 -3290 -3350 {
lab=vdd_tr}
N -3350 -3040 -3340 -3040 {
lab=ctrl_wu}
N -3340 -3040 -3340 -3010 {
lab=ctrl_wu}
N -3290 -2750 -3290 -2740 {
lab=GND}
N -3290 -2450 -3290 -2440 {
lab=GND}
N -3240 -2490 -3230 -2490 {
lab=vpres11}
N -3290 -2600 -3290 -2590 {
lab=GND}
N -3350 -2640 -3340 -2640 {
lab=vpre11}
N -3350 -2790 -3340 -2790 {
lab=vpre11}
N -3240 -2790 -3230 -2790 {
lab=vpos11}
N -3240 -2640 -3230 -2640 {
lab=vpres11}
N -3350 -2460 -3340 -2460 {
lab=vb_wu}
N -3350 -2820 -3340 -2820 {
lab=ctrl_tr}
N -3350 -2670 -3340 -2670 {
lab=ctrl_inf}
N -3290 -2550 -3290 -2530 {
lab=vdd_wu}
N -3290 -2700 -3290 -2680 {
lab=vdd_inf}
N -3290 -2850 -3290 -2830 {
lab=vdd_tr}
N -3350 -2520 -3340 -2520 {
lab=ctrl_wu}
N -3340 -2520 -3340 -2490 {
lab=ctrl_wu}
N -3290 -2230 -3290 -2220 {
lab=GND}
N -3290 -1930 -3290 -1920 {
lab=GND}
N -3240 -1970 -3230 -1970 {
lab=vpres12}
N -3290 -2080 -3290 -2070 {
lab=GND}
N -3350 -2120 -3340 -2120 {
lab=vpre12}
N -3350 -2270 -3340 -2270 {
lab=vpre12}
N -3240 -2270 -3230 -2270 {
lab=vpos12}
N -3240 -2120 -3230 -2120 {
lab=vpres12}
N -3350 -1940 -3340 -1940 {
lab=vb_wu}
N -3350 -2300 -3340 -2300 {
lab=ctrl_tr}
N -3350 -2150 -3340 -2150 {
lab=ctrl_inf}
N -3290 -2030 -3290 -2010 {
lab=vdd_wu}
N -3290 -2180 -3290 -2160 {
lab=vdd_inf}
N -3290 -2330 -3290 -2310 {
lab=vdd_tr}
N -3350 -2000 -3340 -2000 {
lab=ctrl_wu}
N -3340 -2000 -3340 -1970 {
lab=ctrl_wu}
N -3290 -1710 -3290 -1700 {
lab=GND}
N -3290 -1410 -3290 -1400 {
lab=GND}
N -3240 -1450 -3230 -1450 {
lab=vpres13}
N -3290 -1560 -3290 -1550 {
lab=GND}
N -3350 -1600 -3340 -1600 {
lab=vpre13}
N -3350 -1750 -3340 -1750 {
lab=vpre13}
N -3240 -1750 -3230 -1750 {
lab=vpos13}
N -3240 -1600 -3230 -1600 {
lab=vpres13}
N -3350 -1420 -3340 -1420 {
lab=vb_wu}
N -3350 -1780 -3340 -1780 {
lab=ctrl_tr}
N -3350 -1630 -3340 -1630 {
lab=ctrl_inf}
N -3290 -1510 -3290 -1490 {
lab=vdd_wu}
N -3290 -1660 -3290 -1640 {
lab=vdd_inf}
N -3290 -1810 -3290 -1790 {
lab=vdd_tr}
N -3350 -1480 -3340 -1480 {
lab=ctrl_wu}
N -3340 -1480 -3340 -1450 {
lab=ctrl_wu}
N -3290 -1190 -3290 -1180 {
lab=GND}
N -3290 -890 -3290 -880 {
lab=GND}
N -3240 -930 -3230 -930 {
lab=vpres14}
N -3290 -1040 -3290 -1030 {
lab=GND}
N -3350 -1080 -3340 -1080 {
lab=vpre14}
N -3350 -1230 -3340 -1230 {
lab=vpre14}
N -3240 -1230 -3230 -1230 {
lab=vpos14}
N -3350 -900 -3340 -900 {
lab=vb_wu}
N -3350 -1260 -3340 -1260 {
lab=ctrl_tr}
N -3350 -1110 -3340 -1110 {
lab=ctrl_inf}
N -3290 -990 -3290 -970 {
lab=vdd_wu}
N -3290 -1140 -3290 -1120 {
lab=vdd_inf}
N -3290 -1290 -3290 -1270 {
lab=vdd_tr}
N -3350 -960 -3340 -960 {
lab=ctrl_wu}
N -3340 -960 -3340 -930 {
lab=ctrl_wu}
N -3290 -670 -3290 -660 {
lab=GND}
N -3290 -370 -3290 -360 {
lab=GND}
N -3240 -410 -3230 -410 {
lab=vpres15}
N -3290 -520 -3290 -510 {
lab=GND}
N -3350 -710 -3340 -710 {
lab=vpre15}
N -3240 -710 -3230 -710 {
lab=vpos15}
N -3350 -380 -3340 -380 {
lab=vb_wu}
N -3350 -740 -3340 -740 {
lab=ctrl_tr}
N -3350 -590 -3340 -590 {
lab=ctrl_inf}
N -3290 -470 -3290 -450 {
lab=vdd_wu}
N -3290 -620 -3290 -600 {
lab=vdd_inf}
N -3290 -770 -3290 -750 {
lab=vdd_tr}
N -3350 -440 -3340 -440 {
lab=ctrl_wu}
N -3340 -440 -3340 -410 {
lab=ctrl_wu}
N -3350 -7990 -3340 -7990 {
lab=vpre1}
N -3350 -7840 -3340 -7840 {
lab=vpre1}
N -3350 -7320 -3340 -7320 {
lab=vpre2}
N -3350 -560 -3340 -560 {
lab=vpre15}
N -3240 -560 -3230 -560 {
lab=vpres15}
N -3050 -560 -3040 -560 {
lab=vpres15}
N -3050 -1080 -3040 -1080 {
lab=vpres14}
N -2920 -1080 -2910 -1080 {
lab=vpos14}
N -3240 -1080 -3230 -1080 {
lab=vpres14}
N 260 -2480 260 -2460 {
lab=GND}
N 260 -2560 260 -2540 {
lab=vb_tr}
N -3350 -680 -3340 -680 {
lab=vb_tr}
N -3350 -1200 -3340 -1200 {
lab=vb_tr}
N -3350 -1720 -3340 -1720 {
lab=vb_tr}
N -3350 -2240 -3340 -2240 {
lab=vb_tr}
N -3350 -2760 -3340 -2760 {
lab=vb_tr}
N -3350 -3280 -3340 -3280 {
lab=vb_tr}
N -3350 -3800 -3340 -3800 {
lab=vb_tr}
N -3350 -4320 -3340 -4320 {
lab=vb_tr}
N -3350 -4840 -3340 -4840 {
lab=vb_tr}
N -3350 -5360 -3340 -5360 {
lab=vb_tr}
N -3350 -5880 -3340 -5880 {
lab=vb_tr}
N -3350 -6400 -3340 -6400 {
lab=vb_tr}
N -3350 -6920 -3340 -6920 {
lab=vb_tr}
N -3350 -7440 -3340 -7440 {
lab=vb_tr}
N -3350 -7960 -3340 -7960 {
lab=vb_tr}
N 540 -2620 540 -2600 {
lab=GND}
N 540 -2700 540 -2680 {
lab=vdd_inf}
C {devices/vsource.sym} 20 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} 20 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 100 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} 100 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 100 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -3660 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -3760 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4040 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} 110 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -10 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} 240 -2120 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param L_mem_in=0.15
.param W_mem_in=10
.param L_mem_out=0.25
.param W_mem_out=0.45
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
	save all
	tran 1u 150u
	write SNN_15x1_lt_tb.raw
	*wrdata SNN_15x1_lt_tb.ssv v(8)
.endc
" }
C {devices/launcher.sym} 80 -1735 0 0 {name=h1
descr="load 1" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_lt_tb.raw tran"
}
C {devices/lab_pin.sym} -3840 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} 280 -2650 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} 280 -2600 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} 280 -2700 2 0 {name=p16 sig_type=std_logic lab=vdd_stdp}
C {devices/gnd.sym} -2980 -7770 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -3050 -7840 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2910 -7840 2 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -2920 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -2920 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2960 -260 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2990 -140 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -2920 -300 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -2920 -340 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2920 -10 2 0 {name=p61 sig_type=std_logic lab=1}
C {devices/vsource.sym} 20 -2230 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 20 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} 20 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} 200 -2230 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} 200 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 200 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} 460 -2230 0 0 {name=V15 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 460 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 460 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -4010 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} 20 -2370 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 20 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 20 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 100 -2370 0 0 {name=V12 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} 100 -2320 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 100 -2420 2 0 {name=p17 sig_type=std_logic lab=ctrl_tr}
C {devices/vsource.sym} 180 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} 180 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 180 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 190 -2650 0 0 {name=V3 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 190 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 190 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} 380 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 380 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 380 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_wu}
C {devices/vsource.sym} 460 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} 460 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 460 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tr}
C {devices/vsource.sym} 20 -2510 0 0 {name=V7 value="PWL(0 0.8 124.9u 0.8 125u 0.45)"
*0.55}
C {devices/gnd.sym} 20 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 20 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} 100 -2510 0 0 {name=V8 value=0.55}
C {devices/gnd.sym} 100 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 100 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -3660 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2850 -140 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} 20 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3900 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -3760 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -7790 0 0 {name=I1 value=0}
C {devices/gnd.sym} -4040 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -2980 -7250 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -3050 -7320 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2910 -7320 2 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -3290 -7940 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -3230 -7990 2 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -3350 -7990 0 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2920 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -2920 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3230 -7690 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3510 -7840 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -4010 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -3290 -7640 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -3230 -7840 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3350 -7840 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -3350 -7870 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -3660 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3290 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -7900 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3900 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2970 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -2970 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} 180 -2370 0 0 {name=V16 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 180 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 180 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} 620 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} 620 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 620 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} 660 -1830 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 660 -1950 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -2990 -260 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} 340 -2370 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} 340 -2320 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} 340 -2420 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 730 -1890 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 670 -1740 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} 630 -1720 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 630 -1750 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 630 -1690 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 590 -1740 0 0 {name=p85 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} 340 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} 340 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 340 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2880 -260 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} 700 -2650 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 700 -2600 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 700 -2700 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -2980 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -2920 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -2920 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -3050 -6280 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -2920 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -2920 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -3050 -5760 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2920 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -2920 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -2920 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -2920 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -2920 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -2920 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -2920 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -2920 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -3050 -3680 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2910 -3680 2 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -2920 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -2920 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3660 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -3760 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -6230 0 0 {name=I4 value=0}
C {devices/gnd.sym} -4040 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -4010 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -3660 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -3760 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -6750 0 0 {name=I3 value=0}
C {devices/gnd.sym} -4040 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -4010 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -3660 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -3760 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -5190 0 0 {name=I6 value=0}
C {devices/gnd.sym} -4040 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -4010 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -3660 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -3760 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -5710 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4040 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -4010 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -3660 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -3760 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -4150 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4040 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -4010 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -3660 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -3760 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -4670 0 0 {name=I7 value=0}
C {devices/gnd.sym} -4040 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -4010 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -3660 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -3760 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -3630 0 0 {name=I9 value=0}
C {devices/gnd.sym} -4040 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -4010 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -3660 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} 580 -1870 0 0 {name=p105 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} -3510 -7320 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3510 -6800 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3050 -6800 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3510 -3680 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3050 -4200 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3510 -4200 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3050 -4720 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3510 -4720 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3050 -5240 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3510 -5240 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3510 -5760 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3510 -6280 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2910 -4200 2 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -2910 -4720 2 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -2910 -5240 2 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -2910 -5760 2 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -2910 -6280 2 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -2910 -6800 2 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/launcher.sym} 90 -1815 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2920 -160 1 0 {name=x0}
C {devices/gnd.sym} -2980 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -2920 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -2920 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -2920 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -2920 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -2920 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -2920 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -2920 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -2920 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -2920 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -2920 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2970 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2980 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -2920 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2910 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -2920 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2980 -610 1 0 {name=p319 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2970 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3660 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -3760 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -3110 0 0 {name=I10 value=0}
C {devices/gnd.sym} -4040 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -4010 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -3660 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -3760 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -2070 0 0 {name=I12 value=0}
C {devices/gnd.sym} -4040 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -4010 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -3660 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -3760 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -2590 0 0 {name=I11 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4040 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -4010 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -3660 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -3760 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4040 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -4010 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -3660 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3660 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -3760 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -1550 0 0 {name=I13 value=0}
C {devices/gnd.sym} -4040 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -4010 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -3660 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3760 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3660 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -3760 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4040 -510 0 0 {name=I15 value=0}
C {devices/gnd.sym} -4040 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3860 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -3940 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3840 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -4010 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -3660 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3900 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3760 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3510 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3510 -1080 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3510 -1600 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3510 -2640 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3510 -3160 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3660 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -3050 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2910 -560 2 0 {name=p405 sig_type=std_logic lab=vpos15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2920 -380 0 0 {name=x150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} 660 -1890 0 0 {name=x160}
C {devices/lab_pin.sym} -3050 -1080 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2910 -1080 2 0 {name=p382 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -3050 -1600 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2910 -1600 2 0 {name=p392 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -2910 -3160 2 0 {name=p394 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -3050 -3160 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3050 -2640 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2910 -2640 2 0 {name=p400 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -3510 -2120 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3050 -2120 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2910 -2120 2 0 {name=p396 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -2980 -7890 1 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -7370 1 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -6850 1 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -6330 1 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -5810 1 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -5290 1 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -4770 1 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -4250 1 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -3730 1 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -3210 1 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -2690 1 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -2170 1 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -1650 1 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2980 -1130 1 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} 580 -1900 0 0 {name=l7 lab=GND}
C {devices/launcher.sym} 80 -1675 0 0 {name=h3
descr="load 8" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -7690 0 0 {name=x2013}
C {devices/lab_pin.sym} -3350 -7720 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 260 -2370 0 0 {name=V20 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 260 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 260 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3290 -7420 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -3230 -7470 2 0 {name=p2 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -3290 -7120 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -3350 -7350 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -7270 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -3290 -7230 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -7380 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -7320 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -7170 0 0 {name=x2023}
C {devices/lab_pin.sym} -3350 -7200 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -6900 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -3230 -6950 2 0 {name=p52 sig_type=std_logic lab=vpos3}
C {devices/gnd.sym} -3290 -6600 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -3350 -6830 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -6750 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -3290 -6710 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -6860 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -6800 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -6650 0 0 {name=x2033}
C {devices/lab_pin.sym} -3350 -6680 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -6380 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -3230 -6430 2 0 {name=p77 sig_type=std_logic lab=vpos4}
C {devices/gnd.sym} -3290 -6080 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -3350 -6310 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -6230 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -3290 -6190 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -6340 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -6280 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -6130 0 0 {name=x2043}
C {devices/lab_pin.sym} -3350 -6160 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -5860 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -3230 -5910 2 0 {name=p102 sig_type=std_logic lab=vpos5}
C {devices/gnd.sym} -3290 -5560 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -3350 -5790 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -5710 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -3290 -5670 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -5820 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -5760 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -5610 0 0 {name=x2053}
C {devices/lab_pin.sym} -3350 -5640 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -5340 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -3230 -5390 2 0 {name=p122 sig_type=std_logic lab=vpos6}
C {devices/gnd.sym} -3290 -5040 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -3350 -5270 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -5190 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -3290 -5150 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -5300 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -5240 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -5090 0 0 {name=x2063}
C {devices/lab_pin.sym} -3350 -5120 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -4820 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -3230 -4870 2 0 {name=p145 sig_type=std_logic lab=vpos7}
C {devices/gnd.sym} -3290 -4520 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -3350 -4750 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -4670 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -3290 -4630 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -4780 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -4720 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -4570 0 0 {name=x2073}
C {devices/lab_pin.sym} -3350 -4600 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -4300 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -3230 -4350 2 0 {name=p157 sig_type=std_logic lab=vpos8}
C {devices/gnd.sym} -3290 -4000 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -3350 -4230 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -4150 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -3290 -4110 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -4260 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -4200 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -4050 0 0 {name=x2083}
C {devices/lab_pin.sym} -3350 -4080 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -3780 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -3230 -3830 2 0 {name=p173 sig_type=std_logic lab=vpos9}
C {devices/gnd.sym} -3290 -3480 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -3350 -3710 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -3630 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -3290 -3590 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -3740 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -3680 0 0 {name=x2092}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -3530 0 0 {name=x2093}
C {devices/lab_pin.sym} -3350 -3560 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -3260 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -3230 -3310 2 0 {name=p188 sig_type=std_logic lab=vpos10}
C {devices/gnd.sym} -3290 -2960 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -3350 -3190 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -3110 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -3290 -3070 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -3220 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -3160 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -3010 0 0 {name=x2103}
C {devices/lab_pin.sym} -3350 -3040 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -2740 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -3230 -2790 2 0 {name=p200 sig_type=std_logic lab=vpos11}
C {devices/gnd.sym} -3290 -2440 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -3350 -2670 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -2590 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -3290 -2550 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -2700 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -2640 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -2490 0 0 {name=x2113}
C {devices/lab_pin.sym} -3350 -2520 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -2220 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -3230 -2270 2 0 {name=p212 sig_type=std_logic lab=vpos12}
C {devices/gnd.sym} -3290 -1920 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -3350 -2150 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -2070 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -3290 -2030 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -2180 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -2120 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -1970 0 0 {name=x2123}
C {devices/lab_pin.sym} -3350 -2000 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -1700 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -3230 -1750 2 0 {name=p229 sig_type=std_logic lab=vpos13}
C {devices/gnd.sym} -3290 -1400 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -3350 -1630 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -1550 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -3290 -1510 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -1660 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -1600 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -1450 0 0 {name=x2133}
C {devices/lab_pin.sym} -3350 -1480 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -1180 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -3230 -1230 2 0 {name=p242 sig_type=std_logic lab=vpos14}
C {devices/gnd.sym} -3290 -880 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -3350 -1110 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -1030 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -3290 -990 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -1140 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -1080 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -930 0 0 {name=x2143}
C {devices/lab_pin.sym} -3350 -960 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3290 -660 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -3230 -710 2 0 {name=p255 sig_type=std_logic lab=vpos15}
C {devices/gnd.sym} -3290 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -3350 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3290 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -3290 -770 0 0 {name=p261 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3290 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3350 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -740 0 0 {name=p266 sig_type=std_logic lab=ctrl_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3290 -560 0 0 {name=x2152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3290 -410 0 0 {name=x2153}
C {devices/lab_pin.sym} -3350 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -3230 -7320 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3230 -7170 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3350 -7320 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3350 -7470 0 0 {name=p20 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3350 -6800 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3350 -6950 0 0 {name=p54 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3230 -6800 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3230 -6650 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3350 -6280 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3350 -6430 0 0 {name=p83 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3230 -6280 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3230 -6130 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3230 -5760 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3230 -5610 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3350 -5760 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3350 -5910 0 0 {name=p109 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3350 -5240 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3350 -5390 0 0 {name=p126 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3230 -5240 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3230 -5090 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3350 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3350 -710 0 0 {name=p147 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3230 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3230 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3350 -1080 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3350 -1230 0 0 {name=p244 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3230 -1080 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3230 -930 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3350 -1600 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3350 -1750 0 0 {name=p231 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3230 -1600 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3230 -1450 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3350 -2120 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3350 -2270 0 0 {name=p214 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3230 -2120 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3230 -1970 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3230 -2640 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3230 -2490 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3350 -2640 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3350 -2790 0 0 {name=p204 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3350 -3160 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3350 -3310 0 0 {name=p190 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3230 -3160 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3230 -3010 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3350 -3680 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3350 -3830 0 0 {name=p175 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3230 -3680 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3230 -3530 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3350 -4200 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3350 -4350 0 0 {name=p161 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3230 -4200 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3230 -4050 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3350 -4720 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3350 -4870 0 0 {name=p257 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3230 -4720 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3230 -4570 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -7990 0 0 {name=x2011}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -710 0 0 {name=x2151}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -1230 0 0 {name=x2141}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -1750 0 0 {name=x2131}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -2270 0 0 {name=x2121}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -2790 0 0 {name=x2111}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -3310 0 0 {name=x2101}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -3830 0 0 {name=x2091}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -4350 0 0 {name=x2081}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -4870 0 0 {name=x2071}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -5390 0 0 {name=x2061}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -5910 0 0 {name=x2051}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -6430 0 0 {name=x2041}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -6950 0 0 {name=x2031}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3290 -7470 0 0 {name=x2021}
C {devices/vsource.sym} 260 -2510 0 0 {name=V21 value=0.5}
C {devices/gnd.sym} 260 -2460 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} 260 -2560 2 0 {name=p268 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -680 0 0 {name=p269 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -900 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -1200 0 0 {name=p68 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -1420 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -1720 0 0 {name=p100 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -1940 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -2240 0 0 {name=p135 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -2460 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -2760 0 0 {name=p169 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -2980 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -3280 0 0 {name=p197 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -3500 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -3800 0 0 {name=p226 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -4020 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -4320 0 0 {name=p251 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -4540 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -4840 0 0 {name=p271 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -5060 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -5360 0 0 {name=p273 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -5580 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -5880 0 0 {name=p275 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -6100 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -6400 0 0 {name=p278 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -6620 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -6920 0 0 {name=p280 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -7140 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -7440 0 0 {name=p282 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -7660 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3350 -7960 0 0 {name=p284 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3350 -1260 0 0 {name=p15 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -1780 0 0 {name=p49 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -2300 0 0 {name=p69 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -2820 0 0 {name=p99 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -3340 0 0 {name=p118 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -3860 0 0 {name=p137 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -4380 0 0 {name=p155 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -4900 0 0 {name=p171 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -5420 0 0 {name=p186 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -5940 0 0 {name=p198 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -6460 0 0 {name=p210 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -6980 0 0 {name=p227 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -7500 0 0 {name=p240 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3350 -8020 0 0 {name=p253 sig_type=std_logic lab=ctrl_tr}
C {devices/vsource.sym} 540 -2650 0 0 {name=V22 value=1.8}
C {devices/gnd.sym} 540 -2600 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 540 -2700 2 0 {name=p285 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3290 -1290 0 0 {name=p24 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -1810 0 0 {name=p45 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -2330 0 0 {name=p62 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -2850 0 0 {name=p90 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -3370 0 0 {name=p112 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -3890 0 0 {name=p132 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -4410 0 0 {name=p151 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -4930 0 0 {name=p166 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -5450 0 0 {name=p181 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -5970 0 0 {name=p194 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -6490 0 0 {name=p206 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -7010 0 0 {name=p221 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -7530 0 0 {name=p236 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3290 -8050 0 0 {name=p248 sig_type=std_logic lab=vdd_tr}
C {sky130_fd_pr/nfet_01v8.sym} -2940 -1460 0 0 {name=M1
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
