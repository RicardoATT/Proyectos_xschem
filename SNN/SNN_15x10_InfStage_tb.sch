v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -1200 800 -800 {flags=graph
y1=-0.053
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 800 -400 1600 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Weights updating ;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 3200 -2400 4000 -2000 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=1}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 0 -800 800 -400 {flags=graph
y1=3
y2=4.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 800 -800 1600 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 2400 -2400 3200 -2000 {flags=graph
y1=-1.4e-06
y2=0.12
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16"
node="p0
p1"}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 2400 -1200 3200 -800 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 3200 -2000 4000 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 3200 -1600 4000 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 3200 -1200 4000 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 2400 -800 3200 -400 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 2400 -400 3200 0 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 3200 -800 4000 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 3200 -400 4000 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 800 -1200 1600 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
B 2 0 -400 800 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-0.031
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000124998
x2=0.000125041
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpre1; vpres1\\"
\\"vpre2; vpres2\\"
\\"vpre3; vpres3\\"
\\"vpre4; vpres4\\"
\\"vpre5; vpres5\\"
\\"vpre6; vpres6\\"
\\"vpre7; vpres7\\"
\\"vpre8; vpres8\\"
\\"vpre9; vpres9\\""}
N 20 -2620 20 -2600 {
lab=GND}
N 20 -2700 20 -2680 {
lab=vdd_in}
N 100 -2620 100 -2600 {
lab=GND}
N 100 -2700 100 -2680 {
lab=vdd_pre}
N -3760 -7250 -3760 -7230 {
lab=GND}
N -3760 -7410 -3760 -7390 {
lab=vdd_pre}
N -4140 -7240 -4140 -7220 {
lab=GND}
N -3940 -7340 -3940 -7320 {
lab=vc2}
N -3940 -7370 -3930 -7370 {
lab=vdd_in}
N -3930 -7400 -3930 -7370 {
lab=vdd_in}
N -3940 -7400 -3930 -7400 {
lab=vdd_in}
N -4020 -7370 -3980 -7370 {
lab=#net1}
N -4060 -7400 -3940 -7400 {
lab=vdd_in}
N -4070 -7370 -4060 -7370 {
lab=vdd_in}
N -4070 -7400 -4070 -7370 {
lab=vdd_in}
N -4070 -7400 -4060 -7400 {
lab=vdd_in}
N -4060 -7340 -4060 -7320 {
lab=#net1}
N -4060 -7320 -4000 -7320 {
lab=#net1}
N -4000 -7370 -4000 -7320 {
lab=#net1}
N -4140 -7320 -4140 -7300 {
lab=#net2}
N 280 -2620 280 -2600 {
lab=GND}
N 280 -2700 280 -2680 {
lab=vdd_stdp}
N -3080 -7780 -3080 -7770 {
lab=GND}
N -3080 -7890 -3080 -7880 {
lab=vdd_syn0}
N -3020 -7700 -3010 -7700 {
lab=GND}
N -3020 -7670 -3020 -7660 {
lab=p0}
N -3020 -270 -3020 -260 {
lab=#net3}
N -3020 -340 -3020 -330 {
lab=p0}
N -3020 -20 -3020 -10 {
lab=0}
N 20 -2200 20 -2180 {
lab=GND}
N 20 -2280 20 -2260 {
lab=uw}
N 200 -2200 200 -2180 {
lab=GND}
N 200 -2280 200 -2260 {
lab=training}
N -3620 -7320 -3610 -7320 {
lab=vpre2}
N -3090 -160 -3090 -140 {
lab=GND}
N -2950 -160 -2950 -140 {
lab=vdd_pos}
N 460 -2200 460 -2180 {
lab=GND}
N 460 -2280 460 -2260 {
lab=inference}
N -4080 -7320 -4060 -7320 {
lab=#net1}
N 20 -2340 20 -2320 {
lab=GND}
N 20 -2420 20 -2400 {
lab=ctrl_wu}
N 100 -2340 100 -2320 {
lab=GND}
N 100 -2420 100 -2400 {
lab=ctrl_tr}
N 180 -2480 180 -2460 {
lab=GND}
N 180 -2560 180 -2540 {
lab=vb_wu}
N 190 -2620 190 -2600 {
lab=GND}
N 190 -2700 190 -2680 {
lab=vdd_pos}
N 380 -2620 380 -2600 {
lab=GND}
N 380 -2700 380 -2680 {
lab=vdd_wu}
N 460 -2620 460 -2600 {
lab=GND}
N 460 -2700 460 -2680 {
lab=vdd_tr}
N 20 -2480 20 -2460 {
lab=GND}
N 20 -2560 20 -2540 {
lab=vb_pre}
N 100 -2480 100 -2460 {
lab=GND}
N 100 -2560 100 -2540 {
lab=vb_pos}
N -3150 -7840 -3140 -7840 {
lab=vpres1}
N -3020 -7840 -3010 -7840 {
lab=#net4}
N -3760 -7770 -3760 -7750 {
lab=GND}
N -3760 -7930 -3760 -7910 {
lab=vdd_pre}
N -4140 -7760 -4140 -7740 {
lab=GND}
N -3940 -7860 -3940 -7840 {
lab=vc1}
N -3940 -7890 -3930 -7890 {
lab=vdd_in}
N -3930 -7920 -3930 -7890 {
lab=vdd_in}
N -3940 -7920 -3930 -7920 {
lab=vdd_in}
N -4020 -7890 -3980 -7890 {
lab=#net5}
N -4060 -7920 -3940 -7920 {
lab=vdd_in}
N -4070 -7890 -4060 -7890 {
lab=vdd_in}
N -4070 -7920 -4070 -7890 {
lab=vdd_in}
N -4070 -7920 -4060 -7920 {
lab=vdd_in}
N -4060 -7860 -4060 -7840 {
lab=#net5}
N -4060 -7840 -4000 -7840 {
lab=#net5}
N -4000 -7890 -4000 -7840 {
lab=#net5}
N -4140 -7840 -4140 -7820 {
lab=#net6}
N -3080 -7260 -3080 -7250 {
lab=GND}
N -3080 -7370 -3080 -7360 {
lab=vdd_syn0}
N -3390 -7950 -3390 -7940 {
lab=GND}
N -3020 -7180 -3010 -7180 {
lab=GND}
N -3020 -7150 -3020 -7140 {
lab=p0}
N -3620 -7840 -3610 -7840 {
lab=vpre1}
N -4080 -7840 -4060 -7840 {
lab=#net5}
N -3390 -7650 -3390 -7640 {
lab=GND}
N -3340 -7690 -3330 -7690 {
lab=vpres1}
N -3390 -7800 -3390 -7790 {
lab=GND}
N -3340 -7990 -3330 -7990 {
lab=vpos1}
N -3340 -7840 -3330 -7840 {
lab=vpres1}
N -3150 -7320 -3140 -7320 {
lab=vpres2}
N -3020 -7320 -3010 -7320 {
lab=#net7}
N -3070 -7180 -3060 -7180 {
lab=ctrl_pos}
N -3070 -7700 -3060 -7700 {
lab=ctrl_pos}
N 180 -2340 180 -2320 {
lab=GND}
N 180 -2420 180 -2400 {
lab=ctrl_inf}
N 620 -2620 620 -2600 {
lab=GND}
N 620 -2700 620 -2680 {
lab=vdd_inh}
N 120 -4590 120 -4580 {
lab=vdd_inh}
N 340 -2340 340 -2320 {
lab=GND}
N 340 -2420 340 -2400 {
lab=ctrl_vinh}
N 120 -4300 120 -4290 {
lab=GND}
N 300 -4440 310 -4440 {
lab=inh_d}
N 150 -4040 160 -4040 {
lab=inh1}
N 120 -4050 120 -4040 {
lab=GND}
N 120 -4000 120 -3990 {
lab=inh_d}
N 80 -4040 90 -4040 {
lab=ctrl_vinh}
N 340 -2480 340 -2460 {
lab=GND}
N 340 -2560 340 -2540 {
lab=vlky}
N -3940 -7840 -3860 -7840 {
lab=vc1}
N -3860 -7880 -3850 -7880 {
lab=vlky}
N -3860 -7800 -3850 -7800 {
lab=vb_pre}
N -3860 -7360 -3850 -7360 {
lab=vlky}
N -3940 -7320 -3860 -7320 {
lab=vc2}
N -3860 -7280 -3850 -7280 {
lab=vb_pre}
N -3090 -260 -3090 -250 {
lab=inh0}
N -3060 -260 -3060 -250 {
lab=vb_pos}
N -2980 -260 -2980 -250 {
lab=vlky}
N 20 -2760 20 -2740 {
lab=GND}
N 20 -2840 20 -2820 {
lab=vdd_syn0}
N -3450 -7660 -3440 -7660 {
lab=vb_wu}
N -3020 -7820 -3020 -7800 {
lab=#net8}
N -3020 -7740 -3020 -7730 {
lab=#net9}
N -3020 -7300 -3020 -7280 {
lab=#net10}
N -3020 -7220 -3020 -7210 {
lab=#net11}
N -3080 -6740 -3080 -6730 {
lab=GND}
N -3080 -6850 -3080 -6840 {
lab=vdd_syn0}
N -3020 -6660 -3010 -6660 {
lab=GND}
N -3020 -6630 -3020 -6620 {
lab=p0}
N -3150 -6800 -3140 -6800 {
lab=vpres3}
N -3020 -6800 -3010 -6800 {
lab=#net12}
N -3070 -6660 -3060 -6660 {
lab=ctrl_pos}
N -3020 -6780 -3020 -6760 {
lab=#net13}
N -3020 -6700 -3020 -6690 {
lab=#net14}
N -3080 -6220 -3080 -6210 {
lab=GND}
N -3080 -6330 -3080 -6320 {
lab=vdd_syn0}
N -3020 -6140 -3010 -6140 {
lab=GND}
N -3020 -6110 -3020 -6100 {
lab=p0}
N -3150 -6280 -3140 -6280 {
lab=vpres4}
N -3020 -6280 -3010 -6280 {
lab=#net15}
N -3070 -6140 -3060 -6140 {
lab=ctrl_pos}
N -3020 -6260 -3020 -6240 {
lab=#net16}
N -3020 -6180 -3020 -6170 {
lab=#net17}
N -3080 -5700 -3080 -5690 {
lab=GND}
N -3080 -5810 -3080 -5800 {
lab=vdd_syn0}
N -3020 -5620 -3010 -5620 {
lab=GND}
N -3020 -5590 -3020 -5580 {
lab=p0}
N -3150 -5760 -3140 -5760 {
lab=vpres5}
N -3020 -5760 -3010 -5760 {
lab=#net18}
N -3070 -5620 -3060 -5620 {
lab=ctrl_pos}
N -3020 -5740 -3020 -5720 {
lab=#net19}
N -3020 -5660 -3020 -5650 {
lab=#net20}
N -3080 -5180 -3080 -5170 {
lab=GND}
N -3080 -5290 -3080 -5280 {
lab=vdd_syn0}
N -3020 -5100 -3010 -5100 {
lab=GND}
N -3020 -5070 -3020 -5060 {
lab=p0}
N -3150 -5240 -3140 -5240 {
lab=vpres6}
N -3020 -5240 -3010 -5240 {
lab=#net21}
N -3070 -5100 -3060 -5100 {
lab=ctrl_pos}
N -3020 -5220 -3020 -5200 {
lab=#net22}
N -3020 -5140 -3020 -5130 {
lab=#net23}
N -3080 -4660 -3080 -4650 {
lab=GND}
N -3080 -4770 -3080 -4760 {
lab=vdd_syn0}
N -3020 -4580 -3010 -4580 {
lab=GND}
N -3020 -4550 -3020 -4540 {
lab=p0}
N -3150 -4720 -3140 -4720 {
lab=vpres7}
N -3020 -4720 -3010 -4720 {
lab=#net24}
N -3070 -4580 -3060 -4580 {
lab=ctrl_pos}
N -3020 -4700 -3020 -4680 {
lab=#net25}
N -3020 -4620 -3020 -4610 {
lab=#net26}
N -3080 -4140 -3080 -4130 {
lab=GND}
N -3080 -4250 -3080 -4240 {
lab=vdd_syn0}
N -3020 -4060 -3010 -4060 {
lab=GND}
N -3020 -4030 -3020 -4020 {
lab=p0}
N -3150 -4200 -3140 -4200 {
lab=vpres8}
N -3020 -4200 -3010 -4200 {
lab=#net27}
N -3070 -4060 -3060 -4060 {
lab=ctrl_pos}
N -3020 -4180 -3020 -4160 {
lab=#net28}
N -3020 -4100 -3020 -4090 {
lab=#net29}
N -3080 -3620 -3080 -3610 {
lab=GND}
N -3080 -3730 -3080 -3720 {
lab=vdd_syn0}
N -3020 -3540 -3010 -3540 {
lab=GND}
N -3020 -3510 -3020 -3500 {
lab=p0}
N -3150 -3680 -3140 -3680 {
lab=vpres9}
N -3020 -3680 -3010 -3680 {
lab=#net30}
N -3070 -3540 -3060 -3540 {
lab=ctrl_pos}
N -3020 -3660 -3020 -3640 {
lab=#net31}
N -3020 -3580 -3020 -3570 {
lab=#net32}
N -3760 -6210 -3760 -6190 {
lab=GND}
N -3760 -6370 -3760 -6350 {
lab=vdd_pre}
N -4140 -6200 -4140 -6180 {
lab=GND}
N -3940 -6300 -3940 -6280 {
lab=vc4}
N -3940 -6330 -3930 -6330 {
lab=vdd_in}
N -3930 -6360 -3930 -6330 {
lab=vdd_in}
N -3940 -6360 -3930 -6360 {
lab=vdd_in}
N -4020 -6330 -3980 -6330 {
lab=#net33}
N -4060 -6360 -3940 -6360 {
lab=vdd_in}
N -4070 -6330 -4060 -6330 {
lab=vdd_in}
N -4070 -6360 -4070 -6330 {
lab=vdd_in}
N -4070 -6360 -4060 -6360 {
lab=vdd_in}
N -4060 -6300 -4060 -6280 {
lab=#net33}
N -4060 -6280 -4000 -6280 {
lab=#net33}
N -4000 -6330 -4000 -6280 {
lab=#net33}
N -4140 -6280 -4140 -6260 {
lab=#net34}
N -3620 -6280 -3610 -6280 {
lab=vpre4}
N -4080 -6280 -4060 -6280 {
lab=#net33}
N -3760 -6730 -3760 -6710 {
lab=GND}
N -3760 -6890 -3760 -6870 {
lab=vdd_pre}
N -4140 -6720 -4140 -6700 {
lab=GND}
N -3940 -6820 -3940 -6800 {
lab=vc3}
N -3940 -6850 -3930 -6850 {
lab=vdd_in}
N -3930 -6880 -3930 -6850 {
lab=vdd_in}
N -3940 -6880 -3930 -6880 {
lab=vdd_in}
N -4020 -6850 -3980 -6850 {
lab=#net35}
N -4060 -6880 -3940 -6880 {
lab=vdd_in}
N -4070 -6850 -4060 -6850 {
lab=vdd_in}
N -4070 -6880 -4070 -6850 {
lab=vdd_in}
N -4070 -6880 -4060 -6880 {
lab=vdd_in}
N -4060 -6820 -4060 -6800 {
lab=#net35}
N -4060 -6800 -4000 -6800 {
lab=#net35}
N -4000 -6850 -4000 -6800 {
lab=#net35}
N -4140 -6800 -4140 -6780 {
lab=#net36}
N -3620 -6800 -3610 -6800 {
lab=vpre3}
N -4080 -6800 -4060 -6800 {
lab=#net35}
N -3940 -6800 -3860 -6800 {
lab=vc3}
N -3860 -6840 -3850 -6840 {
lab=vlky}
N -3860 -6760 -3850 -6760 {
lab=vb_pre}
N -3860 -6320 -3850 -6320 {
lab=vlky}
N -3940 -6280 -3860 -6280 {
lab=vc4}
N -3860 -6240 -3850 -6240 {
lab=vb_pre}
N -3760 -5170 -3760 -5150 {
lab=GND}
N -3760 -5330 -3760 -5310 {
lab=vdd_pre}
N -4140 -5160 -4140 -5140 {
lab=GND}
N -3940 -5260 -3940 -5240 {
lab=vc6}
N -3940 -5290 -3930 -5290 {
lab=vdd_in}
N -3930 -5320 -3930 -5290 {
lab=vdd_in}
N -3940 -5320 -3930 -5320 {
lab=vdd_in}
N -4020 -5290 -3980 -5290 {
lab=#net37}
N -4060 -5320 -3940 -5320 {
lab=vdd_in}
N -4070 -5290 -4060 -5290 {
lab=vdd_in}
N -4070 -5320 -4070 -5290 {
lab=vdd_in}
N -4070 -5320 -4060 -5320 {
lab=vdd_in}
N -4060 -5260 -4060 -5240 {
lab=#net37}
N -4060 -5240 -4000 -5240 {
lab=#net37}
N -4000 -5290 -4000 -5240 {
lab=#net37}
N -4140 -5240 -4140 -5220 {
lab=#net38}
N -3620 -5240 -3610 -5240 {
lab=vpre6}
N -4080 -5240 -4060 -5240 {
lab=#net37}
N -3760 -5690 -3760 -5670 {
lab=GND}
N -3760 -5850 -3760 -5830 {
lab=vdd_pre}
N -4140 -5680 -4140 -5660 {
lab=GND}
N -3940 -5780 -3940 -5760 {
lab=vc5}
N -3940 -5810 -3930 -5810 {
lab=vdd_in}
N -3930 -5840 -3930 -5810 {
lab=vdd_in}
N -3940 -5840 -3930 -5840 {
lab=vdd_in}
N -4020 -5810 -3980 -5810 {
lab=#net39}
N -4060 -5840 -3940 -5840 {
lab=vdd_in}
N -4070 -5810 -4060 -5810 {
lab=vdd_in}
N -4070 -5840 -4070 -5810 {
lab=vdd_in}
N -4070 -5840 -4060 -5840 {
lab=vdd_in}
N -4060 -5780 -4060 -5760 {
lab=#net39}
N -4060 -5760 -4000 -5760 {
lab=#net39}
N -4000 -5810 -4000 -5760 {
lab=#net39}
N -4140 -5760 -4140 -5740 {
lab=#net40}
N -3620 -5760 -3610 -5760 {
lab=vpre5}
N -4080 -5760 -4060 -5760 {
lab=#net39}
N -3940 -5760 -3860 -5760 {
lab=vc5}
N -3860 -5800 -3850 -5800 {
lab=vlky}
N -3860 -5720 -3850 -5720 {
lab=vb_pre}
N -3860 -5280 -3850 -5280 {
lab=vlky}
N -3940 -5240 -3860 -5240 {
lab=vc6}
N -3860 -5200 -3850 -5200 {
lab=vb_pre}
N -3760 -4130 -3760 -4110 {
lab=GND}
N -3760 -4290 -3760 -4270 {
lab=vdd_pre}
N -4140 -4120 -4140 -4100 {
lab=GND}
N -3940 -4220 -3940 -4200 {
lab=vc8}
N -3940 -4250 -3930 -4250 {
lab=vdd_in}
N -3930 -4280 -3930 -4250 {
lab=vdd_in}
N -3940 -4280 -3930 -4280 {
lab=vdd_in}
N -4020 -4250 -3980 -4250 {
lab=#net41}
N -4060 -4280 -3940 -4280 {
lab=vdd_in}
N -4070 -4250 -4060 -4250 {
lab=vdd_in}
N -4070 -4280 -4070 -4250 {
lab=vdd_in}
N -4070 -4280 -4060 -4280 {
lab=vdd_in}
N -4060 -4220 -4060 -4200 {
lab=#net41}
N -4060 -4200 -4000 -4200 {
lab=#net41}
N -4000 -4250 -4000 -4200 {
lab=#net41}
N -4140 -4200 -4140 -4180 {
lab=#net42}
N -3620 -4200 -3610 -4200 {
lab=vpre8}
N -4080 -4200 -4060 -4200 {
lab=#net41}
N -3760 -4650 -3760 -4630 {
lab=GND}
N -3760 -4810 -3760 -4790 {
lab=vdd_pre}
N -4140 -4640 -4140 -4620 {
lab=GND}
N -3940 -4740 -3940 -4720 {
lab=vc7}
N -3940 -4770 -3930 -4770 {
lab=vdd_in}
N -3930 -4800 -3930 -4770 {
lab=vdd_in}
N -3940 -4800 -3930 -4800 {
lab=vdd_in}
N -4020 -4770 -3980 -4770 {
lab=#net43}
N -4060 -4800 -3940 -4800 {
lab=vdd_in}
N -4070 -4770 -4060 -4770 {
lab=vdd_in}
N -4070 -4800 -4070 -4770 {
lab=vdd_in}
N -4070 -4800 -4060 -4800 {
lab=vdd_in}
N -4060 -4740 -4060 -4720 {
lab=#net43}
N -4060 -4720 -4000 -4720 {
lab=#net43}
N -4000 -4770 -4000 -4720 {
lab=#net43}
N -4140 -4720 -4140 -4700 {
lab=#net44}
N -3620 -4720 -3610 -4720 {
lab=vpre7}
N -4080 -4720 -4060 -4720 {
lab=#net43}
N -3940 -4720 -3860 -4720 {
lab=vc7}
N -3860 -4760 -3850 -4760 {
lab=vlky}
N -3860 -4680 -3850 -4680 {
lab=vb_pre}
N -3860 -4240 -3850 -4240 {
lab=vlky}
N -3940 -4200 -3860 -4200 {
lab=vc8}
N -3860 -4160 -3850 -4160 {
lab=vb_pre}
N -3760 -3610 -3760 -3590 {
lab=GND}
N -3760 -3770 -3760 -3750 {
lab=vdd_pre}
N -4140 -3600 -4140 -3580 {
lab=GND}
N -3940 -3700 -3940 -3680 {
lab=vc9}
N -3940 -3730 -3930 -3730 {
lab=vdd_in}
N -3930 -3760 -3930 -3730 {
lab=vdd_in}
N -3940 -3760 -3930 -3760 {
lab=vdd_in}
N -4020 -3730 -3980 -3730 {
lab=#net45}
N -4060 -3760 -3940 -3760 {
lab=vdd_in}
N -4070 -3730 -4060 -3730 {
lab=vdd_in}
N -4070 -3760 -4070 -3730 {
lab=vdd_in}
N -4070 -3760 -4060 -3760 {
lab=vdd_in}
N -4060 -3700 -4060 -3680 {
lab=#net45}
N -4060 -3680 -4000 -3680 {
lab=#net45}
N -4000 -3730 -4000 -3680 {
lab=#net45}
N -4140 -3680 -4140 -3660 {
lab=#net46}
N -3620 -3680 -3610 -3680 {
lab=vpre9}
N -4080 -3680 -4060 -3680 {
lab=#net45}
N -3860 -3720 -3850 -3720 {
lab=vlky}
N -3940 -3680 -3860 -3680 {
lab=vc9}
N -3860 -3640 -3850 -3640 {
lab=vb_pre}
N 30 -4350 40 -4350 {
lab=0}
N -3080 -3100 -3080 -3090 {
lab=GND}
N -3080 -3210 -3080 -3200 {
lab=vdd_syn0}
N -3020 -3020 -3010 -3020 {
lab=GND}
N -3020 -2990 -3020 -2980 {
lab=p0}
N -3150 -3160 -3140 -3160 {
lab=vpres10}
N -3020 -3160 -3010 -3160 {
lab=#net47}
N -3070 -3020 -3060 -3020 {
lab=ctrl_pos}
N -3020 -3140 -3020 -3120 {
lab=#net48}
N -3020 -3060 -3020 -3050 {
lab=#net49}
N -3080 -2580 -3080 -2570 {
lab=GND}
N -3080 -2690 -3080 -2680 {
lab=vdd_syn0}
N -3020 -2500 -3010 -2500 {
lab=GND}
N -3020 -2470 -3020 -2460 {
lab=p0}
N -3150 -2640 -3140 -2640 {
lab=vpres11}
N -3020 -2640 -3010 -2640 {
lab=#net50}
N -3070 -2500 -3060 -2500 {
lab=ctrl_pos}
N -3020 -2620 -3020 -2600 {
lab=#net51}
N -3020 -2540 -3020 -2530 {
lab=#net52}
N -3080 -2060 -3080 -2050 {
lab=GND}
N -3080 -2170 -3080 -2160 {
lab=vdd_syn0}
N -3020 -1980 -3010 -1980 {
lab=GND}
N -3020 -1950 -3020 -1940 {
lab=p0}
N -3150 -2120 -3140 -2120 {
lab=vpres12}
N -3020 -2120 -3010 -2120 {
lab=#net53}
N -3070 -1980 -3060 -1980 {
lab=ctrl_pos}
N -3020 -2100 -3020 -2080 {
lab=#net54}
N -3020 -2020 -3020 -2010 {
lab=#net55}
N -3080 -1540 -3080 -1530 {
lab=GND}
N -3080 -1650 -3080 -1640 {
lab=vdd_syn0}
N -3020 -1460 -3010 -1460 {
lab=GND}
N -3020 -1430 -3020 -1420 {
lab=p0}
N -3150 -1600 -3140 -1600 {
lab=vpres13}
N -3020 -1600 -3010 -1600 {
lab=#net56}
N -3070 -1460 -3060 -1460 {
lab=ctrl_pos}
N -3020 -1580 -3020 -1560 {
lab=#net57}
N -3020 -1500 -3020 -1490 {
lab=#net58}
N -3080 -1020 -3080 -1010 {
lab=GND}
N -3080 -1130 -3080 -1120 {
lab=vdd_syn0}
N -3020 -940 -3010 -940 {
lab=GND}
N -3020 -910 -3020 -900 {
lab=p0}
N -3070 -940 -3060 -940 {
lab=ctrl_pos}
N -3020 -1060 -3020 -1040 {
lab=#net59}
N -3020 -980 -3020 -970 {
lab=#net60}
N -3080 -500 -3080 -490 {
lab=GND}
N -3080 -610 -3080 -600 {
lab=vdd_syn0}
N -3020 -420 -3010 -420 {
lab=GND}
N -3020 -390 -3020 -380 {
lab=p0}
N -3020 -560 -3010 -560 {
lab=#net61}
N -3070 -420 -3060 -420 {
lab=ctrl_pos}
N -3020 -540 -3020 -520 {
lab=#net62}
N -3020 -460 -3020 -450 {
lab=#net63}
N -3760 -3090 -3760 -3070 {
lab=GND}
N -3760 -3250 -3760 -3230 {
lab=vdd_pre}
N -4140 -3080 -4140 -3060 {
lab=GND}
N -3940 -3180 -3940 -3160 {
lab=vc10}
N -3940 -3210 -3930 -3210 {
lab=vdd_in}
N -3930 -3240 -3930 -3210 {
lab=vdd_in}
N -3940 -3240 -3930 -3240 {
lab=vdd_in}
N -4020 -3210 -3980 -3210 {
lab=#net64}
N -4060 -3240 -3940 -3240 {
lab=vdd_in}
N -4070 -3210 -4060 -3210 {
lab=vdd_in}
N -4070 -3240 -4070 -3210 {
lab=vdd_in}
N -4070 -3240 -4060 -3240 {
lab=vdd_in}
N -4060 -3180 -4060 -3160 {
lab=#net64}
N -4060 -3160 -4000 -3160 {
lab=#net64}
N -4000 -3210 -4000 -3160 {
lab=#net64}
N -4140 -3160 -4140 -3140 {
lab=#net65}
N -3620 -3160 -3610 -3160 {
lab=vpre10}
N -4080 -3160 -4060 -3160 {
lab=#net64}
N -3860 -3200 -3850 -3200 {
lab=vlky}
N -3940 -3160 -3860 -3160 {
lab=vc10}
N -3860 -3120 -3850 -3120 {
lab=vb_pre}
N -3760 -2050 -3760 -2030 {
lab=GND}
N -3760 -2210 -3760 -2190 {
lab=vdd_pre}
N -4140 -2040 -4140 -2020 {
lab=GND}
N -3940 -2140 -3940 -2120 {
lab=vc12}
N -3940 -2170 -3930 -2170 {
lab=vdd_in}
N -3930 -2200 -3930 -2170 {
lab=vdd_in}
N -3940 -2200 -3930 -2200 {
lab=vdd_in}
N -4020 -2170 -3980 -2170 {
lab=#net66}
N -4060 -2200 -3940 -2200 {
lab=vdd_in}
N -4070 -2170 -4060 -2170 {
lab=vdd_in}
N -4070 -2200 -4070 -2170 {
lab=vdd_in}
N -4070 -2200 -4060 -2200 {
lab=vdd_in}
N -4060 -2140 -4060 -2120 {
lab=#net66}
N -4060 -2120 -4000 -2120 {
lab=#net66}
N -4000 -2170 -4000 -2120 {
lab=#net66}
N -4140 -2120 -4140 -2100 {
lab=#net67}
N -3620 -2120 -3610 -2120 {
lab=vpre12}
N -4080 -2120 -4060 -2120 {
lab=#net66}
N -3760 -2570 -3760 -2550 {
lab=GND}
N -3760 -2730 -3760 -2710 {
lab=vdd_pre}
N -4140 -2560 -4140 -2540 {
lab=GND}
N -3940 -2660 -3940 -2640 {
lab=vc11}
N -3940 -2690 -3930 -2690 {
lab=vdd_in}
N -3930 -2720 -3930 -2690 {
lab=vdd_in}
N -3940 -2720 -3930 -2720 {
lab=vdd_in}
N -4020 -2690 -3980 -2690 {
lab=#net68}
N -4060 -2720 -3940 -2720 {
lab=vdd_in}
N -4070 -2690 -4060 -2690 {
lab=vdd_in}
N -4070 -2720 -4070 -2690 {
lab=vdd_in}
N -4070 -2720 -4060 -2720 {
lab=vdd_in}
N -4060 -2660 -4060 -2640 {
lab=#net68}
N -4060 -2640 -4000 -2640 {
lab=#net68}
N -4000 -2690 -4000 -2640 {
lab=#net68}
N -4140 -2640 -4140 -2620 {
lab=#net69}
N -3620 -2640 -3610 -2640 {
lab=vpre11}
N -4080 -2640 -4060 -2640 {
lab=#net68}
N -3940 -2640 -3860 -2640 {
lab=vc11}
N -3860 -2680 -3850 -2680 {
lab=vlky}
N -3860 -2600 -3850 -2600 {
lab=vb_pre}
N -3860 -2160 -3850 -2160 {
lab=vlky}
N -3940 -2120 -3860 -2120 {
lab=vc12}
N -3860 -2080 -3850 -2080 {
lab=vb_pre}
N -3760 -1010 -3760 -990 {
lab=GND}
N -3760 -1170 -3760 -1150 {
lab=vdd_pre}
N -4140 -1000 -4140 -980 {
lab=GND}
N -3940 -1100 -3940 -1080 {
lab=vc14}
N -3940 -1130 -3930 -1130 {
lab=vdd_in}
N -3930 -1160 -3930 -1130 {
lab=vdd_in}
N -3940 -1160 -3930 -1160 {
lab=vdd_in}
N -4020 -1130 -3980 -1130 {
lab=#net70}
N -4060 -1160 -3940 -1160 {
lab=vdd_in}
N -4070 -1130 -4060 -1130 {
lab=vdd_in}
N -4070 -1160 -4070 -1130 {
lab=vdd_in}
N -4070 -1160 -4060 -1160 {
lab=vdd_in}
N -4060 -1100 -4060 -1080 {
lab=#net70}
N -4060 -1080 -4000 -1080 {
lab=#net70}
N -4000 -1130 -4000 -1080 {
lab=#net70}
N -4140 -1080 -4140 -1060 {
lab=#net71}
N -3620 -1080 -3610 -1080 {
lab=vpre14}
N -4080 -1080 -4060 -1080 {
lab=#net70}
N -3760 -1530 -3760 -1510 {
lab=GND}
N -3760 -1690 -3760 -1670 {
lab=vdd_pre}
N -4140 -1520 -4140 -1500 {
lab=GND}
N -3940 -1620 -3940 -1600 {
lab=vc13}
N -3940 -1650 -3930 -1650 {
lab=vdd_in}
N -3930 -1680 -3930 -1650 {
lab=vdd_in}
N -3940 -1680 -3930 -1680 {
lab=vdd_in}
N -4020 -1650 -3980 -1650 {
lab=#net72}
N -4060 -1680 -3940 -1680 {
lab=vdd_in}
N -4070 -1650 -4060 -1650 {
lab=vdd_in}
N -4070 -1680 -4070 -1650 {
lab=vdd_in}
N -4070 -1680 -4060 -1680 {
lab=vdd_in}
N -4060 -1620 -4060 -1600 {
lab=#net72}
N -4060 -1600 -4000 -1600 {
lab=#net72}
N -4000 -1650 -4000 -1600 {
lab=#net72}
N -4140 -1600 -4140 -1580 {
lab=#net73}
N -3620 -1600 -3610 -1600 {
lab=vpre13}
N -4080 -1600 -4060 -1600 {
lab=#net72}
N -3940 -1600 -3860 -1600 {
lab=vc13}
N -3860 -1640 -3850 -1640 {
lab=vlky}
N -3860 -1560 -3850 -1560 {
lab=vb_pre}
N -3860 -1120 -3850 -1120 {
lab=vlky}
N -3940 -1080 -3860 -1080 {
lab=vc14}
N -3860 -1040 -3850 -1040 {
lab=vb_pre}
N -3760 -490 -3760 -470 {
lab=GND}
N -3760 -650 -3760 -630 {
lab=vdd_pre}
N -4140 -480 -4140 -460 {
lab=GND}
N -3940 -580 -3940 -560 {
lab=vc15}
N -3940 -610 -3930 -610 {
lab=vdd_in}
N -3930 -640 -3930 -610 {
lab=vdd_in}
N -3940 -640 -3930 -640 {
lab=vdd_in}
N -4020 -610 -3980 -610 {
lab=#net74}
N -4060 -640 -3940 -640 {
lab=vdd_in}
N -4070 -610 -4060 -610 {
lab=vdd_in}
N -4070 -640 -4070 -610 {
lab=vdd_in}
N -4070 -640 -4060 -640 {
lab=vdd_in}
N -4060 -580 -4060 -560 {
lab=#net74}
N -4060 -560 -4000 -560 {
lab=#net74}
N -4000 -610 -4000 -560 {
lab=#net74}
N -4140 -560 -4140 -540 {
lab=#net75}
N -3620 -560 -3610 -560 {
lab=vpre15}
N -4080 -560 -4060 -560 {
lab=#net74}
N -3860 -600 -3850 -600 {
lab=vlky}
N -3940 -560 -3860 -560 {
lab=vc15}
N -3860 -520 -3850 -520 {
lab=vb_pre}
N -3450 -8020 -3440 -8020 {
lab=ctrl_tr}
N -3450 -7870 -3440 -7870 {
lab=ctrl_inf}
N -3390 -7750 -3390 -7730 {
lab=vdd_wu}
N -3390 -7900 -3390 -7880 {
lab=vdd_inf}
N -3390 -8050 -3390 -8030 {
lab=vdd_tr}
N -3450 -7720 -3440 -7720 {
lab=ctrl_wu}
N -3440 -7720 -3440 -7690 {
lab=ctrl_wu}
N 260 -2340 260 -2320 {
lab=GND}
N 260 -2420 260 -2400 {
lab=ctrl_pos}
N -3390 -7430 -3390 -7420 {
lab=GND}
N -3390 -7130 -3390 -7120 {
lab=GND}
N -3340 -7170 -3330 -7170 {
lab=vpres2}
N -3390 -7280 -3390 -7270 {
lab=GND}
N -3450 -7470 -3440 -7470 {
lab=vpre2}
N -3340 -7470 -3330 -7470 {
lab=vpos2}
N -3340 -7320 -3330 -7320 {
lab=vpres2}
N -3450 -7140 -3440 -7140 {
lab=vb_wu}
N -3450 -7500 -3440 -7500 {
lab=ctrl_tr}
N -3450 -7350 -3440 -7350 {
lab=ctrl_inf}
N -3390 -7230 -3390 -7210 {
lab=vdd_wu}
N -3390 -7380 -3390 -7360 {
lab=vdd_inf}
N -3390 -7530 -3390 -7510 {
lab=vdd_tr}
N -3450 -7200 -3440 -7200 {
lab=ctrl_wu}
N -3440 -7200 -3440 -7170 {
lab=ctrl_wu}
N -3390 -6910 -3390 -6900 {
lab=GND}
N -3390 -6610 -3390 -6600 {
lab=GND}
N -3340 -6650 -3330 -6650 {
lab=vpres3}
N -3390 -6760 -3390 -6750 {
lab=GND}
N -3450 -6800 -3440 -6800 {
lab=vpre3}
N -3450 -6950 -3440 -6950 {
lab=vpre3}
N -3340 -6950 -3330 -6950 {
lab=vpos3}
N -3340 -6800 -3330 -6800 {
lab=vpres3}
N -3450 -6620 -3440 -6620 {
lab=vb_wu}
N -3450 -6980 -3440 -6980 {
lab=ctrl_tr}
N -3450 -6830 -3440 -6830 {
lab=ctrl_inf}
N -3390 -6710 -3390 -6690 {
lab=vdd_wu}
N -3390 -6860 -3390 -6840 {
lab=vdd_inf}
N -3390 -7010 -3390 -6990 {
lab=vdd_tr}
N -3450 -6680 -3440 -6680 {
lab=ctrl_wu}
N -3440 -6680 -3440 -6650 {
lab=ctrl_wu}
N -3390 -6390 -3390 -6380 {
lab=GND}
N -3390 -6090 -3390 -6080 {
lab=GND}
N -3340 -6130 -3330 -6130 {
lab=vpres4}
N -3390 -6240 -3390 -6230 {
lab=GND}
N -3450 -6280 -3440 -6280 {
lab=vpre4}
N -3450 -6430 -3440 -6430 {
lab=vpre4}
N -3340 -6430 -3330 -6430 {
lab=vpos4}
N -3340 -6280 -3330 -6280 {
lab=vpres4}
N -3450 -6100 -3440 -6100 {
lab=vb_wu}
N -3450 -6460 -3440 -6460 {
lab=ctrl_tr}
N -3450 -6310 -3440 -6310 {
lab=ctrl_inf}
N -3390 -6190 -3390 -6170 {
lab=vdd_wu}
N -3390 -6340 -3390 -6320 {
lab=vdd_inf}
N -3390 -6490 -3390 -6470 {
lab=vdd_tr}
N -3450 -6160 -3440 -6160 {
lab=ctrl_wu}
N -3440 -6160 -3440 -6130 {
lab=ctrl_wu}
N -3390 -5870 -3390 -5860 {
lab=GND}
N -3390 -5570 -3390 -5560 {
lab=GND}
N -3340 -5610 -3330 -5610 {
lab=vpres5}
N -3390 -5720 -3390 -5710 {
lab=GND}
N -3450 -5760 -3440 -5760 {
lab=vpre5}
N -3450 -5910 -3440 -5910 {
lab=vpre5}
N -3340 -5910 -3330 -5910 {
lab=vpos5}
N -3340 -5760 -3330 -5760 {
lab=vpres5}
N -3450 -5580 -3440 -5580 {
lab=vb_wu}
N -3450 -5940 -3440 -5940 {
lab=ctrl_tr}
N -3450 -5790 -3440 -5790 {
lab=ctrl_inf}
N -3390 -5670 -3390 -5650 {
lab=vdd_wu}
N -3390 -5820 -3390 -5800 {
lab=vdd_inf}
N -3390 -5970 -3390 -5950 {
lab=vdd_tr}
N -3450 -5640 -3440 -5640 {
lab=ctrl_wu}
N -3440 -5640 -3440 -5610 {
lab=ctrl_wu}
N -3390 -5350 -3390 -5340 {
lab=GND}
N -3390 -5050 -3390 -5040 {
lab=GND}
N -3340 -5090 -3330 -5090 {
lab=vpres6}
N -3390 -5200 -3390 -5190 {
lab=GND}
N -3450 -5240 -3440 -5240 {
lab=vpre6}
N -3450 -5390 -3440 -5390 {
lab=vpre6}
N -3340 -5390 -3330 -5390 {
lab=vpos6}
N -3340 -5240 -3330 -5240 {
lab=vpres6}
N -3450 -5060 -3440 -5060 {
lab=vb_wu}
N -3450 -5420 -3440 -5420 {
lab=ctrl_tr}
N -3450 -5270 -3440 -5270 {
lab=ctrl_inf}
N -3390 -5150 -3390 -5130 {
lab=vdd_wu}
N -3390 -5300 -3390 -5280 {
lab=vdd_inf}
N -3390 -5450 -3390 -5430 {
lab=vdd_tr}
N -3450 -5120 -3440 -5120 {
lab=ctrl_wu}
N -3440 -5120 -3440 -5090 {
lab=ctrl_wu}
N -3390 -4830 -3390 -4820 {
lab=GND}
N -3390 -4530 -3390 -4520 {
lab=GND}
N -3340 -4570 -3330 -4570 {
lab=vpres7}
N -3390 -4680 -3390 -4670 {
lab=GND}
N -3450 -4720 -3440 -4720 {
lab=vpre7}
N -3450 -4870 -3440 -4870 {
lab=vpre7}
N -3340 -4870 -3330 -4870 {
lab=vpos7}
N -3340 -4720 -3330 -4720 {
lab=vpres7}
N -3450 -4540 -3440 -4540 {
lab=vb_wu}
N -3450 -4900 -3440 -4900 {
lab=ctrl_tr}
N -3450 -4750 -3440 -4750 {
lab=ctrl_inf}
N -3390 -4630 -3390 -4610 {
lab=vdd_wu}
N -3390 -4780 -3390 -4760 {
lab=vdd_inf}
N -3390 -4930 -3390 -4910 {
lab=vdd_tr}
N -3450 -4600 -3440 -4600 {
lab=ctrl_wu}
N -3440 -4600 -3440 -4570 {
lab=ctrl_wu}
N -3390 -4310 -3390 -4300 {
lab=GND}
N -3390 -4010 -3390 -4000 {
lab=GND}
N -3340 -4050 -3330 -4050 {
lab=vpres8}
N -3390 -4160 -3390 -4150 {
lab=GND}
N -3450 -4200 -3440 -4200 {
lab=vpre8}
N -3450 -4350 -3440 -4350 {
lab=vpre8}
N -3340 -4350 -3330 -4350 {
lab=vpos8}
N -3340 -4200 -3330 -4200 {
lab=vpres8}
N -3450 -4020 -3440 -4020 {
lab=vb_wu}
N -3450 -4380 -3440 -4380 {
lab=ctrl_tr}
N -3450 -4230 -3440 -4230 {
lab=ctrl_inf}
N -3390 -4110 -3390 -4090 {
lab=vdd_wu}
N -3390 -4260 -3390 -4240 {
lab=vdd_inf}
N -3390 -4410 -3390 -4390 {
lab=vdd_tr}
N -3450 -4080 -3440 -4080 {
lab=ctrl_wu}
N -3440 -4080 -3440 -4050 {
lab=ctrl_wu}
N -3390 -3790 -3390 -3780 {
lab=GND}
N -3390 -3490 -3390 -3480 {
lab=GND}
N -3340 -3530 -3330 -3530 {
lab=vpres9}
N -3390 -3640 -3390 -3630 {
lab=GND}
N -3450 -3680 -3440 -3680 {
lab=vpre9}
N -3450 -3830 -3440 -3830 {
lab=vpre9}
N -3340 -3830 -3330 -3830 {
lab=vpos9}
N -3340 -3680 -3330 -3680 {
lab=vpres9}
N -3450 -3500 -3440 -3500 {
lab=vb_wu}
N -3450 -3860 -3440 -3860 {
lab=ctrl_tr}
N -3450 -3710 -3440 -3710 {
lab=ctrl_inf}
N -3390 -3590 -3390 -3570 {
lab=vdd_wu}
N -3390 -3740 -3390 -3720 {
lab=vdd_inf}
N -3390 -3890 -3390 -3870 {
lab=vdd_tr}
N -3450 -3560 -3440 -3560 {
lab=ctrl_wu}
N -3440 -3560 -3440 -3530 {
lab=ctrl_wu}
N -3390 -3270 -3390 -3260 {
lab=GND}
N -3390 -2970 -3390 -2960 {
lab=GND}
N -3340 -3010 -3330 -3010 {
lab=vpres10}
N -3390 -3120 -3390 -3110 {
lab=GND}
N -3450 -3160 -3440 -3160 {
lab=vpre10}
N -3450 -3310 -3440 -3310 {
lab=vpre10}
N -3340 -3310 -3330 -3310 {
lab=vpos10}
N -3340 -3160 -3330 -3160 {
lab=vpres10}
N -3450 -2980 -3440 -2980 {
lab=vb_wu}
N -3450 -3340 -3440 -3340 {
lab=ctrl_tr}
N -3450 -3190 -3440 -3190 {
lab=ctrl_inf}
N -3390 -3070 -3390 -3050 {
lab=vdd_wu}
N -3390 -3220 -3390 -3200 {
lab=vdd_inf}
N -3390 -3370 -3390 -3350 {
lab=vdd_tr}
N -3450 -3040 -3440 -3040 {
lab=ctrl_wu}
N -3440 -3040 -3440 -3010 {
lab=ctrl_wu}
N -3390 -2750 -3390 -2740 {
lab=GND}
N -3390 -2450 -3390 -2440 {
lab=GND}
N -3340 -2490 -3330 -2490 {
lab=vpres11}
N -3390 -2600 -3390 -2590 {
lab=GND}
N -3450 -2640 -3440 -2640 {
lab=vpre11}
N -3450 -2790 -3440 -2790 {
lab=vpre11}
N -3340 -2790 -3330 -2790 {
lab=vpos11}
N -3340 -2640 -3330 -2640 {
lab=vpres11}
N -3450 -2460 -3440 -2460 {
lab=vb_wu}
N -3450 -2820 -3440 -2820 {
lab=ctrl_tr}
N -3450 -2670 -3440 -2670 {
lab=ctrl_inf}
N -3390 -2550 -3390 -2530 {
lab=vdd_wu}
N -3390 -2700 -3390 -2680 {
lab=vdd_inf}
N -3390 -2850 -3390 -2830 {
lab=vdd_tr}
N -3450 -2520 -3440 -2520 {
lab=ctrl_wu}
N -3440 -2520 -3440 -2490 {
lab=ctrl_wu}
N -3390 -2230 -3390 -2220 {
lab=GND}
N -3390 -1930 -3390 -1920 {
lab=GND}
N -3340 -1970 -3330 -1970 {
lab=vpres12}
N -3390 -2080 -3390 -2070 {
lab=GND}
N -3450 -2120 -3440 -2120 {
lab=vpre12}
N -3450 -2270 -3440 -2270 {
lab=vpre12}
N -3340 -2270 -3330 -2270 {
lab=vpos12}
N -3340 -2120 -3330 -2120 {
lab=vpres12}
N -3450 -1940 -3440 -1940 {
lab=vb_wu}
N -3450 -2300 -3440 -2300 {
lab=ctrl_tr}
N -3450 -2150 -3440 -2150 {
lab=ctrl_inf}
N -3390 -2030 -3390 -2010 {
lab=vdd_wu}
N -3390 -2180 -3390 -2160 {
lab=vdd_inf}
N -3390 -2330 -3390 -2310 {
lab=vdd_tr}
N -3450 -2000 -3440 -2000 {
lab=ctrl_wu}
N -3440 -2000 -3440 -1970 {
lab=ctrl_wu}
N -3390 -1710 -3390 -1700 {
lab=GND}
N -3390 -1410 -3390 -1400 {
lab=GND}
N -3340 -1450 -3330 -1450 {
lab=vpres13}
N -3390 -1560 -3390 -1550 {
lab=GND}
N -3450 -1600 -3440 -1600 {
lab=vpre13}
N -3450 -1750 -3440 -1750 {
lab=vpre13}
N -3340 -1750 -3330 -1750 {
lab=vpos13}
N -3340 -1600 -3330 -1600 {
lab=vpres13}
N -3450 -1420 -3440 -1420 {
lab=vb_wu}
N -3450 -1780 -3440 -1780 {
lab=ctrl_tr}
N -3450 -1630 -3440 -1630 {
lab=ctrl_inf}
N -3390 -1510 -3390 -1490 {
lab=vdd_wu}
N -3390 -1660 -3390 -1640 {
lab=vdd_inf}
N -3390 -1810 -3390 -1790 {
lab=vdd_tr}
N -3450 -1480 -3440 -1480 {
lab=ctrl_wu}
N -3440 -1480 -3440 -1450 {
lab=ctrl_wu}
N -3390 -1190 -3390 -1180 {
lab=GND}
N -3390 -890 -3390 -880 {
lab=GND}
N -3340 -930 -3330 -930 {
lab=vpres14}
N -3390 -1040 -3390 -1030 {
lab=GND}
N -3450 -1080 -3440 -1080 {
lab=vpre14}
N -3450 -1230 -3440 -1230 {
lab=vpre14}
N -3340 -1230 -3330 -1230 {
lab=vpos14}
N -3450 -900 -3440 -900 {
lab=vb_wu}
N -3450 -1260 -3440 -1260 {
lab=ctrl_tr}
N -3450 -1110 -3440 -1110 {
lab=ctrl_inf}
N -3390 -990 -3390 -970 {
lab=vdd_wu}
N -3390 -1140 -3390 -1120 {
lab=vdd_inf}
N -3390 -1290 -3390 -1270 {
lab=vdd_tr}
N -3450 -960 -3440 -960 {
lab=ctrl_wu}
N -3440 -960 -3440 -930 {
lab=ctrl_wu}
N -3390 -670 -3390 -660 {
lab=GND}
N -3390 -370 -3390 -360 {
lab=GND}
N -3340 -410 -3330 -410 {
lab=vpres15}
N -3390 -520 -3390 -510 {
lab=GND}
N -3450 -710 -3440 -710 {
lab=vpre15}
N -3340 -710 -3330 -710 {
lab=vpos15}
N -3450 -380 -3440 -380 {
lab=vb_wu}
N -3450 -740 -3440 -740 {
lab=ctrl_tr}
N -3450 -590 -3440 -590 {
lab=ctrl_inf}
N -3390 -470 -3390 -450 {
lab=vdd_wu}
N -3390 -620 -3390 -600 {
lab=vdd_inf}
N -3390 -770 -3390 -750 {
lab=vdd_tr}
N -3450 -440 -3440 -440 {
lab=ctrl_wu}
N -3440 -440 -3440 -410 {
lab=ctrl_wu}
N -3450 -7990 -3440 -7990 {
lab=vpre1}
N -3450 -7840 -3440 -7840 {
lab=vpre1}
N -3450 -7320 -3440 -7320 {
lab=vpre2}
N -3450 -560 -3440 -560 {
lab=vpre15}
N -3340 -560 -3330 -560 {
lab=vpres15}
N -3150 -560 -3140 -560 {
lab=vpres15}
N -3150 -1080 -3140 -1080 {
lab=vpres14}
N -3020 -1080 -3010 -1080 {
lab=#net76}
N -3340 -1080 -3330 -1080 {
lab=vpres14}
N 260 -2480 260 -2460 {
lab=GND}
N 260 -2560 260 -2540 {
lab=vb_tr}
N -3450 -680 -3440 -680 {
lab=vb_tr}
N -3450 -1200 -3440 -1200 {
lab=vb_tr}
N -3450 -1720 -3440 -1720 {
lab=vb_tr}
N -3450 -2240 -3440 -2240 {
lab=vb_tr}
N -3450 -2760 -3440 -2760 {
lab=vb_tr}
N -3450 -3280 -3440 -3280 {
lab=vb_tr}
N -3450 -3800 -3440 -3800 {
lab=vb_tr}
N -3450 -4320 -3440 -4320 {
lab=vb_tr}
N -3450 -4840 -3440 -4840 {
lab=vb_tr}
N -3450 -5360 -3440 -5360 {
lab=vb_tr}
N -3450 -5880 -3440 -5880 {
lab=vb_tr}
N -3450 -6400 -3440 -6400 {
lab=vb_tr}
N -3450 -6920 -3440 -6920 {
lab=vb_tr}
N -3450 -7440 -3440 -7440 {
lab=vb_tr}
N -3450 -7960 -3440 -7960 {
lab=vb_tr}
N 540 -2620 540 -2600 {
lab=GND}
N 540 -2700 540 -2680 {
lab=vdd_inf}
N -2700 -270 -2700 -260 {
lab=#net77}
N -2700 -340 -2700 -330 {
lab=p1}
N -2700 -20 -2700 -10 {
lab=1}
N -2770 -160 -2770 -140 {
lab=GND}
N -2630 -160 -2630 -140 {
lab=vdd_pos}
N -2770 -260 -2770 -250 {
lab=inh1}
N -2740 -260 -2740 -250 {
lab=vb_pos}
N -2660 -260 -2660 -250 {
lab=vlky}
N -2380 -270 -2380 -260 {
lab=#net78}
N -2380 -340 -2380 -330 {
lab=p2}
N -2380 -20 -2380 -10 {
lab=2}
N -2450 -160 -2450 -140 {
lab=GND}
N -2310 -160 -2310 -140 {
lab=vdd_pos}
N -2450 -260 -2450 -250 {
lab=inh2}
N -2420 -260 -2420 -250 {
lab=vb_pos}
N -2340 -260 -2340 -250 {
lab=vlky}
N -2060 -270 -2060 -260 {
lab=#net79}
N -2060 -340 -2060 -330 {
lab=p3}
N -2060 -20 -2060 -10 {
lab=3}
N -2130 -160 -2130 -140 {
lab=GND}
N -1990 -160 -1990 -140 {
lab=vdd_pos}
N -2130 -260 -2130 -250 {
lab=inh3}
N -2100 -260 -2100 -250 {
lab=vb_pos}
N -2020 -260 -2020 -250 {
lab=vlky}
N -1740 -270 -1740 -260 {
lab=#net80}
N -1740 -340 -1740 -330 {
lab=p4}
N -1740 -20 -1740 -10 {
lab=4}
N -1810 -160 -1810 -140 {
lab=GND}
N -1670 -160 -1670 -140 {
lab=vdd_pos}
N -1810 -260 -1810 -250 {
lab=inh4}
N -1780 -260 -1780 -250 {
lab=vb_pos}
N -1700 -260 -1700 -250 {
lab=vlky}
N -1420 -270 -1420 -260 {
lab=#net81}
N -1420 -340 -1420 -330 {
lab=p5}
N -1420 -20 -1420 -10 {
lab=5}
N -1490 -160 -1490 -140 {
lab=GND}
N -1350 -160 -1350 -140 {
lab=vdd_pos}
N -1490 -260 -1490 -250 {
lab=inh5}
N -1460 -260 -1460 -250 {
lab=vb_pos}
N -1380 -260 -1380 -250 {
lab=vlky}
N -1100 -270 -1100 -260 {
lab=#net82}
N -1100 -340 -1100 -330 {
lab=p6}
N -1100 -20 -1100 -10 {
lab=6}
N -1170 -160 -1170 -140 {
lab=GND}
N -1030 -160 -1030 -140 {
lab=vdd_pos}
N -1170 -260 -1170 -250 {
lab=inh6}
N -1140 -260 -1140 -250 {
lab=vb_pos}
N -1060 -260 -1060 -250 {
lab=vlky}
N -780 -270 -780 -260 {
lab=#net83}
N -780 -340 -780 -330 {
lab=p7}
N -780 -20 -780 -10 {
lab=7}
N -850 -160 -850 -140 {
lab=GND}
N -710 -160 -710 -140 {
lab=vdd_pos}
N -850 -260 -850 -250 {
lab=inh7}
N -820 -260 -820 -250 {
lab=vb_pos}
N -740 -260 -740 -250 {
lab=vlky}
N -460 -270 -460 -260 {
lab=#net84}
N -460 -340 -460 -330 {
lab=p8}
N -460 -20 -460 -10 {
lab=8}
N -530 -160 -530 -140 {
lab=GND}
N -390 -160 -390 -140 {
lab=vdd_pos}
N -530 -260 -530 -250 {
lab=inh8}
N -500 -260 -500 -250 {
lab=vb_pos}
N -420 -260 -420 -250 {
lab=vlky}
N -140 -270 -140 -260 {
lab=#net85}
N -140 -340 -140 -330 {
lab=p9}
N -140 -20 -140 -10 {
lab=9}
N -210 -160 -210 -140 {
lab=GND}
N -70 -160 -70 -140 {
lab=vdd_pos}
N -210 -260 -210 -250 {
lab=inh9}
N -180 -260 -180 -250 {
lab=vb_pos}
N -100 -260 -100 -250 {
lab=vlky}
N -2760 -7780 -2760 -7770 {
lab=GND}
N -2760 -7890 -2760 -7880 {
lab=vdd_syn1}
N -2700 -7700 -2690 -7700 {
lab=GND}
N -2700 -7670 -2700 -7660 {
lab=p1}
N -2830 -7840 -2820 -7840 {
lab=vpres1}
N -2700 -7840 -2690 -7840 {
lab=#net86}
N -2750 -7700 -2740 -7700 {
lab=ctrl_pos}
N -2700 -7820 -2700 -7800 {
lab=#net87}
N -2700 -7740 -2700 -7730 {
lab=#net88}
N 150 -3900 160 -3900 {
lab=inh2}
N 120 -3910 120 -3900 {
lab=GND}
N 120 -3860 120 -3850 {
lab=inh_d}
N 80 -3900 90 -3900 {
lab=ctrl_vinh}
N 150 -3760 160 -3760 {
lab=inh3}
N 120 -3770 120 -3760 {
lab=GND}
N 120 -3720 120 -3710 {
lab=inh_d}
N 80 -3760 90 -3760 {
lab=ctrl_vinh}
N 150 -3620 160 -3620 {
lab=inh4}
N 120 -3630 120 -3620 {
lab=GND}
N 120 -3580 120 -3570 {
lab=inh_d}
N 80 -3620 90 -3620 {
lab=ctrl_vinh}
N 150 -3480 160 -3480 {
lab=inh5}
N 120 -3490 120 -3480 {
lab=GND}
N 120 -3440 120 -3430 {
lab=inh_d}
N 80 -3480 90 -3480 {
lab=ctrl_vinh}
N 150 -3340 160 -3340 {
lab=inh6}
N 120 -3350 120 -3340 {
lab=GND}
N 120 -3300 120 -3290 {
lab=inh_d}
N 80 -3340 90 -3340 {
lab=ctrl_vinh}
N 150 -3200 160 -3200 {
lab=inh7}
N 120 -3210 120 -3200 {
lab=GND}
N 120 -3160 120 -3150 {
lab=inh_d}
N 80 -3200 90 -3200 {
lab=ctrl_vinh}
N 150 -3060 160 -3060 {
lab=inh8}
N 120 -3070 120 -3060 {
lab=GND}
N 120 -3020 120 -3010 {
lab=inh_d}
N 80 -3060 90 -3060 {
lab=ctrl_vinh}
N 150 -2920 160 -2920 {
lab=inh9}
N 120 -2930 120 -2920 {
lab=GND}
N 120 -2880 120 -2870 {
lab=inh_d}
N 80 -2920 90 -2920 {
lab=ctrl_vinh}
N 150 -4180 160 -4180 {
lab=inh0}
N 120 -4190 120 -4180 {
lab=GND}
N 120 -4140 120 -4130 {
lab=inh_d}
N 80 -4180 90 -4180 {
lab=ctrl_vinh}
N -2440 -7780 -2440 -7770 {
lab=GND}
N -2440 -7890 -2440 -7880 {
lab=vdd_syn2}
N -2380 -7700 -2370 -7700 {
lab=GND}
N -2380 -7670 -2380 -7660 {
lab=p2}
N -2510 -7840 -2500 -7840 {
lab=vpres1}
N -2380 -7840 -2370 -7840 {
lab=#net89}
N -2430 -7700 -2420 -7700 {
lab=ctrl_pos}
N -2380 -7820 -2380 -7800 {
lab=#net90}
N -2380 -7740 -2380 -7730 {
lab=#net91}
N -2120 -7780 -2120 -7770 {
lab=GND}
N -2120 -7890 -2120 -7880 {
lab=vdd_syn3}
N -2060 -7700 -2050 -7700 {
lab=GND}
N -2060 -7670 -2060 -7660 {
lab=p3}
N -2190 -7840 -2180 -7840 {
lab=vpres1}
N -2060 -7840 -2050 -7840 {
lab=#net92}
N -2110 -7700 -2100 -7700 {
lab=ctrl_pos}
N -2060 -7820 -2060 -7800 {
lab=#net93}
N -2060 -7740 -2060 -7730 {
lab=#net94}
N -1800 -7780 -1800 -7770 {
lab=GND}
N -1800 -7890 -1800 -7880 {
lab=vdd_syn4}
N -1740 -7700 -1730 -7700 {
lab=GND}
N -1740 -7670 -1740 -7660 {
lab=p4}
N -1870 -7840 -1860 -7840 {
lab=vpres1}
N -1740 -7840 -1730 -7840 {
lab=#net95}
N -1790 -7700 -1780 -7700 {
lab=ctrl_pos}
N -1740 -7820 -1740 -7800 {
lab=#net96}
N -1740 -7740 -1740 -7730 {
lab=#net97}
N -1480 -7780 -1480 -7770 {
lab=GND}
N -1480 -7890 -1480 -7880 {
lab=vdd_syn5}
N -1420 -7700 -1410 -7700 {
lab=GND}
N -1420 -7670 -1420 -7660 {
lab=p5}
N -1550 -7840 -1540 -7840 {
lab=vpres1}
N -1420 -7840 -1410 -7840 {
lab=#net98}
N -1470 -7700 -1460 -7700 {
lab=ctrl_pos}
N -1420 -7820 -1420 -7800 {
lab=#net99}
N -1420 -7740 -1420 -7730 {
lab=#net100}
N -1160 -7780 -1160 -7770 {
lab=GND}
N -1160 -7890 -1160 -7880 {
lab=vdd_syn6}
N -1100 -7700 -1090 -7700 {
lab=GND}
N -1100 -7670 -1100 -7660 {
lab=p6}
N -1230 -7840 -1220 -7840 {
lab=vpres1}
N -1100 -7840 -1090 -7840 {
lab=#net101}
N -1150 -7700 -1140 -7700 {
lab=ctrl_pos}
N -1100 -7820 -1100 -7800 {
lab=#net102}
N -1100 -7740 -1100 -7730 {
lab=#net103}
N -840 -7780 -840 -7770 {
lab=GND}
N -840 -7890 -840 -7880 {
lab=vdd_syn7}
N -780 -7700 -770 -7700 {
lab=GND}
N -780 -7670 -780 -7660 {
lab=p7}
N -910 -7840 -900 -7840 {
lab=vpres1}
N -780 -7840 -770 -7840 {
lab=#net104}
N -830 -7700 -820 -7700 {
lab=ctrl_pos}
N -780 -7820 -780 -7800 {
lab=#net105}
N -780 -7740 -780 -7730 {
lab=#net106}
N -520 -7780 -520 -7770 {
lab=GND}
N -520 -7890 -520 -7880 {
lab=vdd_syn8}
N -460 -7700 -450 -7700 {
lab=GND}
N -460 -7670 -460 -7660 {
lab=p8}
N -590 -7840 -580 -7840 {
lab=vpres1}
N -460 -7840 -450 -7840 {
lab=#net107}
N -510 -7700 -500 -7700 {
lab=ctrl_pos}
N -460 -7820 -460 -7800 {
lab=#net108}
N -460 -7740 -460 -7730 {
lab=#net109}
N -200 -7780 -200 -7770 {
lab=GND}
N -200 -7890 -200 -7880 {
lab=vdd_syn9}
N -140 -7700 -130 -7700 {
lab=GND}
N -140 -7670 -140 -7660 {
lab=p9}
N -270 -7840 -260 -7840 {
lab=vpres1}
N -140 -7840 -130 -7840 {
lab=#net110}
N -190 -7700 -180 -7700 {
lab=ctrl_pos}
N -140 -7820 -140 -7800 {
lab=#net111}
N -140 -7740 -140 -7730 {
lab=#net112}
N -2760 -7260 -2760 -7250 {
lab=GND}
N -2760 -7370 -2760 -7360 {
lab=vdd_syn1}
N -2700 -7180 -2690 -7180 {
lab=GND}
N -2700 -7150 -2700 -7140 {
lab=p1}
N -2830 -7320 -2820 -7320 {
lab=vpres2}
N -2700 -7320 -2690 -7320 {
lab=#net113}
N -2750 -7180 -2740 -7180 {
lab=ctrl_pos}
N -2700 -7300 -2700 -7280 {
lab=#net114}
N -2700 -7220 -2700 -7210 {
lab=#net115}
N -2440 -7260 -2440 -7250 {
lab=GND}
N -2440 -7370 -2440 -7360 {
lab=vdd_syn2}
N -2380 -7180 -2370 -7180 {
lab=GND}
N -2380 -7150 -2380 -7140 {
lab=p2}
N -2510 -7320 -2500 -7320 {
lab=vpres2}
N -2380 -7320 -2370 -7320 {
lab=#net116}
N -2430 -7180 -2420 -7180 {
lab=ctrl_pos}
N -2380 -7300 -2380 -7280 {
lab=#net117}
N -2380 -7220 -2380 -7210 {
lab=#net118}
N -2120 -7260 -2120 -7250 {
lab=GND}
N -2120 -7370 -2120 -7360 {
lab=vdd_syn3}
N -2060 -7180 -2050 -7180 {
lab=GND}
N -2060 -7150 -2060 -7140 {
lab=p3}
N -2190 -7320 -2180 -7320 {
lab=vpres2}
N -2060 -7320 -2050 -7320 {
lab=#net119}
N -2110 -7180 -2100 -7180 {
lab=ctrl_pos}
N -2060 -7300 -2060 -7280 {
lab=#net120}
N -2060 -7220 -2060 -7210 {
lab=#net121}
N -1800 -7260 -1800 -7250 {
lab=GND}
N -1800 -7370 -1800 -7360 {
lab=vdd_syn4}
N -1740 -7180 -1730 -7180 {
lab=GND}
N -1740 -7150 -1740 -7140 {
lab=p4}
N -1870 -7320 -1860 -7320 {
lab=vpres2}
N -1740 -7320 -1730 -7320 {
lab=#net122}
N -1790 -7180 -1780 -7180 {
lab=ctrl_pos}
N -1740 -7300 -1740 -7280 {
lab=#net123}
N -1740 -7220 -1740 -7210 {
lab=#net124}
N -1480 -7260 -1480 -7250 {
lab=GND}
N -1480 -7370 -1480 -7360 {
lab=vdd_syn5}
N -1420 -7180 -1410 -7180 {
lab=GND}
N -1420 -7150 -1420 -7140 {
lab=p5}
N -1550 -7320 -1540 -7320 {
lab=vpres2}
N -1420 -7320 -1410 -7320 {
lab=#net125}
N -1470 -7180 -1460 -7180 {
lab=ctrl_pos}
N -1420 -7300 -1420 -7280 {
lab=#net126}
N -1420 -7220 -1420 -7210 {
lab=#net127}
N -1160 -7260 -1160 -7250 {
lab=GND}
N -1160 -7370 -1160 -7360 {
lab=vdd_syn6}
N -1100 -7180 -1090 -7180 {
lab=GND}
N -1100 -7150 -1100 -7140 {
lab=p6}
N -1230 -7320 -1220 -7320 {
lab=vpres2}
N -1100 -7320 -1090 -7320 {
lab=#net128}
N -1150 -7180 -1140 -7180 {
lab=ctrl_pos}
N -1100 -7300 -1100 -7280 {
lab=#net129}
N -1100 -7220 -1100 -7210 {
lab=#net130}
N -840 -7260 -840 -7250 {
lab=GND}
N -840 -7370 -840 -7360 {
lab=vdd_syn7}
N -780 -7180 -770 -7180 {
lab=GND}
N -780 -7150 -780 -7140 {
lab=p7}
N -910 -7320 -900 -7320 {
lab=vpres2}
N -780 -7320 -770 -7320 {
lab=#net131}
N -830 -7180 -820 -7180 {
lab=ctrl_pos}
N -780 -7300 -780 -7280 {
lab=#net132}
N -780 -7220 -780 -7210 {
lab=#net133}
N -520 -7260 -520 -7250 {
lab=GND}
N -520 -7370 -520 -7360 {
lab=vdd_syn8}
N -460 -7180 -450 -7180 {
lab=GND}
N -460 -7150 -460 -7140 {
lab=p8}
N -590 -7320 -580 -7320 {
lab=vpres2}
N -460 -7320 -450 -7320 {
lab=#net134}
N -510 -7180 -500 -7180 {
lab=ctrl_pos}
N -460 -7300 -460 -7280 {
lab=#net135}
N -460 -7220 -460 -7210 {
lab=#net136}
N -200 -7260 -200 -7250 {
lab=GND}
N -200 -7370 -200 -7360 {
lab=vdd_syn9}
N -140 -7180 -130 -7180 {
lab=GND}
N -140 -7150 -140 -7140 {
lab=p9}
N -270 -7320 -260 -7320 {
lab=vpres2}
N -140 -7320 -130 -7320 {
lab=#net137}
N -190 -7180 -180 -7180 {
lab=ctrl_pos}
N -140 -7300 -140 -7280 {
lab=#net138}
N -140 -7220 -140 -7210 {
lab=#net139}
N -2760 -6740 -2760 -6730 {
lab=GND}
N -2760 -6850 -2760 -6840 {
lab=vdd_syn1}
N -2700 -6660 -2690 -6660 {
lab=GND}
N -2700 -6630 -2700 -6620 {
lab=p1}
N -2830 -6800 -2820 -6800 {
lab=vpres3}
N -2700 -6800 -2690 -6800 {
lab=#net140}
N -2750 -6660 -2740 -6660 {
lab=ctrl_pos}
N -2700 -6780 -2700 -6760 {
lab=#net141}
N -2700 -6700 -2700 -6690 {
lab=#net142}
N -2440 -6740 -2440 -6730 {
lab=GND}
N -2440 -6850 -2440 -6840 {
lab=vdd_syn2}
N -2380 -6660 -2370 -6660 {
lab=GND}
N -2380 -6630 -2380 -6620 {
lab=p2}
N -2510 -6800 -2500 -6800 {
lab=vpres3}
N -2380 -6800 -2370 -6800 {
lab=#net143}
N -2430 -6660 -2420 -6660 {
lab=ctrl_pos}
N -2380 -6780 -2380 -6760 {
lab=#net144}
N -2380 -6700 -2380 -6690 {
lab=#net145}
N -2120 -6740 -2120 -6730 {
lab=GND}
N -2120 -6850 -2120 -6840 {
lab=vdd_syn3}
N -2060 -6660 -2050 -6660 {
lab=GND}
N -2060 -6630 -2060 -6620 {
lab=p3}
N -2190 -6800 -2180 -6800 {
lab=vpres3}
N -2060 -6800 -2050 -6800 {
lab=#net146}
N -2110 -6660 -2100 -6660 {
lab=ctrl_pos}
N -2060 -6780 -2060 -6760 {
lab=#net147}
N -2060 -6700 -2060 -6690 {
lab=#net148}
N -1800 -6740 -1800 -6730 {
lab=GND}
N -1800 -6850 -1800 -6840 {
lab=vdd_syn4}
N -1740 -6660 -1730 -6660 {
lab=GND}
N -1740 -6630 -1740 -6620 {
lab=p4}
N -1870 -6800 -1860 -6800 {
lab=vpres3}
N -1740 -6800 -1730 -6800 {
lab=#net149}
N -1790 -6660 -1780 -6660 {
lab=ctrl_pos}
N -1740 -6780 -1740 -6760 {
lab=#net150}
N -1740 -6700 -1740 -6690 {
lab=#net151}
N -1480 -6740 -1480 -6730 {
lab=GND}
N -1480 -6850 -1480 -6840 {
lab=vdd_syn5}
N -1420 -6660 -1410 -6660 {
lab=GND}
N -1420 -6630 -1420 -6620 {
lab=p5}
N -1550 -6800 -1540 -6800 {
lab=vpres3}
N -1420 -6800 -1410 -6800 {
lab=#net152}
N -1470 -6660 -1460 -6660 {
lab=ctrl_pos}
N -1420 -6780 -1420 -6760 {
lab=#net153}
N -1420 -6700 -1420 -6690 {
lab=#net154}
N -1160 -6740 -1160 -6730 {
lab=GND}
N -1160 -6850 -1160 -6840 {
lab=vdd_syn6}
N -1100 -6660 -1090 -6660 {
lab=GND}
N -1100 -6630 -1100 -6620 {
lab=p6}
N -1230 -6800 -1220 -6800 {
lab=vpres3}
N -1100 -6800 -1090 -6800 {
lab=#net155}
N -1150 -6660 -1140 -6660 {
lab=ctrl_pos}
N -1100 -6780 -1100 -6760 {
lab=#net156}
N -1100 -6700 -1100 -6690 {
lab=#net157}
N -840 -6740 -840 -6730 {
lab=GND}
N -840 -6850 -840 -6840 {
lab=vdd_syn7}
N -780 -6660 -770 -6660 {
lab=GND}
N -780 -6630 -780 -6620 {
lab=p7}
N -910 -6800 -900 -6800 {
lab=vpres3}
N -780 -6800 -770 -6800 {
lab=#net158}
N -830 -6660 -820 -6660 {
lab=ctrl_pos}
N -780 -6780 -780 -6760 {
lab=#net159}
N -780 -6700 -780 -6690 {
lab=#net160}
N -520 -6740 -520 -6730 {
lab=GND}
N -520 -6850 -520 -6840 {
lab=vdd_syn8}
N -460 -6660 -450 -6660 {
lab=GND}
N -460 -6630 -460 -6620 {
lab=p8}
N -590 -6800 -580 -6800 {
lab=vpres3}
N -460 -6800 -450 -6800 {
lab=#net161}
N -510 -6660 -500 -6660 {
lab=ctrl_pos}
N -460 -6780 -460 -6760 {
lab=#net162}
N -460 -6700 -460 -6690 {
lab=#net163}
N -200 -6740 -200 -6730 {
lab=GND}
N -200 -6850 -200 -6840 {
lab=vdd_syn9}
N -140 -6660 -130 -6660 {
lab=GND}
N -140 -6630 -140 -6620 {
lab=p9}
N -270 -6800 -260 -6800 {
lab=vpres3}
N -140 -6800 -130 -6800 {
lab=#net164}
N -190 -6660 -180 -6660 {
lab=ctrl_pos}
N -140 -6780 -140 -6760 {
lab=#net165}
N -140 -6700 -140 -6690 {
lab=#net166}
N -2760 -6220 -2760 -6210 {
lab=GND}
N -2760 -6330 -2760 -6320 {
lab=vdd_syn1}
N -2700 -6140 -2690 -6140 {
lab=GND}
N -2700 -6110 -2700 -6100 {
lab=p1}
N -2830 -6280 -2820 -6280 {
lab=vpres4}
N -2700 -6280 -2690 -6280 {
lab=#net167}
N -2750 -6140 -2740 -6140 {
lab=ctrl_pos}
N -2700 -6260 -2700 -6240 {
lab=#net168}
N -2700 -6180 -2700 -6170 {
lab=#net169}
N -2440 -6220 -2440 -6210 {
lab=GND}
N -2440 -6330 -2440 -6320 {
lab=vdd_syn2}
N -2380 -6140 -2370 -6140 {
lab=GND}
N -2380 -6110 -2380 -6100 {
lab=p2}
N -2510 -6280 -2500 -6280 {
lab=vpres4}
N -2380 -6280 -2370 -6280 {
lab=#net170}
N -2430 -6140 -2420 -6140 {
lab=ctrl_pos}
N -2380 -6260 -2380 -6240 {
lab=#net171}
N -2380 -6180 -2380 -6170 {
lab=#net172}
N -2120 -6220 -2120 -6210 {
lab=GND}
N -2120 -6330 -2120 -6320 {
lab=vdd_syn3}
N -2060 -6140 -2050 -6140 {
lab=GND}
N -2060 -6110 -2060 -6100 {
lab=p3}
N -2190 -6280 -2180 -6280 {
lab=vpres4}
N -2060 -6280 -2050 -6280 {
lab=#net173}
N -2110 -6140 -2100 -6140 {
lab=ctrl_pos}
N -2060 -6260 -2060 -6240 {
lab=#net174}
N -2060 -6180 -2060 -6170 {
lab=#net175}
N -1800 -6220 -1800 -6210 {
lab=GND}
N -1800 -6330 -1800 -6320 {
lab=vdd_syn4}
N -1740 -6140 -1730 -6140 {
lab=GND}
N -1740 -6110 -1740 -6100 {
lab=p4}
N -1870 -6280 -1860 -6280 {
lab=vpres4}
N -1740 -6280 -1730 -6280 {
lab=#net176}
N -1790 -6140 -1780 -6140 {
lab=ctrl_pos}
N -1740 -6260 -1740 -6240 {
lab=#net177}
N -1740 -6180 -1740 -6170 {
lab=#net178}
N -1480 -6220 -1480 -6210 {
lab=GND}
N -1480 -6330 -1480 -6320 {
lab=vdd_syn5}
N -1420 -6140 -1410 -6140 {
lab=GND}
N -1420 -6110 -1420 -6100 {
lab=p5}
N -1550 -6280 -1540 -6280 {
lab=vpres4}
N -1420 -6280 -1410 -6280 {
lab=#net179}
N -1470 -6140 -1460 -6140 {
lab=ctrl_pos}
N -1420 -6260 -1420 -6240 {
lab=#net180}
N -1420 -6180 -1420 -6170 {
lab=#net181}
N -1160 -6220 -1160 -6210 {
lab=GND}
N -1160 -6330 -1160 -6320 {
lab=vdd_syn6}
N -1100 -6140 -1090 -6140 {
lab=GND}
N -1100 -6110 -1100 -6100 {
lab=p6}
N -1230 -6280 -1220 -6280 {
lab=vpres4}
N -1100 -6280 -1090 -6280 {
lab=#net182}
N -1150 -6140 -1140 -6140 {
lab=ctrl_pos}
N -1100 -6260 -1100 -6240 {
lab=#net183}
N -1100 -6180 -1100 -6170 {
lab=#net184}
N -840 -6220 -840 -6210 {
lab=GND}
N -840 -6330 -840 -6320 {
lab=vdd_syn7}
N -780 -6140 -770 -6140 {
lab=GND}
N -780 -6110 -780 -6100 {
lab=p7}
N -910 -6280 -900 -6280 {
lab=vpres4}
N -780 -6280 -770 -6280 {
lab=#net185}
N -830 -6140 -820 -6140 {
lab=ctrl_pos}
N -780 -6260 -780 -6240 {
lab=#net186}
N -780 -6180 -780 -6170 {
lab=#net187}
N -520 -6220 -520 -6210 {
lab=GND}
N -520 -6330 -520 -6320 {
lab=vdd_syn8}
N -460 -6140 -450 -6140 {
lab=GND}
N -460 -6110 -460 -6100 {
lab=p8}
N -590 -6280 -580 -6280 {
lab=vpres4}
N -460 -6280 -450 -6280 {
lab=#net188}
N -510 -6140 -500 -6140 {
lab=ctrl_pos}
N -460 -6260 -460 -6240 {
lab=#net189}
N -460 -6180 -460 -6170 {
lab=#net190}
N -200 -6220 -200 -6210 {
lab=GND}
N -200 -6330 -200 -6320 {
lab=vdd_syn9}
N -140 -6140 -130 -6140 {
lab=GND}
N -140 -6110 -140 -6100 {
lab=p9}
N -270 -6280 -260 -6280 {
lab=vpres4}
N -140 -6280 -130 -6280 {
lab=#net191}
N -190 -6140 -180 -6140 {
lab=ctrl_pos}
N -140 -6260 -140 -6240 {
lab=#net192}
N -140 -6180 -140 -6170 {
lab=#net193}
N -2760 -5700 -2760 -5690 {
lab=GND}
N -2760 -5810 -2760 -5800 {
lab=vdd_syn1}
N -2700 -5620 -2690 -5620 {
lab=GND}
N -2700 -5590 -2700 -5580 {
lab=p1}
N -2830 -5760 -2820 -5760 {
lab=vpres5}
N -2700 -5760 -2690 -5760 {
lab=#net194}
N -2750 -5620 -2740 -5620 {
lab=ctrl_pos}
N -2700 -5740 -2700 -5720 {
lab=#net195}
N -2700 -5660 -2700 -5650 {
lab=#net196}
N -2440 -5700 -2440 -5690 {
lab=GND}
N -2440 -5810 -2440 -5800 {
lab=vdd_syn2}
N -2380 -5620 -2370 -5620 {
lab=GND}
N -2380 -5590 -2380 -5580 {
lab=p2}
N -2510 -5760 -2500 -5760 {
lab=vpres5}
N -2380 -5760 -2370 -5760 {
lab=#net197}
N -2430 -5620 -2420 -5620 {
lab=ctrl_pos}
N -2380 -5740 -2380 -5720 {
lab=#net198}
N -2380 -5660 -2380 -5650 {
lab=#net199}
N -2120 -5700 -2120 -5690 {
lab=GND}
N -2120 -5810 -2120 -5800 {
lab=vdd_syn3}
N -2060 -5620 -2050 -5620 {
lab=GND}
N -2060 -5590 -2060 -5580 {
lab=p3}
N -2190 -5760 -2180 -5760 {
lab=vpres5}
N -2060 -5760 -2050 -5760 {
lab=#net200}
N -2110 -5620 -2100 -5620 {
lab=ctrl_pos}
N -2060 -5740 -2060 -5720 {
lab=#net201}
N -2060 -5660 -2060 -5650 {
lab=#net202}
N -1800 -5700 -1800 -5690 {
lab=GND}
N -1800 -5810 -1800 -5800 {
lab=vdd_syn4}
N -1740 -5620 -1730 -5620 {
lab=GND}
N -1740 -5590 -1740 -5580 {
lab=p4}
N -1870 -5760 -1860 -5760 {
lab=vpres5}
N -1740 -5760 -1730 -5760 {
lab=#net203}
N -1790 -5620 -1780 -5620 {
lab=ctrl_pos}
N -1740 -5740 -1740 -5720 {
lab=#net204}
N -1740 -5660 -1740 -5650 {
lab=#net205}
N -1480 -5700 -1480 -5690 {
lab=GND}
N -1480 -5810 -1480 -5800 {
lab=vdd_syn5}
N -1420 -5620 -1410 -5620 {
lab=GND}
N -1420 -5590 -1420 -5580 {
lab=p5}
N -1550 -5760 -1540 -5760 {
lab=vpres5}
N -1420 -5760 -1410 -5760 {
lab=#net206}
N -1470 -5620 -1460 -5620 {
lab=ctrl_pos}
N -1420 -5740 -1420 -5720 {
lab=#net207}
N -1420 -5660 -1420 -5650 {
lab=#net208}
N -1160 -5700 -1160 -5690 {
lab=GND}
N -1160 -5810 -1160 -5800 {
lab=vdd_syn6}
N -1100 -5620 -1090 -5620 {
lab=GND}
N -1100 -5590 -1100 -5580 {
lab=p6}
N -1230 -5760 -1220 -5760 {
lab=vpres5}
N -1100 -5760 -1090 -5760 {
lab=#net209}
N -1150 -5620 -1140 -5620 {
lab=ctrl_pos}
N -1100 -5740 -1100 -5720 {
lab=#net210}
N -1100 -5660 -1100 -5650 {
lab=#net211}
N -840 -5700 -840 -5690 {
lab=GND}
N -840 -5810 -840 -5800 {
lab=vdd_syn7}
N -780 -5620 -770 -5620 {
lab=GND}
N -780 -5590 -780 -5580 {
lab=p7}
N -910 -5760 -900 -5760 {
lab=vpres5}
N -780 -5760 -770 -5760 {
lab=#net212}
N -830 -5620 -820 -5620 {
lab=ctrl_pos}
N -780 -5740 -780 -5720 {
lab=#net213}
N -780 -5660 -780 -5650 {
lab=#net214}
N -520 -5700 -520 -5690 {
lab=GND}
N -520 -5810 -520 -5800 {
lab=vdd_syn8}
N -460 -5620 -450 -5620 {
lab=GND}
N -460 -5590 -460 -5580 {
lab=p8}
N -590 -5760 -580 -5760 {
lab=vpres5}
N -460 -5760 -450 -5760 {
lab=#net215}
N -510 -5620 -500 -5620 {
lab=ctrl_pos}
N -460 -5740 -460 -5720 {
lab=#net216}
N -460 -5660 -460 -5650 {
lab=#net217}
N -200 -5700 -200 -5690 {
lab=GND}
N -200 -5810 -200 -5800 {
lab=vdd_syn9}
N -140 -5620 -130 -5620 {
lab=GND}
N -140 -5590 -140 -5580 {
lab=p9}
N -270 -5760 -260 -5760 {
lab=vpres5}
N -140 -5760 -130 -5760 {
lab=#net218}
N -190 -5620 -180 -5620 {
lab=ctrl_pos}
N -140 -5740 -140 -5720 {
lab=#net219}
N -140 -5660 -140 -5650 {
lab=#net220}
N -2760 -5180 -2760 -5170 {
lab=GND}
N -2760 -5290 -2760 -5280 {
lab=vdd_syn1}
N -2700 -5100 -2690 -5100 {
lab=GND}
N -2700 -5070 -2700 -5060 {
lab=p1}
N -2830 -5240 -2820 -5240 {
lab=vpres6}
N -2700 -5240 -2690 -5240 {
lab=#net221}
N -2750 -5100 -2740 -5100 {
lab=ctrl_pos}
N -2700 -5220 -2700 -5200 {
lab=#net222}
N -2700 -5140 -2700 -5130 {
lab=#net223}
N -2440 -5180 -2440 -5170 {
lab=GND}
N -2440 -5290 -2440 -5280 {
lab=vdd_syn2}
N -2380 -5100 -2370 -5100 {
lab=GND}
N -2380 -5070 -2380 -5060 {
lab=p2}
N -2510 -5240 -2500 -5240 {
lab=vpres6}
N -2380 -5240 -2370 -5240 {
lab=#net224}
N -2430 -5100 -2420 -5100 {
lab=ctrl_pos}
N -2380 -5220 -2380 -5200 {
lab=#net225}
N -2380 -5140 -2380 -5130 {
lab=#net226}
N -2120 -5180 -2120 -5170 {
lab=GND}
N -2120 -5290 -2120 -5280 {
lab=vdd_syn3}
N -2060 -5100 -2050 -5100 {
lab=GND}
N -2060 -5070 -2060 -5060 {
lab=p3}
N -2190 -5240 -2180 -5240 {
lab=vpres6}
N -2060 -5240 -2050 -5240 {
lab=#net227}
N -2110 -5100 -2100 -5100 {
lab=ctrl_pos}
N -2060 -5220 -2060 -5200 {
lab=#net228}
N -2060 -5140 -2060 -5130 {
lab=#net229}
N -1800 -5180 -1800 -5170 {
lab=GND}
N -1800 -5290 -1800 -5280 {
lab=vdd_syn4}
N -1740 -5100 -1730 -5100 {
lab=GND}
N -1740 -5070 -1740 -5060 {
lab=p4}
N -1870 -5240 -1860 -5240 {
lab=vpres6}
N -1740 -5240 -1730 -5240 {
lab=#net230}
N -1790 -5100 -1780 -5100 {
lab=ctrl_pos}
N -1740 -5220 -1740 -5200 {
lab=#net231}
N -1740 -5140 -1740 -5130 {
lab=#net232}
N -1480 -5180 -1480 -5170 {
lab=GND}
N -1480 -5290 -1480 -5280 {
lab=vdd_syn5}
N -1420 -5100 -1410 -5100 {
lab=GND}
N -1420 -5070 -1420 -5060 {
lab=p5}
N -1550 -5240 -1540 -5240 {
lab=vpres6}
N -1420 -5240 -1410 -5240 {
lab=#net233}
N -1470 -5100 -1460 -5100 {
lab=ctrl_pos}
N -1420 -5220 -1420 -5200 {
lab=#net234}
N -1420 -5140 -1420 -5130 {
lab=#net235}
N -1160 -5180 -1160 -5170 {
lab=GND}
N -1160 -5290 -1160 -5280 {
lab=vdd_syn6}
N -1100 -5100 -1090 -5100 {
lab=GND}
N -1100 -5070 -1100 -5060 {
lab=p6}
N -1230 -5240 -1220 -5240 {
lab=vpres6}
N -1100 -5240 -1090 -5240 {
lab=#net236}
N -1150 -5100 -1140 -5100 {
lab=ctrl_pos}
N -1100 -5220 -1100 -5200 {
lab=#net237}
N -1100 -5140 -1100 -5130 {
lab=#net238}
N -840 -5180 -840 -5170 {
lab=GND}
N -840 -5290 -840 -5280 {
lab=vdd_syn7}
N -780 -5100 -770 -5100 {
lab=GND}
N -780 -5070 -780 -5060 {
lab=p7}
N -910 -5240 -900 -5240 {
lab=vpres6}
N -780 -5240 -770 -5240 {
lab=#net239}
N -830 -5100 -820 -5100 {
lab=ctrl_pos}
N -780 -5220 -780 -5200 {
lab=#net240}
N -780 -5140 -780 -5130 {
lab=#net241}
N -520 -5180 -520 -5170 {
lab=GND}
N -520 -5290 -520 -5280 {
lab=vdd_syn8}
N -460 -5100 -450 -5100 {
lab=GND}
N -460 -5070 -460 -5060 {
lab=p8}
N -590 -5240 -580 -5240 {
lab=vpres6}
N -460 -5240 -450 -5240 {
lab=#net242}
N -510 -5100 -500 -5100 {
lab=ctrl_pos}
N -460 -5220 -460 -5200 {
lab=#net243}
N -460 -5140 -460 -5130 {
lab=#net244}
N -200 -5180 -200 -5170 {
lab=GND}
N -200 -5290 -200 -5280 {
lab=vdd_syn9}
N -140 -5100 -130 -5100 {
lab=GND}
N -140 -5070 -140 -5060 {
lab=p9}
N -270 -5240 -260 -5240 {
lab=vpres6}
N -140 -5240 -130 -5240 {
lab=#net245}
N -190 -5100 -180 -5100 {
lab=ctrl_pos}
N -140 -5220 -140 -5200 {
lab=#net246}
N -140 -5140 -140 -5130 {
lab=#net247}
N -2760 -4660 -2760 -4650 {
lab=GND}
N -2760 -4770 -2760 -4760 {
lab=vdd_syn1}
N -2700 -4580 -2690 -4580 {
lab=GND}
N -2700 -4550 -2700 -4540 {
lab=p1}
N -2830 -4720 -2820 -4720 {
lab=vpres7}
N -2700 -4720 -2690 -4720 {
lab=#net248}
N -2750 -4580 -2740 -4580 {
lab=ctrl_pos}
N -2700 -4700 -2700 -4680 {
lab=#net249}
N -2700 -4620 -2700 -4610 {
lab=#net250}
N -2440 -4660 -2440 -4650 {
lab=GND}
N -2440 -4770 -2440 -4760 {
lab=vdd_syn2}
N -2380 -4580 -2370 -4580 {
lab=GND}
N -2380 -4550 -2380 -4540 {
lab=p2}
N -2510 -4720 -2500 -4720 {
lab=vpres7}
N -2380 -4720 -2370 -4720 {
lab=#net251}
N -2430 -4580 -2420 -4580 {
lab=ctrl_pos}
N -2380 -4700 -2380 -4680 {
lab=#net252}
N -2380 -4620 -2380 -4610 {
lab=#net253}
N -2120 -4660 -2120 -4650 {
lab=GND}
N -2120 -4770 -2120 -4760 {
lab=vdd_syn3}
N -2060 -4580 -2050 -4580 {
lab=GND}
N -2060 -4550 -2060 -4540 {
lab=p3}
N -2190 -4720 -2180 -4720 {
lab=vpres7}
N -2060 -4720 -2050 -4720 {
lab=#net254}
N -2110 -4580 -2100 -4580 {
lab=ctrl_pos}
N -2060 -4700 -2060 -4680 {
lab=#net255}
N -2060 -4620 -2060 -4610 {
lab=#net256}
N -1800 -4660 -1800 -4650 {
lab=GND}
N -1800 -4770 -1800 -4760 {
lab=vdd_syn4}
N -1740 -4580 -1730 -4580 {
lab=GND}
N -1740 -4550 -1740 -4540 {
lab=p4}
N -1870 -4720 -1860 -4720 {
lab=vpres7}
N -1740 -4720 -1730 -4720 {
lab=#net257}
N -1790 -4580 -1780 -4580 {
lab=ctrl_pos}
N -1740 -4700 -1740 -4680 {
lab=#net258}
N -1740 -4620 -1740 -4610 {
lab=#net259}
N -1480 -4660 -1480 -4650 {
lab=GND}
N -1480 -4770 -1480 -4760 {
lab=vdd_syn5}
N -1420 -4580 -1410 -4580 {
lab=GND}
N -1420 -4550 -1420 -4540 {
lab=p5}
N -1550 -4720 -1540 -4720 {
lab=vpres7}
N -1420 -4720 -1410 -4720 {
lab=#net260}
N -1470 -4580 -1460 -4580 {
lab=ctrl_pos}
N -1420 -4700 -1420 -4680 {
lab=#net261}
N -1420 -4620 -1420 -4610 {
lab=#net262}
N -1160 -4660 -1160 -4650 {
lab=GND}
N -1160 -4770 -1160 -4760 {
lab=vdd_syn6}
N -1100 -4580 -1090 -4580 {
lab=GND}
N -1100 -4550 -1100 -4540 {
lab=p6}
N -1230 -4720 -1220 -4720 {
lab=vpres7}
N -1100 -4720 -1090 -4720 {
lab=#net263}
N -1150 -4580 -1140 -4580 {
lab=ctrl_pos}
N -1100 -4700 -1100 -4680 {
lab=#net264}
N -1100 -4620 -1100 -4610 {
lab=#net265}
N -840 -4660 -840 -4650 {
lab=GND}
N -840 -4770 -840 -4760 {
lab=vdd_syn7}
N -780 -4580 -770 -4580 {
lab=GND}
N -780 -4550 -780 -4540 {
lab=p7}
N -910 -4720 -900 -4720 {
lab=vpres7}
N -780 -4720 -770 -4720 {
lab=#net266}
N -830 -4580 -820 -4580 {
lab=ctrl_pos}
N -780 -4700 -780 -4680 {
lab=#net267}
N -780 -4620 -780 -4610 {
lab=#net268}
N -520 -4660 -520 -4650 {
lab=GND}
N -520 -4770 -520 -4760 {
lab=vdd_syn8}
N -460 -4580 -450 -4580 {
lab=GND}
N -460 -4550 -460 -4540 {
lab=p8}
N -590 -4720 -580 -4720 {
lab=vpres7}
N -460 -4720 -450 -4720 {
lab=#net269}
N -510 -4580 -500 -4580 {
lab=ctrl_pos}
N -460 -4700 -460 -4680 {
lab=#net270}
N -460 -4620 -460 -4610 {
lab=#net271}
N -200 -4660 -200 -4650 {
lab=GND}
N -200 -4770 -200 -4760 {
lab=vdd_syn9}
N -140 -4580 -130 -4580 {
lab=GND}
N -140 -4550 -140 -4540 {
lab=p9}
N -270 -4720 -260 -4720 {
lab=vpres7}
N -140 -4720 -130 -4720 {
lab=#net272}
N -190 -4580 -180 -4580 {
lab=ctrl_pos}
N -140 -4700 -140 -4680 {
lab=#net273}
N -140 -4620 -140 -4610 {
lab=#net274}
N -2760 -4140 -2760 -4130 {
lab=GND}
N -2760 -4250 -2760 -4240 {
lab=vdd_syn1}
N -2700 -4060 -2690 -4060 {
lab=GND}
N -2700 -4030 -2700 -4020 {
lab=p1}
N -2830 -4200 -2820 -4200 {
lab=vpres8}
N -2700 -4200 -2690 -4200 {
lab=#net275}
N -2750 -4060 -2740 -4060 {
lab=ctrl_pos}
N -2700 -4180 -2700 -4160 {
lab=#net276}
N -2700 -4100 -2700 -4090 {
lab=#net277}
N -2440 -4140 -2440 -4130 {
lab=GND}
N -2440 -4250 -2440 -4240 {
lab=vdd_syn2}
N -2380 -4060 -2370 -4060 {
lab=GND}
N -2380 -4030 -2380 -4020 {
lab=p2}
N -2510 -4200 -2500 -4200 {
lab=vpres8}
N -2380 -4200 -2370 -4200 {
lab=#net278}
N -2430 -4060 -2420 -4060 {
lab=ctrl_pos}
N -2380 -4180 -2380 -4160 {
lab=#net279}
N -2380 -4100 -2380 -4090 {
lab=#net280}
N -2120 -4140 -2120 -4130 {
lab=GND}
N -2120 -4250 -2120 -4240 {
lab=vdd_syn3}
N -2060 -4060 -2050 -4060 {
lab=GND}
N -2060 -4030 -2060 -4020 {
lab=p3}
N -2190 -4200 -2180 -4200 {
lab=vpres8}
N -2060 -4200 -2050 -4200 {
lab=#net281}
N -2110 -4060 -2100 -4060 {
lab=ctrl_pos}
N -2060 -4180 -2060 -4160 {
lab=#net282}
N -2060 -4100 -2060 -4090 {
lab=#net283}
N -1800 -4140 -1800 -4130 {
lab=GND}
N -1800 -4250 -1800 -4240 {
lab=vdd_syn4}
N -1740 -4060 -1730 -4060 {
lab=GND}
N -1740 -4030 -1740 -4020 {
lab=p4}
N -1870 -4200 -1860 -4200 {
lab=vpres8}
N -1740 -4200 -1730 -4200 {
lab=#net284}
N -1790 -4060 -1780 -4060 {
lab=ctrl_pos}
N -1740 -4180 -1740 -4160 {
lab=#net285}
N -1740 -4100 -1740 -4090 {
lab=#net286}
N -1480 -4140 -1480 -4130 {
lab=GND}
N -1480 -4250 -1480 -4240 {
lab=vdd_syn5}
N -1420 -4060 -1410 -4060 {
lab=GND}
N -1420 -4030 -1420 -4020 {
lab=p5}
N -1550 -4200 -1540 -4200 {
lab=vpres8}
N -1420 -4200 -1410 -4200 {
lab=#net287}
N -1470 -4060 -1460 -4060 {
lab=ctrl_pos}
N -1420 -4180 -1420 -4160 {
lab=#net288}
N -1420 -4100 -1420 -4090 {
lab=#net289}
N -1160 -4140 -1160 -4130 {
lab=GND}
N -1160 -4250 -1160 -4240 {
lab=vdd_syn6}
N -1100 -4060 -1090 -4060 {
lab=GND}
N -1100 -4030 -1100 -4020 {
lab=p6}
N -1230 -4200 -1220 -4200 {
lab=vpres8}
N -1100 -4200 -1090 -4200 {
lab=#net290}
N -1150 -4060 -1140 -4060 {
lab=ctrl_pos}
N -1100 -4180 -1100 -4160 {
lab=#net291}
N -1100 -4100 -1100 -4090 {
lab=#net292}
N -840 -4140 -840 -4130 {
lab=GND}
N -840 -4250 -840 -4240 {
lab=vdd_syn7}
N -780 -4060 -770 -4060 {
lab=GND}
N -780 -4030 -780 -4020 {
lab=p7}
N -910 -4200 -900 -4200 {
lab=vpres8}
N -780 -4200 -770 -4200 {
lab=#net293}
N -830 -4060 -820 -4060 {
lab=ctrl_pos}
N -780 -4180 -780 -4160 {
lab=#net294}
N -780 -4100 -780 -4090 {
lab=#net295}
N -520 -4140 -520 -4130 {
lab=GND}
N -520 -4250 -520 -4240 {
lab=vdd_syn8}
N -460 -4060 -450 -4060 {
lab=GND}
N -460 -4030 -460 -4020 {
lab=p8}
N -590 -4200 -580 -4200 {
lab=vpres8}
N -460 -4200 -450 -4200 {
lab=#net296}
N -510 -4060 -500 -4060 {
lab=ctrl_pos}
N -460 -4180 -460 -4160 {
lab=#net297}
N -460 -4100 -460 -4090 {
lab=#net298}
N -200 -4140 -200 -4130 {
lab=GND}
N -200 -4250 -200 -4240 {
lab=vdd_syn9}
N -140 -4060 -130 -4060 {
lab=GND}
N -140 -4030 -140 -4020 {
lab=p9}
N -270 -4200 -260 -4200 {
lab=vpres8}
N -140 -4200 -130 -4200 {
lab=#net299}
N -190 -4060 -180 -4060 {
lab=ctrl_pos}
N -140 -4180 -140 -4160 {
lab=#net300}
N -140 -4100 -140 -4090 {
lab=#net301}
N -2760 -3620 -2760 -3610 {
lab=GND}
N -2760 -3730 -2760 -3720 {
lab=vdd_syn1}
N -2700 -3540 -2690 -3540 {
lab=GND}
N -2700 -3510 -2700 -3500 {
lab=p1}
N -2830 -3680 -2820 -3680 {
lab=vpres9}
N -2700 -3680 -2690 -3680 {
lab=#net302}
N -2750 -3540 -2740 -3540 {
lab=ctrl_pos}
N -2700 -3660 -2700 -3640 {
lab=#net303}
N -2700 -3580 -2700 -3570 {
lab=#net304}
N -2440 -3620 -2440 -3610 {
lab=GND}
N -2440 -3730 -2440 -3720 {
lab=vdd_syn2}
N -2380 -3540 -2370 -3540 {
lab=GND}
N -2380 -3510 -2380 -3500 {
lab=p2}
N -2510 -3680 -2500 -3680 {
lab=vpres9}
N -2380 -3680 -2370 -3680 {
lab=#net305}
N -2430 -3540 -2420 -3540 {
lab=ctrl_pos}
N -2380 -3660 -2380 -3640 {
lab=#net306}
N -2380 -3580 -2380 -3570 {
lab=#net307}
N -2120 -3620 -2120 -3610 {
lab=GND}
N -2120 -3730 -2120 -3720 {
lab=vdd_syn3}
N -2060 -3540 -2050 -3540 {
lab=GND}
N -2060 -3510 -2060 -3500 {
lab=p3}
N -2190 -3680 -2180 -3680 {
lab=vpres9}
N -2060 -3680 -2050 -3680 {
lab=#net308}
N -2110 -3540 -2100 -3540 {
lab=ctrl_pos}
N -2060 -3660 -2060 -3640 {
lab=#net309}
N -2060 -3580 -2060 -3570 {
lab=#net310}
N -1800 -3620 -1800 -3610 {
lab=GND}
N -1800 -3730 -1800 -3720 {
lab=vdd_syn4}
N -1740 -3540 -1730 -3540 {
lab=GND}
N -1740 -3510 -1740 -3500 {
lab=p4}
N -1870 -3680 -1860 -3680 {
lab=vpres9}
N -1740 -3680 -1730 -3680 {
lab=#net311}
N -1790 -3540 -1780 -3540 {
lab=ctrl_pos}
N -1740 -3660 -1740 -3640 {
lab=#net312}
N -1740 -3580 -1740 -3570 {
lab=#net313}
N -1480 -3620 -1480 -3610 {
lab=GND}
N -1480 -3730 -1480 -3720 {
lab=vdd_syn5}
N -1420 -3540 -1410 -3540 {
lab=GND}
N -1420 -3510 -1420 -3500 {
lab=p5}
N -1550 -3680 -1540 -3680 {
lab=vpres9}
N -1420 -3680 -1410 -3680 {
lab=#net314}
N -1470 -3540 -1460 -3540 {
lab=ctrl_pos}
N -1420 -3660 -1420 -3640 {
lab=#net315}
N -1420 -3580 -1420 -3570 {
lab=#net316}
N -1160 -3620 -1160 -3610 {
lab=GND}
N -1160 -3730 -1160 -3720 {
lab=vdd_syn6}
N -1100 -3540 -1090 -3540 {
lab=GND}
N -1100 -3510 -1100 -3500 {
lab=p6}
N -1230 -3680 -1220 -3680 {
lab=vpres9}
N -1100 -3680 -1090 -3680 {
lab=#net317}
N -1150 -3540 -1140 -3540 {
lab=ctrl_pos}
N -1100 -3660 -1100 -3640 {
lab=#net318}
N -1100 -3580 -1100 -3570 {
lab=#net319}
N -840 -3620 -840 -3610 {
lab=GND}
N -840 -3730 -840 -3720 {
lab=vdd_syn7}
N -780 -3540 -770 -3540 {
lab=GND}
N -780 -3510 -780 -3500 {
lab=p7}
N -910 -3680 -900 -3680 {
lab=vpres9}
N -780 -3680 -770 -3680 {
lab=#net320}
N -830 -3540 -820 -3540 {
lab=ctrl_pos}
N -780 -3660 -780 -3640 {
lab=#net321}
N -780 -3580 -780 -3570 {
lab=#net322}
N -520 -3620 -520 -3610 {
lab=GND}
N -520 -3730 -520 -3720 {
lab=vdd_syn8}
N -460 -3540 -450 -3540 {
lab=GND}
N -460 -3510 -460 -3500 {
lab=p8}
N -590 -3680 -580 -3680 {
lab=vpres9}
N -460 -3680 -450 -3680 {
lab=#net323}
N -510 -3540 -500 -3540 {
lab=ctrl_pos}
N -460 -3660 -460 -3640 {
lab=#net324}
N -460 -3580 -460 -3570 {
lab=#net325}
N -200 -3620 -200 -3610 {
lab=GND}
N -200 -3730 -200 -3720 {
lab=vdd_syn9}
N -140 -3540 -130 -3540 {
lab=GND}
N -140 -3510 -140 -3500 {
lab=p9}
N -270 -3680 -260 -3680 {
lab=vpres9}
N -140 -3680 -130 -3680 {
lab=#net326}
N -190 -3540 -180 -3540 {
lab=ctrl_pos}
N -140 -3660 -140 -3640 {
lab=#net327}
N -140 -3580 -140 -3570 {
lab=#net328}
N -2760 -3100 -2760 -3090 {
lab=GND}
N -2760 -3210 -2760 -3200 {
lab=vdd_syn1}
N -2700 -3020 -2690 -3020 {
lab=GND}
N -2700 -2990 -2700 -2980 {
lab=p1}
N -2830 -3160 -2820 -3160 {
lab=vpres10}
N -2700 -3160 -2690 -3160 {
lab=#net329}
N -2750 -3020 -2740 -3020 {
lab=ctrl_pos}
N -2700 -3140 -2700 -3120 {
lab=#net330}
N -2700 -3060 -2700 -3050 {
lab=#net331}
N -2440 -3100 -2440 -3090 {
lab=GND}
N -2440 -3210 -2440 -3200 {
lab=vdd_syn2}
N -2380 -3020 -2370 -3020 {
lab=GND}
N -2380 -2990 -2380 -2980 {
lab=p2}
N -2510 -3160 -2500 -3160 {
lab=vpres10}
N -2380 -3160 -2370 -3160 {
lab=#net332}
N -2430 -3020 -2420 -3020 {
lab=ctrl_pos}
N -2380 -3140 -2380 -3120 {
lab=#net333}
N -2380 -3060 -2380 -3050 {
lab=#net334}
N -2120 -3100 -2120 -3090 {
lab=GND}
N -2120 -3210 -2120 -3200 {
lab=vdd_syn3}
N -2060 -3020 -2050 -3020 {
lab=GND}
N -2060 -2990 -2060 -2980 {
lab=p3}
N -2190 -3160 -2180 -3160 {
lab=vpres10}
N -2060 -3160 -2050 -3160 {
lab=#net335}
N -2110 -3020 -2100 -3020 {
lab=ctrl_pos}
N -2060 -3140 -2060 -3120 {
lab=#net336}
N -2060 -3060 -2060 -3050 {
lab=#net337}
N -1800 -3100 -1800 -3090 {
lab=GND}
N -1800 -3210 -1800 -3200 {
lab=vdd_syn4}
N -1740 -3020 -1730 -3020 {
lab=GND}
N -1740 -2990 -1740 -2980 {
lab=p4}
N -1870 -3160 -1860 -3160 {
lab=vpres10}
N -1740 -3160 -1730 -3160 {
lab=#net338}
N -1790 -3020 -1780 -3020 {
lab=ctrl_pos}
N -1740 -3140 -1740 -3120 {
lab=#net339}
N -1740 -3060 -1740 -3050 {
lab=#net340}
N -1480 -3100 -1480 -3090 {
lab=GND}
N -1480 -3210 -1480 -3200 {
lab=vdd_syn5}
N -1420 -3020 -1410 -3020 {
lab=GND}
N -1420 -2990 -1420 -2980 {
lab=p5}
N -1550 -3160 -1540 -3160 {
lab=vpres10}
N -1420 -3160 -1410 -3160 {
lab=#net341}
N -1470 -3020 -1460 -3020 {
lab=ctrl_pos}
N -1420 -3140 -1420 -3120 {
lab=#net342}
N -1420 -3060 -1420 -3050 {
lab=#net343}
N -1160 -3100 -1160 -3090 {
lab=GND}
N -1160 -3210 -1160 -3200 {
lab=vdd_syn6}
N -1100 -3020 -1090 -3020 {
lab=GND}
N -1100 -2990 -1100 -2980 {
lab=p6}
N -1230 -3160 -1220 -3160 {
lab=vpres10}
N -1100 -3160 -1090 -3160 {
lab=#net344}
N -1150 -3020 -1140 -3020 {
lab=ctrl_pos}
N -1100 -3140 -1100 -3120 {
lab=#net345}
N -1100 -3060 -1100 -3050 {
lab=#net346}
N -840 -3100 -840 -3090 {
lab=GND}
N -840 -3210 -840 -3200 {
lab=vdd_syn7}
N -780 -3020 -770 -3020 {
lab=GND}
N -780 -2990 -780 -2980 {
lab=p7}
N -910 -3160 -900 -3160 {
lab=vpres10}
N -780 -3160 -770 -3160 {
lab=#net347}
N -830 -3020 -820 -3020 {
lab=ctrl_pos}
N -780 -3140 -780 -3120 {
lab=#net348}
N -780 -3060 -780 -3050 {
lab=#net349}
N -520 -3100 -520 -3090 {
lab=GND}
N -520 -3210 -520 -3200 {
lab=vdd_syn8}
N -460 -3020 -450 -3020 {
lab=GND}
N -460 -2990 -460 -2980 {
lab=p8}
N -590 -3160 -580 -3160 {
lab=vpres10}
N -460 -3160 -450 -3160 {
lab=#net350}
N -510 -3020 -500 -3020 {
lab=ctrl_pos}
N -460 -3140 -460 -3120 {
lab=#net351}
N -460 -3060 -460 -3050 {
lab=#net352}
N -200 -3100 -200 -3090 {
lab=GND}
N -200 -3210 -200 -3200 {
lab=vdd_syn9}
N -140 -3020 -130 -3020 {
lab=GND}
N -140 -2990 -140 -2980 {
lab=p9}
N -270 -3160 -260 -3160 {
lab=vpres10}
N -140 -3160 -130 -3160 {
lab=#net353}
N -190 -3020 -180 -3020 {
lab=ctrl_pos}
N -140 -3140 -140 -3120 {
lab=#net354}
N -140 -3060 -140 -3050 {
lab=#net355}
N -2760 -2580 -2760 -2570 {
lab=GND}
N -2760 -2690 -2760 -2680 {
lab=vdd_syn1}
N -2700 -2500 -2690 -2500 {
lab=GND}
N -2700 -2470 -2700 -2460 {
lab=p1}
N -2830 -2640 -2820 -2640 {
lab=vpres11}
N -2700 -2640 -2690 -2640 {
lab=#net356}
N -2750 -2500 -2740 -2500 {
lab=ctrl_pos}
N -2700 -2620 -2700 -2600 {
lab=#net357}
N -2700 -2540 -2700 -2530 {
lab=#net358}
N -2440 -2580 -2440 -2570 {
lab=GND}
N -2440 -2690 -2440 -2680 {
lab=vdd_syn2}
N -2380 -2500 -2370 -2500 {
lab=GND}
N -2380 -2470 -2380 -2460 {
lab=p2}
N -2510 -2640 -2500 -2640 {
lab=vpres11}
N -2380 -2640 -2370 -2640 {
lab=#net359}
N -2430 -2500 -2420 -2500 {
lab=ctrl_pos}
N -2380 -2620 -2380 -2600 {
lab=#net360}
N -2380 -2540 -2380 -2530 {
lab=#net361}
N -2120 -2580 -2120 -2570 {
lab=GND}
N -2120 -2690 -2120 -2680 {
lab=vdd_syn3}
N -2060 -2500 -2050 -2500 {
lab=GND}
N -2060 -2470 -2060 -2460 {
lab=p3}
N -2190 -2640 -2180 -2640 {
lab=vpres11}
N -2060 -2640 -2050 -2640 {
lab=#net362}
N -2110 -2500 -2100 -2500 {
lab=ctrl_pos}
N -2060 -2620 -2060 -2600 {
lab=#net363}
N -2060 -2540 -2060 -2530 {
lab=#net364}
N -1800 -2580 -1800 -2570 {
lab=GND}
N -1800 -2690 -1800 -2680 {
lab=vdd_syn4}
N -1740 -2500 -1730 -2500 {
lab=GND}
N -1740 -2470 -1740 -2460 {
lab=p4}
N -1870 -2640 -1860 -2640 {
lab=vpres11}
N -1740 -2640 -1730 -2640 {
lab=#net365}
N -1790 -2500 -1780 -2500 {
lab=ctrl_pos}
N -1740 -2620 -1740 -2600 {
lab=#net366}
N -1740 -2540 -1740 -2530 {
lab=#net367}
N -1480 -2580 -1480 -2570 {
lab=GND}
N -1480 -2690 -1480 -2680 {
lab=vdd_syn5}
N -1420 -2500 -1410 -2500 {
lab=GND}
N -1420 -2470 -1420 -2460 {
lab=p5}
N -1550 -2640 -1540 -2640 {
lab=vpres11}
N -1420 -2640 -1410 -2640 {
lab=#net368}
N -1470 -2500 -1460 -2500 {
lab=ctrl_pos}
N -1420 -2620 -1420 -2600 {
lab=#net369}
N -1420 -2540 -1420 -2530 {
lab=#net370}
N -1160 -2580 -1160 -2570 {
lab=GND}
N -1160 -2690 -1160 -2680 {
lab=vdd_syn6}
N -1100 -2500 -1090 -2500 {
lab=GND}
N -1100 -2470 -1100 -2460 {
lab=p6}
N -1230 -2640 -1220 -2640 {
lab=vpres11}
N -1100 -2640 -1090 -2640 {
lab=#net371}
N -1150 -2500 -1140 -2500 {
lab=ctrl_pos}
N -1100 -2620 -1100 -2600 {
lab=#net372}
N -1100 -2540 -1100 -2530 {
lab=#net373}
N -840 -2580 -840 -2570 {
lab=GND}
N -840 -2690 -840 -2680 {
lab=vdd_syn7}
N -780 -2500 -770 -2500 {
lab=GND}
N -780 -2470 -780 -2460 {
lab=p7}
N -910 -2640 -900 -2640 {
lab=vpres11}
N -780 -2640 -770 -2640 {
lab=#net374}
N -830 -2500 -820 -2500 {
lab=ctrl_pos}
N -780 -2620 -780 -2600 {
lab=#net375}
N -780 -2540 -780 -2530 {
lab=#net376}
N -520 -2580 -520 -2570 {
lab=GND}
N -520 -2690 -520 -2680 {
lab=vdd_syn8}
N -460 -2500 -450 -2500 {
lab=GND}
N -460 -2470 -460 -2460 {
lab=p8}
N -590 -2640 -580 -2640 {
lab=vpres11}
N -460 -2640 -450 -2640 {
lab=#net377}
N -510 -2500 -500 -2500 {
lab=ctrl_pos}
N -460 -2620 -460 -2600 {
lab=#net378}
N -460 -2540 -460 -2530 {
lab=#net379}
N -200 -2580 -200 -2570 {
lab=GND}
N -200 -2690 -200 -2680 {
lab=vdd_syn9}
N -140 -2500 -130 -2500 {
lab=GND}
N -140 -2470 -140 -2460 {
lab=p9}
N -270 -2640 -260 -2640 {
lab=vpres11}
N -140 -2640 -130 -2640 {
lab=#net380}
N -190 -2500 -180 -2500 {
lab=ctrl_pos}
N -140 -2620 -140 -2600 {
lab=#net381}
N -140 -2540 -140 -2530 {
lab=#net382}
N -2760 -2060 -2760 -2050 {
lab=GND}
N -2760 -2170 -2760 -2160 {
lab=vdd_syn1}
N -2700 -1980 -2690 -1980 {
lab=GND}
N -2700 -1950 -2700 -1940 {
lab=p1}
N -2830 -2120 -2820 -2120 {
lab=vpres12}
N -2700 -2120 -2690 -2120 {
lab=#net383}
N -2750 -1980 -2740 -1980 {
lab=ctrl_pos}
N -2700 -2100 -2700 -2080 {
lab=#net384}
N -2700 -2020 -2700 -2010 {
lab=#net385}
N -2440 -2060 -2440 -2050 {
lab=GND}
N -2440 -2170 -2440 -2160 {
lab=vdd_syn2}
N -2380 -1980 -2370 -1980 {
lab=GND}
N -2380 -1950 -2380 -1940 {
lab=p2}
N -2510 -2120 -2500 -2120 {
lab=vpres12}
N -2380 -2120 -2370 -2120 {
lab=#net386}
N -2430 -1980 -2420 -1980 {
lab=ctrl_pos}
N -2380 -2100 -2380 -2080 {
lab=#net387}
N -2380 -2020 -2380 -2010 {
lab=#net388}
N -2120 -2060 -2120 -2050 {
lab=GND}
N -2120 -2170 -2120 -2160 {
lab=vdd_syn3}
N -2060 -1980 -2050 -1980 {
lab=GND}
N -2060 -1950 -2060 -1940 {
lab=p3}
N -2190 -2120 -2180 -2120 {
lab=vpres12}
N -2060 -2120 -2050 -2120 {
lab=#net389}
N -2110 -1980 -2100 -1980 {
lab=ctrl_pos}
N -2060 -2100 -2060 -2080 {
lab=#net390}
N -2060 -2020 -2060 -2010 {
lab=#net391}
N -1800 -2060 -1800 -2050 {
lab=GND}
N -1800 -2170 -1800 -2160 {
lab=vdd_syn4}
N -1740 -1980 -1730 -1980 {
lab=GND}
N -1740 -1950 -1740 -1940 {
lab=p4}
N -1870 -2120 -1860 -2120 {
lab=vpres12}
N -1740 -2120 -1730 -2120 {
lab=#net392}
N -1790 -1980 -1780 -1980 {
lab=ctrl_pos}
N -1740 -2100 -1740 -2080 {
lab=#net393}
N -1740 -2020 -1740 -2010 {
lab=#net394}
N -1480 -2060 -1480 -2050 {
lab=GND}
N -1480 -2170 -1480 -2160 {
lab=vdd_syn5}
N -1420 -1980 -1410 -1980 {
lab=GND}
N -1420 -1950 -1420 -1940 {
lab=p5}
N -1550 -2120 -1540 -2120 {
lab=vpres12}
N -1420 -2120 -1410 -2120 {
lab=#net395}
N -1470 -1980 -1460 -1980 {
lab=ctrl_pos}
N -1420 -2100 -1420 -2080 {
lab=#net396}
N -1420 -2020 -1420 -2010 {
lab=#net397}
N -1160 -2060 -1160 -2050 {
lab=GND}
N -1160 -2170 -1160 -2160 {
lab=vdd_syn6}
N -1100 -1980 -1090 -1980 {
lab=GND}
N -1100 -1950 -1100 -1940 {
lab=p6}
N -1230 -2120 -1220 -2120 {
lab=vpres12}
N -1100 -2120 -1090 -2120 {
lab=#net398}
N -1150 -1980 -1140 -1980 {
lab=ctrl_pos}
N -1100 -2100 -1100 -2080 {
lab=#net399}
N -1100 -2020 -1100 -2010 {
lab=#net400}
N -840 -2060 -840 -2050 {
lab=GND}
N -840 -2170 -840 -2160 {
lab=vdd_syn7}
N -780 -1980 -770 -1980 {
lab=GND}
N -780 -1950 -780 -1940 {
lab=p7}
N -910 -2120 -900 -2120 {
lab=vpres12}
N -780 -2120 -770 -2120 {
lab=#net401}
N -830 -1980 -820 -1980 {
lab=ctrl_pos}
N -780 -2100 -780 -2080 {
lab=#net402}
N -780 -2020 -780 -2010 {
lab=#net403}
N -520 -2060 -520 -2050 {
lab=GND}
N -520 -2170 -520 -2160 {
lab=vdd_syn8}
N -460 -1980 -450 -1980 {
lab=GND}
N -460 -1950 -460 -1940 {
lab=p8}
N -590 -2120 -580 -2120 {
lab=vpres12}
N -460 -2120 -450 -2120 {
lab=#net404}
N -510 -1980 -500 -1980 {
lab=ctrl_pos}
N -460 -2100 -460 -2080 {
lab=#net405}
N -460 -2020 -460 -2010 {
lab=#net406}
N -200 -2060 -200 -2050 {
lab=GND}
N -200 -2170 -200 -2160 {
lab=vdd_syn9}
N -140 -1980 -130 -1980 {
lab=GND}
N -140 -1950 -140 -1940 {
lab=p9}
N -270 -2120 -260 -2120 {
lab=vpres12}
N -140 -2120 -130 -2120 {
lab=#net407}
N -190 -1980 -180 -1980 {
lab=ctrl_pos}
N -140 -2100 -140 -2080 {
lab=#net408}
N -140 -2020 -140 -2010 {
lab=#net409}
N -2760 -1540 -2760 -1530 {
lab=GND}
N -2760 -1650 -2760 -1640 {
lab=vdd_syn1}
N -2700 -1460 -2690 -1460 {
lab=GND}
N -2700 -1430 -2700 -1420 {
lab=p1}
N -2830 -1600 -2820 -1600 {
lab=vpres13}
N -2700 -1600 -2690 -1600 {
lab=#net410}
N -2750 -1460 -2740 -1460 {
lab=ctrl_pos}
N -2700 -1580 -2700 -1560 {
lab=#net411}
N -2700 -1500 -2700 -1490 {
lab=#net412}
N -2440 -1540 -2440 -1530 {
lab=GND}
N -2440 -1650 -2440 -1640 {
lab=vdd_syn2}
N -2380 -1460 -2370 -1460 {
lab=GND}
N -2380 -1430 -2380 -1420 {
lab=p2}
N -2510 -1600 -2500 -1600 {
lab=vpres13}
N -2380 -1600 -2370 -1600 {
lab=#net413}
N -2430 -1460 -2420 -1460 {
lab=ctrl_pos}
N -2380 -1580 -2380 -1560 {
lab=#net414}
N -2380 -1500 -2380 -1490 {
lab=#net415}
N -2120 -1540 -2120 -1530 {
lab=GND}
N -2120 -1650 -2120 -1640 {
lab=vdd_syn3}
N -2060 -1460 -2050 -1460 {
lab=GND}
N -2060 -1430 -2060 -1420 {
lab=p3}
N -2190 -1600 -2180 -1600 {
lab=vpres13}
N -2060 -1600 -2050 -1600 {
lab=#net416}
N -2110 -1460 -2100 -1460 {
lab=ctrl_pos}
N -2060 -1580 -2060 -1560 {
lab=#net417}
N -2060 -1500 -2060 -1490 {
lab=#net418}
N -1800 -1540 -1800 -1530 {
lab=GND}
N -1800 -1650 -1800 -1640 {
lab=vdd_syn4}
N -1740 -1460 -1730 -1460 {
lab=GND}
N -1740 -1430 -1740 -1420 {
lab=p4}
N -1870 -1600 -1860 -1600 {
lab=vpres13}
N -1740 -1600 -1730 -1600 {
lab=#net419}
N -1790 -1460 -1780 -1460 {
lab=ctrl_pos}
N -1740 -1580 -1740 -1560 {
lab=#net420}
N -1740 -1500 -1740 -1490 {
lab=#net421}
N -1480 -1540 -1480 -1530 {
lab=GND}
N -1480 -1650 -1480 -1640 {
lab=vdd_syn5}
N -1420 -1460 -1410 -1460 {
lab=GND}
N -1420 -1430 -1420 -1420 {
lab=p5}
N -1550 -1600 -1540 -1600 {
lab=vpres13}
N -1420 -1600 -1410 -1600 {
lab=#net422}
N -1470 -1460 -1460 -1460 {
lab=ctrl_pos}
N -1420 -1580 -1420 -1560 {
lab=#net423}
N -1420 -1500 -1420 -1490 {
lab=#net424}
N -1160 -1540 -1160 -1530 {
lab=GND}
N -1160 -1650 -1160 -1640 {
lab=vdd_syn6}
N -1100 -1460 -1090 -1460 {
lab=GND}
N -1100 -1430 -1100 -1420 {
lab=p6}
N -1230 -1600 -1220 -1600 {
lab=vpres13}
N -1100 -1600 -1090 -1600 {
lab=#net425}
N -1150 -1460 -1140 -1460 {
lab=ctrl_pos}
N -1100 -1580 -1100 -1560 {
lab=#net426}
N -1100 -1500 -1100 -1490 {
lab=#net427}
N -840 -1540 -840 -1530 {
lab=GND}
N -840 -1650 -840 -1640 {
lab=vdd_syn7}
N -780 -1460 -770 -1460 {
lab=GND}
N -780 -1430 -780 -1420 {
lab=p7}
N -910 -1600 -900 -1600 {
lab=vpres13}
N -780 -1600 -770 -1600 {
lab=#net428}
N -830 -1460 -820 -1460 {
lab=ctrl_pos}
N -780 -1580 -780 -1560 {
lab=#net429}
N -780 -1500 -780 -1490 {
lab=#net430}
N -520 -1540 -520 -1530 {
lab=GND}
N -520 -1650 -520 -1640 {
lab=vdd_syn8}
N -460 -1460 -450 -1460 {
lab=GND}
N -460 -1430 -460 -1420 {
lab=p8}
N -590 -1600 -580 -1600 {
lab=vpres13}
N -460 -1600 -450 -1600 {
lab=#net431}
N -510 -1460 -500 -1460 {
lab=ctrl_pos}
N -460 -1580 -460 -1560 {
lab=#net432}
N -460 -1500 -460 -1490 {
lab=#net433}
N -200 -1540 -200 -1530 {
lab=GND}
N -200 -1650 -200 -1640 {
lab=vdd_syn9}
N -140 -1460 -130 -1460 {
lab=GND}
N -140 -1430 -140 -1420 {
lab=p9}
N -270 -1600 -260 -1600 {
lab=vpres13}
N -140 -1600 -130 -1600 {
lab=#net434}
N -190 -1460 -180 -1460 {
lab=ctrl_pos}
N -140 -1580 -140 -1560 {
lab=#net435}
N -140 -1500 -140 -1490 {
lab=#net436}
N -2760 -1020 -2760 -1010 {
lab=GND}
N -2760 -1130 -2760 -1120 {
lab=vdd_syn1}
N -2700 -940 -2690 -940 {
lab=GND}
N -2700 -910 -2700 -900 {
lab=p1}
N -2830 -1080 -2820 -1080 {
lab=vpres14}
N -2700 -1080 -2690 -1080 {
lab=#net437}
N -2750 -940 -2740 -940 {
lab=ctrl_pos}
N -2700 -1060 -2700 -1040 {
lab=#net438}
N -2700 -980 -2700 -970 {
lab=#net439}
N -2440 -1020 -2440 -1010 {
lab=GND}
N -2440 -1130 -2440 -1120 {
lab=vdd_syn2}
N -2380 -940 -2370 -940 {
lab=GND}
N -2380 -910 -2380 -900 {
lab=p2}
N -2510 -1080 -2500 -1080 {
lab=vpres14}
N -2380 -1080 -2370 -1080 {
lab=#net440}
N -2430 -940 -2420 -940 {
lab=ctrl_pos}
N -2380 -1060 -2380 -1040 {
lab=#net441}
N -2380 -980 -2380 -970 {
lab=#net442}
N -2120 -1020 -2120 -1010 {
lab=GND}
N -2120 -1130 -2120 -1120 {
lab=vdd_syn3}
N -2060 -940 -2050 -940 {
lab=GND}
N -2060 -910 -2060 -900 {
lab=p3}
N -2190 -1080 -2180 -1080 {
lab=vpres14}
N -2060 -1080 -2050 -1080 {
lab=#net443}
N -2110 -940 -2100 -940 {
lab=ctrl_pos}
N -2060 -1060 -2060 -1040 {
lab=#net444}
N -2060 -980 -2060 -970 {
lab=#net445}
N -1800 -1020 -1800 -1010 {
lab=GND}
N -1800 -1130 -1800 -1120 {
lab=vdd_syn4}
N -1740 -940 -1730 -940 {
lab=GND}
N -1740 -910 -1740 -900 {
lab=p4}
N -1870 -1080 -1860 -1080 {
lab=vpres14}
N -1740 -1080 -1730 -1080 {
lab=#net446}
N -1790 -940 -1780 -940 {
lab=ctrl_pos}
N -1740 -1060 -1740 -1040 {
lab=#net447}
N -1740 -980 -1740 -970 {
lab=#net448}
N -1480 -1020 -1480 -1010 {
lab=GND}
N -1480 -1130 -1480 -1120 {
lab=vdd_syn5}
N -1420 -940 -1410 -940 {
lab=GND}
N -1420 -910 -1420 -900 {
lab=p5}
N -1550 -1080 -1540 -1080 {
lab=vpres14}
N -1420 -1080 -1410 -1080 {
lab=#net449}
N -1470 -940 -1460 -940 {
lab=ctrl_pos}
N -1420 -1060 -1420 -1040 {
lab=#net450}
N -1420 -980 -1420 -970 {
lab=#net451}
N -1160 -1020 -1160 -1010 {
lab=GND}
N -1160 -1130 -1160 -1120 {
lab=vdd_syn6}
N -1100 -940 -1090 -940 {
lab=GND}
N -1100 -910 -1100 -900 {
lab=p6}
N -1230 -1080 -1220 -1080 {
lab=vpres14}
N -1100 -1080 -1090 -1080 {
lab=#net452}
N -1150 -940 -1140 -940 {
lab=ctrl_pos}
N -1100 -1060 -1100 -1040 {
lab=#net453}
N -1100 -980 -1100 -970 {
lab=#net454}
N -840 -1020 -840 -1010 {
lab=GND}
N -840 -1130 -840 -1120 {
lab=vdd_syn7}
N -780 -940 -770 -940 {
lab=GND}
N -780 -910 -780 -900 {
lab=p7}
N -910 -1080 -900 -1080 {
lab=vpres14}
N -780 -1080 -770 -1080 {
lab=#net455}
N -830 -940 -820 -940 {
lab=ctrl_pos}
N -780 -1060 -780 -1040 {
lab=#net456}
N -780 -980 -780 -970 {
lab=#net457}
N -520 -1020 -520 -1010 {
lab=GND}
N -520 -1130 -520 -1120 {
lab=vdd_syn8}
N -460 -940 -450 -940 {
lab=GND}
N -460 -910 -460 -900 {
lab=p8}
N -590 -1080 -580 -1080 {
lab=vpres14}
N -460 -1080 -450 -1080 {
lab=#net458}
N -510 -940 -500 -940 {
lab=ctrl_pos}
N -460 -1060 -460 -1040 {
lab=#net459}
N -460 -980 -460 -970 {
lab=#net460}
N -200 -1020 -200 -1010 {
lab=GND}
N -200 -1130 -200 -1120 {
lab=vdd_syn9}
N -140 -940 -130 -940 {
lab=GND}
N -140 -910 -140 -900 {
lab=p9}
N -270 -1080 -260 -1080 {
lab=vpres14}
N -140 -1080 -130 -1080 {
lab=#net461}
N -190 -940 -180 -940 {
lab=ctrl_pos}
N -140 -1060 -140 -1040 {
lab=#net462}
N -140 -980 -140 -970 {
lab=#net463}
N -2760 -500 -2760 -490 {
lab=GND}
N -2760 -610 -2760 -600 {
lab=vdd_syn1}
N -2700 -420 -2690 -420 {
lab=GND}
N -2700 -390 -2700 -380 {
lab=p1}
N -2830 -560 -2820 -560 {
lab=vpres15}
N -2700 -560 -2690 -560 {
lab=#net464}
N -2750 -420 -2740 -420 {
lab=ctrl_pos}
N -2700 -540 -2700 -520 {
lab=#net465}
N -2700 -460 -2700 -450 {
lab=#net466}
N -2440 -500 -2440 -490 {
lab=GND}
N -2440 -610 -2440 -600 {
lab=vdd_syn2}
N -2380 -420 -2370 -420 {
lab=GND}
N -2380 -390 -2380 -380 {
lab=p2}
N -2510 -560 -2500 -560 {
lab=vpres15}
N -2380 -560 -2370 -560 {
lab=#net467}
N -2430 -420 -2420 -420 {
lab=ctrl_pos}
N -2380 -540 -2380 -520 {
lab=#net468}
N -2380 -460 -2380 -450 {
lab=#net469}
N -2120 -500 -2120 -490 {
lab=GND}
N -2120 -610 -2120 -600 {
lab=vdd_syn3}
N -2060 -420 -2050 -420 {
lab=GND}
N -2060 -390 -2060 -380 {
lab=p3}
N -2190 -560 -2180 -560 {
lab=vpres15}
N -2060 -560 -2050 -560 {
lab=#net470}
N -2110 -420 -2100 -420 {
lab=ctrl_pos}
N -2060 -540 -2060 -520 {
lab=#net471}
N -2060 -460 -2060 -450 {
lab=#net472}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn4}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p4}
N -1870 -560 -1860 -560 {
lab=vpres15}
N -1740 -560 -1730 -560 {
lab=#net473}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net474}
N -1740 -460 -1740 -450 {
lab=#net475}
N -1480 -500 -1480 -490 {
lab=GND}
N -1480 -610 -1480 -600 {
lab=vdd_syn5}
N -1420 -420 -1410 -420 {
lab=GND}
N -1420 -390 -1420 -380 {
lab=p5}
N -1550 -560 -1540 -560 {
lab=vpres15}
N -1420 -560 -1410 -560 {
lab=#net476}
N -1470 -420 -1460 -420 {
lab=ctrl_pos}
N -1420 -540 -1420 -520 {
lab=#net477}
N -1420 -460 -1420 -450 {
lab=#net478}
N -1160 -500 -1160 -490 {
lab=GND}
N -1160 -610 -1160 -600 {
lab=vdd_syn6}
N -1100 -420 -1090 -420 {
lab=GND}
N -1100 -390 -1100 -380 {
lab=p6}
N -1230 -560 -1220 -560 {
lab=vpres15}
N -1100 -560 -1090 -560 {
lab=#net479}
N -1150 -420 -1140 -420 {
lab=ctrl_pos}
N -1100 -540 -1100 -520 {
lab=#net480}
N -1100 -460 -1100 -450 {
lab=#net481}
N -840 -500 -840 -490 {
lab=GND}
N -840 -610 -840 -600 {
lab=vdd_syn7}
N -780 -420 -770 -420 {
lab=GND}
N -780 -390 -780 -380 {
lab=p7}
N -910 -560 -900 -560 {
lab=vpres15}
N -780 -560 -770 -560 {
lab=#net482}
N -830 -420 -820 -420 {
lab=ctrl_pos}
N -780 -540 -780 -520 {
lab=#net483}
N -780 -460 -780 -450 {
lab=#net484}
N -520 -500 -520 -490 {
lab=GND}
N -520 -610 -520 -600 {
lab=vdd_syn8}
N -460 -420 -450 -420 {
lab=GND}
N -460 -390 -460 -380 {
lab=p8}
N -590 -560 -580 -560 {
lab=vpres15}
N -460 -560 -450 -560 {
lab=#net485}
N -510 -420 -500 -420 {
lab=ctrl_pos}
N -460 -540 -460 -520 {
lab=#net486}
N -460 -460 -460 -450 {
lab=#net487}
N -200 -500 -200 -490 {
lab=GND}
N -200 -610 -200 -600 {
lab=vdd_syn9}
N -140 -420 -130 -420 {
lab=GND}
N -140 -390 -140 -380 {
lab=p9}
N -270 -560 -260 -560 {
lab=vpres15}
N -140 -560 -130 -560 {
lab=#net488}
N -190 -420 -180 -420 {
lab=ctrl_pos}
N -140 -540 -140 -520 {
lab=#net489}
N -140 -460 -140 -450 {
lab=#net490}
N 30 -4370 40 -4370 {
lab=1}
N 30 -4390 40 -4390 {
lab=2}
N 30 -4410 40 -4410 {
lab=3}
N 30 -4430 40 -4430 {
lab=4}
N 30 -4450 40 -4450 {
lab=5}
N 30 -4470 40 -4470 {
lab=6}
N 30 -4490 40 -4490 {
lab=7}
N 30 -4510 40 -4510 {
lab=8}
N 30 -4530 40 -4530 {
lab=9}
N 120 -2760 120 -2740 {
lab=GND}
N 120 -2840 120 -2820 {
lab=vdd_syn1}
N 220 -2760 220 -2740 {
lab=GND}
N 220 -2840 220 -2820 {
lab=vdd_syn2}
N 320 -2760 320 -2740 {
lab=GND}
N 320 -2840 320 -2820 {
lab=vdd_syn3}
N 420 -2760 420 -2740 {
lab=GND}
N 420 -2840 420 -2820 {
lab=vdd_syn4}
N 520 -2760 520 -2740 {
lab=GND}
N 520 -2840 520 -2820 {
lab=vdd_syn5}
N 620 -2760 620 -2740 {
lab=GND}
N 620 -2840 620 -2820 {
lab=vdd_syn6}
N 720 -2760 720 -2740 {
lab=GND}
N 720 -2840 720 -2820 {
lab=vdd_syn7}
N 820 -2760 820 -2740 {
lab=GND}
N 820 -2840 820 -2820 {
lab=vdd_syn8}
N 920 -2760 920 -2740 {
lab=GND}
N 920 -2840 920 -2820 {
lab=vdd_syn9}
N 800 -2620 800 -2600 {
lab=GND}
N 800 -2700 800 -2680 {
lab=b_px}
N 720 -2620 720 -2600 {
lab=GND}
N 720 -2700 720 -2680 {
lab=w_px}
C {devices/vsource.sym} 20 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} 20 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 100 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} 100 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 100 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -3760 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -3860 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} 110 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -10 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} 240 -2120 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param L_mem_in=0.15
.param W_mem_in=10
.param L_mem_out=0.25
.param W_mem_out=0.45
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
	save all
	tran 1u 150u
	write SNN_15x1_lt_tb.raw
	*wrdata SNN_15x1_lt_tb.ssv v(8)
.endc
" }
C {devices/launcher.sym} 80 -1735 0 0 {name=h1
descr="load 1" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_lt_tb.raw tran"
}
C {devices/lab_pin.sym} -3940 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} 280 -2650 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} 280 -2600 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} 280 -2700 2 0 {name=p16 sig_type=std_logic lab=vdd_stdp}
C {devices/gnd.sym} -3080 -7770 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -3150 -7840 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -3020 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -3020 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3060 -260 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -3090 -140 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -3020 -300 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -3020 -340 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3020 -10 2 0 {name=p61 sig_type=std_logic lab=0}
C {devices/vsource.sym} 20 -2230 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 20 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} 20 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} 200 -2230 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} 200 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 200 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} 460 -2230 0 0 {name=V15 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 460 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 460 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -4110 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} 20 -2370 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 20 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 20 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 100 -2370 0 0 {name=V12 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} 100 -2320 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 100 -2420 2 0 {name=p17 sig_type=std_logic lab=ctrl_tr}
C {devices/vsource.sym} 180 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} 180 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 180 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 190 -2650 0 0 {name=V3 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 190 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 190 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} 380 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 380 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 380 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_wu}
C {devices/vsource.sym} 460 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} 460 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 460 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tr}
C {devices/vsource.sym} 20 -2510 0 0 {name=V7 value="PWL(0 0.8 124.9u 0.8 125u 0.45)"
*0.55}
C {devices/gnd.sym} 20 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 20 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} 100 -2510 0 0 {name=V8 value=0.55}
C {devices/gnd.sym} 100 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 100 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -3760 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2950 -140 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} 20 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -4000 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -3860 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -7790 0 0 {name=I1 value=0}
C {devices/gnd.sym} -4140 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -3080 -7250 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -3150 -7320 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/gnd.sym} -3390 -7940 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -3330 -7990 2 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -3450 -7990 0 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -3020 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -3020 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3330 -7690 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3610 -7840 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -4110 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -3390 -7640 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -3330 -7840 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3450 -7840 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -3450 -7870 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -3760 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3390 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -7900 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -4000 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3070 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -3070 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} 180 -2370 0 0 {name=V16 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 180 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 180 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} 620 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} 620 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 620 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} 120 -4290 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 120 -4590 2 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -3090 -260 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} 340 -2370 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} 340 -2320 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} 340 -2420 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 310 -4440 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 160 -4040 2 0 {name=p94 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4020 3 0 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -4050 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 120 -3990 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -4040 0 0 {name=p85 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} 340 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} 340 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 340 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2980 -260 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} 20 -2790 0 0 {name=V10 value=1.8
*"PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 20 -2740 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 20 -2840 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -3080 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -3020 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -3020 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -3150 -6280 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -3020 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -3020 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -3150 -5760 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -3020 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -3020 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -3020 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -3020 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -3020 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -3020 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -3020 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -3020 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -3150 -3680 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -3020 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -3020 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -3860 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -6230 0 0 {name=I4 value=0}
C {devices/gnd.sym} -4140 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -4110 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -3760 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -3860 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -6750 0 0 {name=I3 value=0}
C {devices/gnd.sym} -4140 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -4110 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -3760 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -3860 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -5190 0 0 {name=I6 value=0}
C {devices/gnd.sym} -4140 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -4110 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -3760 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -3860 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -5710 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -4110 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -3760 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -3860 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -4150 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -4110 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -3760 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -3860 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -4670 0 0 {name=I7 value=0}
C {devices/gnd.sym} -4140 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -4110 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -3760 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -3860 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -3630 0 0 {name=I9 value=0}
C {devices/gnd.sym} -4140 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -4110 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} 30 -4350 0 0 {name=p105 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -3610 -7320 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3610 -6800 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3150 -6800 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3610 -3680 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3150 -4200 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3610 -4200 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3150 -4720 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3610 -4720 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3150 -5240 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3610 -5240 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3610 -5760 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3610 -6280 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/launcher.sym} 90 -1815 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -3020 -160 1 0 {name=x0}
C {devices/gnd.sym} -3080 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -3020 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -3020 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -3020 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -3020 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -3020 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -3020 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -3020 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -3020 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -3020 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -3020 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -3020 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -3020 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -3860 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -3110 0 0 {name=I10 value=0}
C {devices/gnd.sym} -4140 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -4110 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -3860 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2070 0 0 {name=I12 value=0}
C {devices/gnd.sym} -4140 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -4110 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -3760 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -3860 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2590 0 0 {name=I11 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -4110 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -3760 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -3860 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -4110 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -3760 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -3860 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -1550 0 0 {name=I13 value=0}
C {devices/gnd.sym} -4140 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -4110 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -3760 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -3860 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -510 0 0 {name=I15 value=0}
C {devices/gnd.sym} -4140 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -4110 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -3760 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3610 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3610 -1080 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3610 -1600 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3610 -2640 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3610 -3160 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -3150 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -380 0 0 {name=x150}
C {devices/lab_pin.sym} -3150 -1080 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3150 -1600 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3150 -3160 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3150 -2640 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3610 -2120 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3150 -2120 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3080 -7890 0 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -7370 0 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -5290 0 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3210 0 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/launcher.sym} 80 -1675 0 0 {name=h3
descr="load 8" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -7690 0 0 {name=x2013}
C {devices/lab_pin.sym} -3450 -7720 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 260 -2370 0 0 {name=V20 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 260 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 260 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3390 -7420 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -3330 -7470 2 0 {name=p2 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -3390 -7120 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -3450 -7350 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -7270 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -3390 -7230 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -7380 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -7320 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -7170 0 0 {name=x2023}
C {devices/lab_pin.sym} -3450 -7200 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -6900 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -3330 -6950 2 0 {name=p52 sig_type=std_logic lab=vpos3}
C {devices/gnd.sym} -3390 -6600 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -3450 -6830 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -6750 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -3390 -6710 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -6860 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -6800 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -6650 0 0 {name=x2033}
C {devices/lab_pin.sym} -3450 -6680 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -6380 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -3330 -6430 2 0 {name=p77 sig_type=std_logic lab=vpos4}
C {devices/gnd.sym} -3390 -6080 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -3450 -6310 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -6230 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -3390 -6190 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -6340 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -6280 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -6130 0 0 {name=x2043}
C {devices/lab_pin.sym} -3450 -6160 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -5860 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -3330 -5910 2 0 {name=p102 sig_type=std_logic lab=vpos5}
C {devices/gnd.sym} -3390 -5560 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -3450 -5790 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -5710 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -3390 -5670 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -5820 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -5760 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -5610 0 0 {name=x2053}
C {devices/lab_pin.sym} -3450 -5640 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -5340 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -3330 -5390 2 0 {name=p122 sig_type=std_logic lab=vpos6}
C {devices/gnd.sym} -3390 -5040 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -3450 -5270 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -5190 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -3390 -5150 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -5300 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -5240 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -5090 0 0 {name=x2063}
C {devices/lab_pin.sym} -3450 -5120 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -4820 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -3330 -4870 2 0 {name=p145 sig_type=std_logic lab=vpos7}
C {devices/gnd.sym} -3390 -4520 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -3450 -4750 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4670 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -3390 -4630 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4780 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4720 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4570 0 0 {name=x2073}
C {devices/lab_pin.sym} -3450 -4600 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -4300 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -3330 -4350 2 0 {name=p157 sig_type=std_logic lab=vpos8}
C {devices/gnd.sym} -3390 -4000 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -3450 -4230 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4150 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -3390 -4110 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4260 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4200 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4050 0 0 {name=x2083}
C {devices/lab_pin.sym} -3450 -4080 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3780 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -3330 -3830 2 0 {name=p173 sig_type=std_logic lab=vpos9}
C {devices/gnd.sym} -3390 -3480 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -3450 -3710 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3630 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -3390 -3590 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3740 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3680 0 0 {name=x2092}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3530 0 0 {name=x2093}
C {devices/lab_pin.sym} -3450 -3560 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3260 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -3330 -3310 2 0 {name=p188 sig_type=std_logic lab=vpos10}
C {devices/gnd.sym} -3390 -2960 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -3450 -3190 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3110 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -3390 -3070 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3220 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3160 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3010 0 0 {name=x2103}
C {devices/lab_pin.sym} -3450 -3040 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2740 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -3330 -2790 2 0 {name=p200 sig_type=std_logic lab=vpos11}
C {devices/gnd.sym} -3390 -2440 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -3450 -2670 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2590 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -3390 -2550 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2700 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2640 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2490 0 0 {name=x2113}
C {devices/lab_pin.sym} -3450 -2520 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2220 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -3330 -2270 2 0 {name=p212 sig_type=std_logic lab=vpos12}
C {devices/gnd.sym} -3390 -1920 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -3450 -2150 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2070 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -3390 -2030 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2180 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2120 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1970 0 0 {name=x2123}
C {devices/lab_pin.sym} -3450 -2000 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1700 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -3330 -1750 2 0 {name=p229 sig_type=std_logic lab=vpos13}
C {devices/gnd.sym} -3390 -1400 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -3450 -1630 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1550 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -3390 -1510 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1660 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1600 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1450 0 0 {name=x2133}
C {devices/lab_pin.sym} -3450 -1480 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1180 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -3330 -1230 2 0 {name=p242 sig_type=std_logic lab=vpos14}
C {devices/gnd.sym} -3390 -880 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -3450 -1110 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1030 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -3390 -990 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1140 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1080 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -930 0 0 {name=x2143}
C {devices/lab_pin.sym} -3450 -960 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -660 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -3330 -710 2 0 {name=p255 sig_type=std_logic lab=vpos15}
C {devices/gnd.sym} -3390 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -3450 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -3390 -770 0 0 {name=p261 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -740 0 0 {name=p266 sig_type=std_logic lab=ctrl_tr}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -560 0 0 {name=x2152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -410 0 0 {name=x2153}
C {devices/lab_pin.sym} -3450 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -3330 -7320 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3330 -7170 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3450 -7320 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3450 -7470 0 0 {name=p20 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3450 -6800 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3450 -6950 0 0 {name=p54 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3330 -6800 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3330 -6650 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3450 -6280 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3450 -6430 0 0 {name=p83 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3330 -6280 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -6130 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -5760 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3330 -5610 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3450 -5760 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3450 -5910 0 0 {name=p109 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3450 -5240 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3450 -5390 0 0 {name=p126 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3330 -5240 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3330 -5090 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3450 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3450 -710 0 0 {name=p147 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3330 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3330 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3450 -1080 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3450 -1230 0 0 {name=p244 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3330 -1080 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3330 -930 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3450 -1600 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3450 -1750 0 0 {name=p231 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3330 -1600 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3330 -1450 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3450 -2120 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3450 -2270 0 0 {name=p214 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3330 -2120 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -1970 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -2640 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3330 -2490 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3450 -2640 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3450 -2790 0 0 {name=p204 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3450 -3160 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3450 -3310 0 0 {name=p190 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3330 -3160 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3330 -3010 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3450 -3680 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3450 -3830 0 0 {name=p175 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3330 -3680 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3330 -3530 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3450 -4200 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3450 -4350 0 0 {name=p161 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3330 -4200 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3330 -4050 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3450 -4720 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3450 -4870 0 0 {name=p257 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3330 -4720 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3330 -4570 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -7990 0 0 {name=x2011}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -710 0 0 {name=x2151}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -1230 0 0 {name=x2141}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -1750 0 0 {name=x2131}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -2270 0 0 {name=x2121}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -2790 0 0 {name=x2111}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -3310 0 0 {name=x2101}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -3830 0 0 {name=x2091}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -4350 0 0 {name=x2081}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -4870 0 0 {name=x2071}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -5390 0 0 {name=x2061}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -5910 0 0 {name=x2051}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -6430 0 0 {name=x2041}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -6950 0 0 {name=x2031}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -3390 -7470 0 0 {name=x2021}
C {devices/vsource.sym} 260 -2510 0 0 {name=V21 value=0.5}
C {devices/gnd.sym} 260 -2460 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} 260 -2560 2 0 {name=p268 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -680 0 0 {name=p269 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -900 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1200 0 0 {name=p68 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -1420 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1720 0 0 {name=p100 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -1940 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2240 0 0 {name=p135 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -2460 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2760 0 0 {name=p169 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -2980 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3280 0 0 {name=p197 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -3500 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3800 0 0 {name=p226 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -4020 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4320 0 0 {name=p251 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -4540 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4840 0 0 {name=p271 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -5060 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -5360 0 0 {name=p273 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -5580 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -5880 0 0 {name=p275 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -6100 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -6400 0 0 {name=p278 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -6620 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -6920 0 0 {name=p280 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -7140 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -7440 0 0 {name=p282 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -7660 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -7960 0 0 {name=p284 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -3450 -1260 0 0 {name=p15 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -1780 0 0 {name=p49 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -2300 0 0 {name=p69 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -2820 0 0 {name=p99 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -3340 0 0 {name=p118 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -3860 0 0 {name=p137 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -4380 0 0 {name=p155 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -4900 0 0 {name=p171 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -5420 0 0 {name=p186 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -5940 0 0 {name=p198 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -6460 0 0 {name=p210 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -6980 0 0 {name=p227 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -7500 0 0 {name=p240 sig_type=std_logic lab=ctrl_tr}
C {devices/lab_pin.sym} -3450 -8020 0 0 {name=p253 sig_type=std_logic lab=ctrl_tr}
C {devices/vsource.sym} 540 -2650 0 0 {name=V22 value=1.8}
C {devices/gnd.sym} 540 -2600 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 540 -2700 2 0 {name=p285 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3390 -1290 0 0 {name=p24 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -1810 0 0 {name=p45 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -2330 0 0 {name=p62 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -2850 0 0 {name=p90 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -3370 0 0 {name=p112 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -3890 0 0 {name=p132 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -4410 0 0 {name=p151 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -4930 0 0 {name=p166 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -5450 0 0 {name=p181 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -5970 0 0 {name=p194 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -6490 0 0 {name=p206 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -7010 0 0 {name=p221 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -7530 0 0 {name=p236 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -3390 -8050 0 0 {name=p248 sig_type=std_logic lab=vdd_tr}
C {devices/lab_pin.sym} -2740 -260 1 0 {name=p286 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2770 -140 0 0 {name=l90 lab=GND}
C {devices/ammeter.sym} -2700 -300 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -2700 -340 2 0 {name=p287 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2700 -10 2 0 {name=p288 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} -2630 -140 3 0 {name=p289 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2770 -260 1 0 {name=p290 sig_type=std_logic lab=inh1}
C {devices/lab_pin.sym} -2660 -260 1 0 {name=p291 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2700 -160 1 0 {name=x1}
C {devices/lab_pin.sym} -2420 -260 1 0 {name=p292 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2450 -140 0 0 {name=l91 lab=GND}
C {devices/ammeter.sym} -2380 -300 0 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -2380 -340 2 0 {name=p294 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2380 -10 2 0 {name=p295 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} -2310 -140 3 0 {name=p296 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2450 -260 1 0 {name=p297 sig_type=std_logic lab=inh2}
C {devices/lab_pin.sym} -2340 -260 1 0 {name=p298 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2380 -160 1 0 {name=x2}
C {devices/lab_pin.sym} -2100 -260 1 0 {name=p299 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2130 -140 0 0 {name=l92 lab=GND}
C {devices/ammeter.sym} -2060 -300 0 0 {name=Vmeas3 savecurrent=true}
C {devices/lab_pin.sym} -2060 -340 2 0 {name=p300 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2060 -10 2 0 {name=p301 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} -1990 -140 3 0 {name=p302 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2130 -260 1 0 {name=p303 sig_type=std_logic lab=inh3}
C {devices/lab_pin.sym} -2020 -260 1 0 {name=p305 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2060 -160 1 0 {name=x3}
C {devices/lab_pin.sym} -1780 -260 1 0 {name=p306 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -140 0 0 {name=l93 lab=GND}
C {devices/ammeter.sym} -1740 -300 0 0 {name=Vmeas4 savecurrent=true}
C {devices/lab_pin.sym} -1740 -340 2 0 {name=p307 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1740 -10 2 0 {name=p308 sig_type=std_logic lab=4}
C {devices/lab_pin.sym} -1670 -140 3 0 {name=p309 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1810 -260 1 0 {name=p310 sig_type=std_logic lab=inh4}
C {devices/lab_pin.sym} -1700 -260 1 0 {name=p311 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -160 1 0 {name=x4}
C {devices/lab_pin.sym} -1460 -260 1 0 {name=p314 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1490 -140 0 0 {name=l94 lab=GND}
C {devices/ammeter.sym} -1420 -300 0 0 {name=Vmeas5 savecurrent=true}
C {devices/lab_pin.sym} -1420 -340 2 0 {name=p316 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1420 -10 2 0 {name=p318 sig_type=std_logic lab=5}
C {devices/lab_pin.sym} -1350 -140 3 0 {name=p320 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1490 -260 1 0 {name=p322 sig_type=std_logic lab=inh5}
C {devices/lab_pin.sym} -1380 -260 1 0 {name=p323 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1420 -160 1 0 {name=x5}
C {devices/lab_pin.sym} -1140 -260 1 0 {name=p355 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1170 -140 0 0 {name=l95 lab=GND}
C {devices/ammeter.sym} -1100 -300 0 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -1100 -340 2 0 {name=p356 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1100 -10 2 0 {name=p357 sig_type=std_logic lab=6}
C {devices/lab_pin.sym} -1030 -140 3 0 {name=p358 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1170 -260 1 0 {name=p360 sig_type=std_logic lab=inh6}
C {devices/lab_pin.sym} -1060 -260 1 0 {name=p364 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1100 -160 1 0 {name=x6}
C {devices/lab_pin.sym} -820 -260 1 0 {name=p366 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -850 -140 0 0 {name=l96 lab=GND}
C {devices/ammeter.sym} -780 -300 0 0 {name=Vmeas7 savecurrent=true}
C {devices/lab_pin.sym} -780 -340 2 0 {name=p368 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -780 -10 2 0 {name=p370 sig_type=std_logic lab=7}
C {devices/lab_pin.sym} -710 -140 3 0 {name=p371 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -850 -260 1 0 {name=p372 sig_type=std_logic lab=inh7}
C {devices/lab_pin.sym} -740 -260 1 0 {name=p374 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -780 -160 1 0 {name=x7}
C {devices/lab_pin.sym} -500 -260 1 0 {name=p375 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -530 -140 0 0 {name=l97 lab=GND}
C {devices/ammeter.sym} -460 -300 0 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -460 -340 2 0 {name=p377 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -460 -10 2 0 {name=p379 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} -390 -140 3 0 {name=p381 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -530 -260 1 0 {name=p383 sig_type=std_logic lab=inh8}
C {devices/lab_pin.sym} -420 -260 1 0 {name=p384 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -460 -160 1 0 {name=x8}
C {devices/lab_pin.sym} -180 -260 1 0 {name=p390 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -210 -140 0 0 {name=l98 lab=GND}
C {devices/ammeter.sym} -140 -300 0 0 {name=Vmeas9 savecurrent=true}
C {devices/lab_pin.sym} -140 -340 2 0 {name=p391 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -140 -10 2 0 {name=p393 sig_type=std_logic lab=9}
C {devices/lab_pin.sym} -70 -140 3 0 {name=p395 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -210 -260 1 0 {name=p397 sig_type=std_logic lab=inh9}
C {devices/lab_pin.sym} -100 -260 1 0 {name=p398 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -140 -160 1 0 {name=x9}
C {devices/gnd.sym} -2760 -7770 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2830 -7840 0 0 {name=p399 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2700 -7770 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -7700 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -7700 3 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2700 -7660 2 0 {name=p402 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -7700 0 0 {name=p403 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -7660 0 0 {name=x11}
C {devices/lab_pin.sym} -2760 -7890 0 0 {name=p404 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -3080 -6850 0 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -6330 0 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -5810 0 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -4770 0 0 {name=p406 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -4250 0 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3730 0 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2690 0 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2170 0 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1650 0 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1130 0 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -610 0 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} 160 -3900 2 0 {name=p319 sig_type=std_logic lab=inh2}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3880 3 0 {name=M2
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3910 2 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} 120 -3850 2 0 {name=p407 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3900 0 0 {name=p408 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3760 2 0 {name=p409 sig_type=std_logic lab=inh3}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3740 3 0 {name=M3
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3770 2 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} 120 -3710 2 0 {name=p410 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3760 0 0 {name=p412 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3620 2 0 {name=p414 sig_type=std_logic lab=inh4}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3600 3 0 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3630 2 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} 120 -3570 2 0 {name=p416 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3620 0 0 {name=p417 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3480 2 0 {name=p418 sig_type=std_logic lab=inh5}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3460 3 0 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3490 2 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} 120 -3430 2 0 {name=p419 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3480 0 0 {name=p420 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3340 2 0 {name=p421 sig_type=std_logic lab=inh6}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3320 3 0 {name=M6
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3350 2 0 {name=l107 lab=GND}
C {devices/lab_pin.sym} 120 -3290 2 0 {name=p422 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3340 0 0 {name=p423 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3200 2 0 {name=p424 sig_type=std_logic lab=inh7}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3180 3 0 {name=M7
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3210 2 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} 120 -3150 2 0 {name=p425 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3200 0 0 {name=p426 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3060 2 0 {name=p427 sig_type=std_logic lab=inh8}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3040 3 0 {name=M8
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3070 2 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 120 -3010 2 0 {name=p428 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3060 0 0 {name=p429 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -2920 2 0 {name=p430 sig_type=std_logic lab=inh9}
C {sky130_fd_pr/nfet_01v8.sym} 120 -2900 3 0 {name=M9
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -2930 2 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} 120 -2870 2 0 {name=p431 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -2920 0 0 {name=p432 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -4180 2 0 {name=p433 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4160 3 0 {name=M0
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -4190 2 0 {name=l127 lab=GND}
C {devices/lab_pin.sym} 120 -4130 2 0 {name=p434 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -4180 0 0 {name=p435 sig_type=std_logic lab=ctrl_vinh}
C {devices/gnd.sym} -2440 -7770 0 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -2510 -7840 0 0 {name=p436 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2380 -7770 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -7700 0 0 {name=M12
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -7700 3 0 {name=l129 lab=GND}
C {devices/lab_pin.sym} -2380 -7660 2 0 {name=p438 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -7700 0 0 {name=p439 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -7660 0 0 {name=x12}
C {devices/lab_pin.sym} -2440 -7890 0 0 {name=p440 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -7770 0 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -2190 -7840 0 0 {name=p441 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2060 -7770 0 0 {name=Vmeas13 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -7700 0 0 {name=M13
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -7700 3 0 {name=l131 lab=GND}
C {devices/lab_pin.sym} -2060 -7660 2 0 {name=p443 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -7700 0 0 {name=p444 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -7660 0 0 {name=x13}
C {devices/lab_pin.sym} -2120 -7890 0 0 {name=p445 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -7770 0 0 {name=l132 lab=GND}
C {devices/lab_pin.sym} -1870 -7840 0 0 {name=p446 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1740 -7770 0 0 {name=Vmeas14 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7700 0 0 {name=M14
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7700 3 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} -1740 -7660 2 0 {name=p448 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -7700 0 0 {name=p449 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7660 0 0 {name=x14}
C {devices/lab_pin.sym} -1800 -7890 0 0 {name=p450 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -7770 0 0 {name=l134 lab=GND}
C {devices/lab_pin.sym} -1550 -7840 0 0 {name=p451 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1420 -7770 0 0 {name=Vmeas15 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -7700 0 0 {name=M15
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -7700 3 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} -1420 -7660 2 0 {name=p453 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -7700 0 0 {name=p454 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -7660 0 0 {name=x15}
C {devices/lab_pin.sym} -1480 -7890 0 0 {name=p455 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -7770 0 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} -1230 -7840 0 0 {name=p456 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1100 -7770 0 0 {name=Vmeas16 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -7700 0 0 {name=M16
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -7700 3 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -1100 -7660 2 0 {name=p458 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -7700 0 0 {name=p459 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -7660 0 0 {name=x16}
C {devices/lab_pin.sym} -1160 -7890 0 0 {name=p460 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -7770 0 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -910 -7840 0 0 {name=p461 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -780 -7770 0 0 {name=Vmeas17 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -7700 0 0 {name=M17
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -7700 3 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} -780 -7660 2 0 {name=p464 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -7700 0 0 {name=p466 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -7660 0 0 {name=x17}
C {devices/lab_pin.sym} -840 -7890 0 0 {name=p467 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -7770 0 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -590 -7840 0 0 {name=p468 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -460 -7770 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -7700 0 0 {name=M18
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -7700 3 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -460 -7660 2 0 {name=p470 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -7700 0 0 {name=p471 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -7660 0 0 {name=x18}
C {devices/lab_pin.sym} -520 -7890 0 0 {name=p472 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -7770 0 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} -270 -7840 0 0 {name=p473 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -140 -7770 0 0 {name=Vmeas19 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -7700 0 0 {name=M19
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -7700 3 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} -140 -7660 2 0 {name=p475 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -7700 0 0 {name=p476 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -7660 0 0 {name=x19}
C {devices/lab_pin.sym} -200 -7890 0 0 {name=p477 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -7250 0 0 {name=l144 lab=GND}
C {devices/ammeter.sym} -2700 -7250 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -7180 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -7180 3 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} -2700 -7140 2 0 {name=p480 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -7180 0 0 {name=p481 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -7140 0 0 {name=x21}
C {devices/lab_pin.sym} -2760 -7370 0 0 {name=p482 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -7250 0 0 {name=l148 lab=GND}
C {devices/ammeter.sym} -2380 -7250 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -7180 0 0 {name=M22
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -7180 3 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} -2380 -7140 2 0 {name=p485 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -7180 0 0 {name=p486 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -7140 0 0 {name=x22}
C {devices/lab_pin.sym} -2440 -7370 0 0 {name=p487 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -7250 0 0 {name=l150 lab=GND}
C {devices/ammeter.sym} -2060 -7250 0 0 {name=Vmeas23 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -7180 0 0 {name=M23
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -7180 3 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} -2060 -7140 2 0 {name=p490 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -7180 0 0 {name=p491 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -7140 0 0 {name=x23}
C {devices/lab_pin.sym} -2120 -7370 0 0 {name=p492 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -7250 0 0 {name=l152 lab=GND}
C {devices/ammeter.sym} -1740 -7250 0 0 {name=Vmeas24 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7180 0 0 {name=M24
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7180 3 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} -1740 -7140 2 0 {name=p495 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -7180 0 0 {name=p496 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7140 0 0 {name=x24}
C {devices/lab_pin.sym} -1800 -7370 0 0 {name=p497 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -7250 0 0 {name=l154 lab=GND}
C {devices/ammeter.sym} -1420 -7250 0 0 {name=Vmeas25 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -7180 0 0 {name=M25
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -7180 3 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} -1420 -7140 2 0 {name=p500 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -7180 0 0 {name=p501 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -7140 0 0 {name=x25}
C {devices/lab_pin.sym} -1480 -7370 0 0 {name=p502 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -7250 0 0 {name=l156 lab=GND}
C {devices/ammeter.sym} -1100 -7250 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -7180 0 0 {name=M26
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -7180 3 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -1100 -7140 2 0 {name=p505 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -7180 0 0 {name=p506 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -7140 0 0 {name=x26}
C {devices/lab_pin.sym} -1160 -7370 0 0 {name=p507 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -7250 0 0 {name=l158 lab=GND}
C {devices/ammeter.sym} -780 -7250 0 0 {name=Vmeas27 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -7180 0 0 {name=M27
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -7180 3 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} -780 -7140 2 0 {name=p510 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -7180 0 0 {name=p511 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -7140 0 0 {name=x27}
C {devices/lab_pin.sym} -840 -7370 0 0 {name=p512 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -7250 0 0 {name=l160 lab=GND}
C {devices/ammeter.sym} -460 -7250 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -7180 0 0 {name=M28
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -7180 3 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -460 -7140 2 0 {name=p517 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -7180 0 0 {name=p518 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -7140 0 0 {name=x28}
C {devices/lab_pin.sym} -520 -7370 0 0 {name=p519 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -7250 0 0 {name=l162 lab=GND}
C {devices/ammeter.sym} -140 -7250 0 0 {name=Vmeas29 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -7180 0 0 {name=M29
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -7180 3 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} -140 -7140 2 0 {name=p522 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -7180 0 0 {name=p523 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -7140 0 0 {name=x29}
C {devices/lab_pin.sym} -200 -7370 0 0 {name=p524 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -6730 0 0 {name=l164 lab=GND}
C {devices/ammeter.sym} -2700 -6730 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -6660 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -6660 3 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} -2700 -6620 2 0 {name=p527 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -6660 0 0 {name=p528 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -6620 0 0 {name=x31}
C {devices/lab_pin.sym} -2760 -6850 0 0 {name=p529 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -6730 0 0 {name=l168 lab=GND}
C {devices/ammeter.sym} -2380 -6730 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -6660 0 0 {name=M32
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -6660 3 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} -2380 -6620 2 0 {name=p532 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -6660 0 0 {name=p533 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -6620 0 0 {name=x32}
C {devices/lab_pin.sym} -2440 -6850 0 0 {name=p534 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -6730 0 0 {name=l170 lab=GND}
C {devices/ammeter.sym} -2060 -6730 0 0 {name=Vmeas33 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -6660 0 0 {name=M33
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -6660 3 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} -2060 -6620 2 0 {name=p537 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -6660 0 0 {name=p538 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -6620 0 0 {name=x33}
C {devices/lab_pin.sym} -2120 -6850 0 0 {name=p539 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -6730 0 0 {name=l172 lab=GND}
C {devices/ammeter.sym} -1740 -6730 0 0 {name=Vmeas34 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6660 0 0 {name=M34
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6660 3 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} -1740 -6620 2 0 {name=p542 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -6660 0 0 {name=p543 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6620 0 0 {name=x34}
C {devices/lab_pin.sym} -1800 -6850 0 0 {name=p544 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -6730 0 0 {name=l174 lab=GND}
C {devices/ammeter.sym} -1420 -6730 0 0 {name=Vmeas35 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -6660 0 0 {name=M35
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -6660 3 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} -1420 -6620 2 0 {name=p547 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -6660 0 0 {name=p548 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -6620 0 0 {name=x35}
C {devices/lab_pin.sym} -1480 -6850 0 0 {name=p549 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -6730 0 0 {name=l176 lab=GND}
C {devices/ammeter.sym} -1100 -6730 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -6660 0 0 {name=M36
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -6660 3 0 {name=l177 lab=GND}
C {devices/lab_pin.sym} -1100 -6620 2 0 {name=p552 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -6660 0 0 {name=p553 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -6620 0 0 {name=x36}
C {devices/lab_pin.sym} -1160 -6850 0 0 {name=p554 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -6730 0 0 {name=l178 lab=GND}
C {devices/ammeter.sym} -780 -6730 0 0 {name=Vmeas37 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -6660 0 0 {name=M37
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -6660 3 0 {name=l179 lab=GND}
C {devices/lab_pin.sym} -780 -6620 2 0 {name=p557 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -6660 0 0 {name=p558 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -6620 0 0 {name=x37}
C {devices/lab_pin.sym} -840 -6850 0 0 {name=p559 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -6730 0 0 {name=l180 lab=GND}
C {devices/ammeter.sym} -460 -6730 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -6660 0 0 {name=M38
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -6660 3 0 {name=l181 lab=GND}
C {devices/lab_pin.sym} -460 -6620 2 0 {name=p562 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -6660 0 0 {name=p564 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -6620 0 0 {name=x38}
C {devices/lab_pin.sym} -520 -6850 0 0 {name=p566 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -6730 0 0 {name=l182 lab=GND}
C {devices/ammeter.sym} -140 -6730 0 0 {name=Vmeas39 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -6660 0 0 {name=M39
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -6660 3 0 {name=l183 lab=GND}
C {devices/lab_pin.sym} -140 -6620 2 0 {name=p569 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -6660 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -6620 0 0 {name=x39}
C {devices/lab_pin.sym} -200 -6850 0 0 {name=p571 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -6210 0 0 {name=l184 lab=GND}
C {devices/ammeter.sym} -2700 -6210 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -6140 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -6140 3 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -2700 -6100 2 0 {name=p574 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -6140 0 0 {name=p575 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -6100 0 0 {name=x41}
C {devices/lab_pin.sym} -2760 -6330 0 0 {name=p576 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -6210 0 0 {name=l188 lab=GND}
C {devices/ammeter.sym} -2380 -6210 0 0 {name=Vmeas42 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -6140 0 0 {name=M42
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -6140 3 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} -2380 -6100 2 0 {name=p579 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -6140 0 0 {name=p580 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -6100 0 0 {name=x42}
C {devices/lab_pin.sym} -2440 -6330 0 0 {name=p581 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -6210 0 0 {name=l190 lab=GND}
C {devices/ammeter.sym} -2060 -6210 0 0 {name=Vmeas43 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -6140 0 0 {name=M43
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -6140 3 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -2060 -6100 2 0 {name=p584 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -6140 0 0 {name=p585 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -6100 0 0 {name=x43}
C {devices/lab_pin.sym} -2120 -6330 0 0 {name=p586 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -6210 0 0 {name=l192 lab=GND}
C {devices/ammeter.sym} -1740 -6210 0 0 {name=Vmeas44 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6140 0 0 {name=M44
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6140 3 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -1740 -6100 2 0 {name=p589 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -6140 0 0 {name=p590 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6100 0 0 {name=x44}
C {devices/lab_pin.sym} -1800 -6330 0 0 {name=p591 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -6210 0 0 {name=l194 lab=GND}
C {devices/ammeter.sym} -1420 -6210 0 0 {name=Vmeas45 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -6140 0 0 {name=M45
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -6140 3 0 {name=l195 lab=GND}
C {devices/lab_pin.sym} -1420 -6100 2 0 {name=p594 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -6140 0 0 {name=p595 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -6100 0 0 {name=x45}
C {devices/lab_pin.sym} -1480 -6330 0 0 {name=p596 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -6210 0 0 {name=l196 lab=GND}
C {devices/ammeter.sym} -1100 -6210 0 0 {name=Vmeas46 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -6140 0 0 {name=M46
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -6140 3 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -1100 -6100 2 0 {name=p599 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -6140 0 0 {name=p600 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -6100 0 0 {name=x46}
C {devices/lab_pin.sym} -1160 -6330 0 0 {name=p601 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -6210 0 0 {name=l198 lab=GND}
C {devices/ammeter.sym} -780 -6210 0 0 {name=Vmeas47 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -6140 0 0 {name=M47
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -6140 3 0 {name=l199 lab=GND}
C {devices/lab_pin.sym} -780 -6100 2 0 {name=p604 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -6140 0 0 {name=p605 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -6100 0 0 {name=x47}
C {devices/lab_pin.sym} -840 -6330 0 0 {name=p606 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -6210 0 0 {name=l200 lab=GND}
C {devices/ammeter.sym} -460 -6210 0 0 {name=Vmeas48 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -6140 0 0 {name=M48
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -6140 3 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -460 -6100 2 0 {name=p609 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -6140 0 0 {name=p610 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -6100 0 0 {name=x48}
C {devices/lab_pin.sym} -520 -6330 0 0 {name=p614 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -6210 0 0 {name=l202 lab=GND}
C {devices/ammeter.sym} -140 -6210 0 0 {name=Vmeas49 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -6140 0 0 {name=M49
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -6140 3 0 {name=l203 lab=GND}
C {devices/lab_pin.sym} -140 -6100 2 0 {name=p618 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -6140 0 0 {name=p619 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -6100 0 0 {name=x49}
C {devices/lab_pin.sym} -200 -6330 0 0 {name=p620 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -5690 0 0 {name=l204 lab=GND}
C {devices/lab_pin.sym} -2830 -5760 0 0 {name=p621 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2700 -5690 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -5620 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -5620 3 0 {name=l207 lab=GND}
C {devices/lab_pin.sym} -2700 -5580 2 0 {name=p623 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -5620 0 0 {name=p624 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -5580 0 0 {name=x51}
C {devices/lab_pin.sym} -2760 -5810 0 0 {name=p625 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -5690 0 0 {name=l208 lab=GND}
C {devices/ammeter.sym} -2380 -5690 0 0 {name=Vmeas52 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -5620 0 0 {name=M52
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -5620 3 0 {name=l209 lab=GND}
C {devices/lab_pin.sym} -2380 -5580 2 0 {name=p628 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -5620 0 0 {name=p629 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -5580 0 0 {name=x52}
C {devices/lab_pin.sym} -2440 -5810 0 0 {name=p630 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -5690 0 0 {name=l210 lab=GND}
C {devices/ammeter.sym} -2060 -5690 0 0 {name=Vmeas53 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -5620 0 0 {name=M53
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -5620 3 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} -2060 -5580 2 0 {name=p633 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -5620 0 0 {name=p634 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -5580 0 0 {name=x53}
C {devices/lab_pin.sym} -2120 -5810 0 0 {name=p635 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -5690 0 0 {name=l212 lab=GND}
C {devices/ammeter.sym} -1740 -5690 0 0 {name=Vmeas54 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5620 0 0 {name=M54
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5620 3 0 {name=l213 lab=GND}
C {devices/lab_pin.sym} -1740 -5580 2 0 {name=p638 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -5620 0 0 {name=p639 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5580 0 0 {name=x54}
C {devices/lab_pin.sym} -1800 -5810 0 0 {name=p640 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -5690 0 0 {name=l214 lab=GND}
C {devices/ammeter.sym} -1420 -5690 0 0 {name=Vmeas55 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -5620 0 0 {name=M55
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -5620 3 0 {name=l215 lab=GND}
C {devices/lab_pin.sym} -1420 -5580 2 0 {name=p643 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -5620 0 0 {name=p644 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -5580 0 0 {name=x55}
C {devices/lab_pin.sym} -1480 -5810 0 0 {name=p645 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -5690 0 0 {name=l216 lab=GND}
C {devices/ammeter.sym} -1100 -5690 0 0 {name=Vmeas56 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -5620 0 0 {name=M56
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -5620 3 0 {name=l217 lab=GND}
C {devices/lab_pin.sym} -1100 -5580 2 0 {name=p648 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -5620 0 0 {name=p649 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -5580 0 0 {name=x56}
C {devices/lab_pin.sym} -1160 -5810 0 0 {name=p650 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -5690 0 0 {name=l218 lab=GND}
C {devices/ammeter.sym} -780 -5690 0 0 {name=Vmeas57 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -5620 0 0 {name=M57
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -5620 3 0 {name=l219 lab=GND}
C {devices/lab_pin.sym} -780 -5580 2 0 {name=p653 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -5620 0 0 {name=p654 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -5580 0 0 {name=x57}
C {devices/lab_pin.sym} -840 -5810 0 0 {name=p655 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -5690 0 0 {name=l220 lab=GND}
C {devices/ammeter.sym} -460 -5690 0 0 {name=Vmeas58 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -5620 0 0 {name=M58
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -5620 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} -460 -5580 2 0 {name=p658 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -5620 0 0 {name=p659 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -5580 0 0 {name=x58}
C {devices/lab_pin.sym} -520 -5810 0 0 {name=p660 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -5690 0 0 {name=l222 lab=GND}
C {devices/ammeter.sym} -140 -5690 0 0 {name=Vmeas59 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -5620 0 0 {name=M59
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -5620 3 0 {name=l223 lab=GND}
C {devices/lab_pin.sym} -140 -5580 2 0 {name=p675 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -5620 0 0 {name=p680 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -5580 0 0 {name=x59}
C {devices/lab_pin.sym} -200 -5810 0 0 {name=p687 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -5170 0 0 {name=l224 lab=GND}
C {devices/lab_pin.sym} -2830 -5240 0 0 {name=p692 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2700 -5170 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -5100 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -5100 3 0 {name=l227 lab=GND}
C {devices/lab_pin.sym} -2700 -5060 2 0 {name=p703 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -5100 0 0 {name=p704 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -5060 0 0 {name=x61}
C {devices/lab_pin.sym} -2760 -5290 0 0 {name=p705 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -5170 0 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -2510 -5240 0 0 {name=p706 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2380 -5170 0 0 {name=Vmeas62 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -5100 0 0 {name=M62
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -5100 3 0 {name=l229 lab=GND}
C {devices/lab_pin.sym} -2380 -5060 2 0 {name=p708 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -5100 0 0 {name=p709 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -5060 0 0 {name=x62}
C {devices/lab_pin.sym} -2440 -5290 0 0 {name=p710 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -5170 0 0 {name=l230 lab=GND}
C {devices/lab_pin.sym} -2190 -5240 0 0 {name=p711 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2060 -5170 0 0 {name=Vmeas63 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -5100 0 0 {name=M63
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -5100 3 0 {name=l231 lab=GND}
C {devices/lab_pin.sym} -2060 -5060 2 0 {name=p713 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -5100 0 0 {name=p714 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -5060 0 0 {name=x63}
C {devices/lab_pin.sym} -2120 -5290 0 0 {name=p715 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -5170 0 0 {name=l232 lab=GND}
C {devices/lab_pin.sym} -1870 -5240 0 0 {name=p716 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1740 -5170 0 0 {name=Vmeas64 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5100 0 0 {name=M64
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5100 3 0 {name=l233 lab=GND}
C {devices/lab_pin.sym} -1740 -5060 2 0 {name=p718 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -5100 0 0 {name=p719 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5060 0 0 {name=x64}
C {devices/lab_pin.sym} -1800 -5290 0 0 {name=p720 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -5170 0 0 {name=l234 lab=GND}
C {devices/lab_pin.sym} -1550 -5240 0 0 {name=p721 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1420 -5170 0 0 {name=Vmeas65 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -5100 0 0 {name=M65
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -5100 3 0 {name=l235 lab=GND}
C {devices/lab_pin.sym} -1420 -5060 2 0 {name=p723 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -5100 0 0 {name=p724 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -5060 0 0 {name=x65}
C {devices/lab_pin.sym} -1480 -5290 0 0 {name=p725 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -5170 0 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} -1230 -5240 0 0 {name=p726 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1100 -5170 0 0 {name=Vmeas66 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -5100 0 0 {name=M66
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -5100 3 0 {name=l237 lab=GND}
C {devices/lab_pin.sym} -1100 -5060 2 0 {name=p728 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -5100 0 0 {name=p729 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -5060 0 0 {name=x66}
C {devices/lab_pin.sym} -1160 -5290 0 0 {name=p730 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -5170 0 0 {name=l238 lab=GND}
C {devices/lab_pin.sym} -910 -5240 0 0 {name=p731 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -780 -5170 0 0 {name=Vmeas67 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -5100 0 0 {name=M67
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -5100 3 0 {name=l239 lab=GND}
C {devices/lab_pin.sym} -780 -5060 2 0 {name=p733 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -5100 0 0 {name=p734 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -5060 0 0 {name=x67}
C {devices/lab_pin.sym} -840 -5290 0 0 {name=p735 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -5170 0 0 {name=l240 lab=GND}
C {devices/lab_pin.sym} -590 -5240 0 0 {name=p736 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -460 -5170 0 0 {name=Vmeas68 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -5100 0 0 {name=M68
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -5100 3 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} -460 -5060 2 0 {name=p738 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -5100 0 0 {name=p739 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -5060 0 0 {name=x68}
C {devices/lab_pin.sym} -520 -5290 0 0 {name=p740 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -5170 0 0 {name=l242 lab=GND}
C {devices/lab_pin.sym} -270 -5240 0 0 {name=p741 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -140 -5170 0 0 {name=Vmeas69 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -5100 0 0 {name=M69
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -5100 3 0 {name=l243 lab=GND}
C {devices/lab_pin.sym} -140 -5060 2 0 {name=p743 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -5100 0 0 {name=p744 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -5060 0 0 {name=x69}
C {devices/lab_pin.sym} -200 -5290 0 0 {name=p745 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4650 0 0 {name=l244 lab=GND}
C {devices/lab_pin.sym} -2830 -4720 0 0 {name=p746 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2700 -4650 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4580 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4580 3 0 {name=l259 lab=GND}
C {devices/lab_pin.sym} -2700 -4540 2 0 {name=p748 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4580 0 0 {name=p749 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4540 0 0 {name=x71}
C {devices/lab_pin.sym} -2760 -4770 0 0 {name=p750 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4650 0 0 {name=l260 lab=GND}
C {devices/lab_pin.sym} -2510 -4720 0 0 {name=p751 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2380 -4650 0 0 {name=Vmeas72 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4580 0 0 {name=M72
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4580 3 0 {name=l261 lab=GND}
C {devices/lab_pin.sym} -2380 -4540 2 0 {name=p753 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4580 0 0 {name=p754 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4540 0 0 {name=x72}
C {devices/lab_pin.sym} -2440 -4770 0 0 {name=p755 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4650 0 0 {name=l262 lab=GND}
C {devices/lab_pin.sym} -2190 -4720 0 0 {name=p756 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2060 -4650 0 0 {name=Vmeas73 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4580 0 0 {name=M73
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4580 3 0 {name=l263 lab=GND}
C {devices/lab_pin.sym} -2060 -4540 2 0 {name=p758 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4580 0 0 {name=p759 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4540 0 0 {name=x73}
C {devices/lab_pin.sym} -2120 -4770 0 0 {name=p760 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4650 0 0 {name=l264 lab=GND}
C {devices/lab_pin.sym} -1870 -4720 0 0 {name=p761 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1740 -4650 0 0 {name=Vmeas74 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4580 0 0 {name=M74
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4580 3 0 {name=l265 lab=GND}
C {devices/lab_pin.sym} -1740 -4540 2 0 {name=p763 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4580 0 0 {name=p764 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4540 0 0 {name=x74}
C {devices/lab_pin.sym} -1800 -4770 0 0 {name=p765 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4650 0 0 {name=l266 lab=GND}
C {devices/lab_pin.sym} -1550 -4720 0 0 {name=p766 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1420 -4650 0 0 {name=Vmeas75 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4580 0 0 {name=M75
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4580 3 0 {name=l267 lab=GND}
C {devices/lab_pin.sym} -1420 -4540 2 0 {name=p768 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4580 0 0 {name=p769 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4540 0 0 {name=x75}
C {devices/lab_pin.sym} -1480 -4770 0 0 {name=p770 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4650 0 0 {name=l268 lab=GND}
C {devices/lab_pin.sym} -1230 -4720 0 0 {name=p771 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1100 -4650 0 0 {name=Vmeas76 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4580 0 0 {name=M76
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4580 3 0 {name=l269 lab=GND}
C {devices/lab_pin.sym} -1100 -4540 2 0 {name=p773 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4580 0 0 {name=p774 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4540 0 0 {name=x76}
C {devices/lab_pin.sym} -1160 -4770 0 0 {name=p775 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4650 0 0 {name=l270 lab=GND}
C {devices/lab_pin.sym} -910 -4720 0 0 {name=p776 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -780 -4650 0 0 {name=Vmeas77 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4580 0 0 {name=M77
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4580 3 0 {name=l271 lab=GND}
C {devices/lab_pin.sym} -780 -4540 2 0 {name=p778 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4580 0 0 {name=p779 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4540 0 0 {name=x77}
C {devices/lab_pin.sym} -840 -4770 0 0 {name=p780 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4650 0 0 {name=l272 lab=GND}
C {devices/lab_pin.sym} -590 -4720 0 0 {name=p781 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -460 -4650 0 0 {name=Vmeas78 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4580 0 0 {name=M78
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4580 3 0 {name=l273 lab=GND}
C {devices/lab_pin.sym} -460 -4540 2 0 {name=p783 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4580 0 0 {name=p784 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4540 0 0 {name=x78}
C {devices/lab_pin.sym} -520 -4770 0 0 {name=p785 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4650 0 0 {name=l274 lab=GND}
C {devices/lab_pin.sym} -270 -4720 0 0 {name=p786 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -140 -4650 0 0 {name=Vmeas79 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4580 0 0 {name=M79
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4580 3 0 {name=l275 lab=GND}
C {devices/lab_pin.sym} -140 -4540 2 0 {name=p788 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4580 0 0 {name=p789 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4540 0 0 {name=x79}
C {devices/lab_pin.sym} -200 -4770 0 0 {name=p790 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4130 0 0 {name=l276 lab=GND}
C {devices/lab_pin.sym} -2830 -4200 0 0 {name=p791 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2700 -4130 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4060 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4060 3 0 {name=l277 lab=GND}
C {devices/lab_pin.sym} -2700 -4020 2 0 {name=p793 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4060 0 0 {name=p794 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4020 0 0 {name=x81}
C {devices/lab_pin.sym} -2760 -4250 0 0 {name=p795 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4130 0 0 {name=l278 lab=GND}
C {devices/lab_pin.sym} -2510 -4200 0 0 {name=p796 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2380 -4130 0 0 {name=Vmeas82 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4060 0 0 {name=M82
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4060 3 0 {name=l279 lab=GND}
C {devices/lab_pin.sym} -2380 -4020 2 0 {name=p798 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4060 0 0 {name=p799 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4020 0 0 {name=x82}
C {devices/lab_pin.sym} -2440 -4250 0 0 {name=p800 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4130 0 0 {name=l280 lab=GND}
C {devices/lab_pin.sym} -2190 -4200 0 0 {name=p801 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2060 -4130 0 0 {name=Vmeas83 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4060 0 0 {name=M83
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4060 3 0 {name=l281 lab=GND}
C {devices/lab_pin.sym} -2060 -4020 2 0 {name=p803 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4060 0 0 {name=p804 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4020 0 0 {name=x83}
C {devices/lab_pin.sym} -2120 -4250 0 0 {name=p805 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4130 0 0 {name=l282 lab=GND}
C {devices/lab_pin.sym} -1870 -4200 0 0 {name=p806 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1740 -4130 0 0 {name=Vmeas84 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4060 0 0 {name=M84
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4060 3 0 {name=l283 lab=GND}
C {devices/lab_pin.sym} -1740 -4020 2 0 {name=p808 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4060 0 0 {name=p809 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4020 0 0 {name=x84}
C {devices/lab_pin.sym} -1800 -4250 0 0 {name=p810 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4130 0 0 {name=l284 lab=GND}
C {devices/lab_pin.sym} -1550 -4200 0 0 {name=p811 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1420 -4130 0 0 {name=Vmeas85 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4060 0 0 {name=M85
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4060 3 0 {name=l285 lab=GND}
C {devices/lab_pin.sym} -1420 -4020 2 0 {name=p813 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4060 0 0 {name=p814 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4020 0 0 {name=x85}
C {devices/lab_pin.sym} -1480 -4250 0 0 {name=p815 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4130 0 0 {name=l286 lab=GND}
C {devices/lab_pin.sym} -1230 -4200 0 0 {name=p816 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1100 -4130 0 0 {name=Vmeas86 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4060 0 0 {name=M86
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4060 3 0 {name=l287 lab=GND}
C {devices/lab_pin.sym} -1100 -4020 2 0 {name=p818 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4060 0 0 {name=p819 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4020 0 0 {name=x86}
C {devices/lab_pin.sym} -1160 -4250 0 0 {name=p820 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4130 0 0 {name=l288 lab=GND}
C {devices/lab_pin.sym} -910 -4200 0 0 {name=p821 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -780 -4130 0 0 {name=Vmeas87 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4060 0 0 {name=M87
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4060 3 0 {name=l289 lab=GND}
C {devices/lab_pin.sym} -780 -4020 2 0 {name=p823 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4060 0 0 {name=p824 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4020 0 0 {name=x87}
C {devices/lab_pin.sym} -840 -4250 0 0 {name=p825 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4130 0 0 {name=l290 lab=GND}
C {devices/lab_pin.sym} -590 -4200 0 0 {name=p826 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -460 -4130 0 0 {name=Vmeas88 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4060 0 0 {name=M88
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4060 3 0 {name=l291 lab=GND}
C {devices/lab_pin.sym} -460 -4020 2 0 {name=p828 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4060 0 0 {name=p829 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4020 0 0 {name=x88}
C {devices/lab_pin.sym} -520 -4250 0 0 {name=p830 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4130 0 0 {name=l292 lab=GND}
C {devices/lab_pin.sym} -270 -4200 0 0 {name=p831 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -140 -4130 0 0 {name=Vmeas89 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4060 0 0 {name=M89
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4060 3 0 {name=l293 lab=GND}
C {devices/lab_pin.sym} -140 -4020 2 0 {name=p833 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4060 0 0 {name=p834 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4020 0 0 {name=x89}
C {devices/lab_pin.sym} -200 -4250 0 0 {name=p835 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3610 0 0 {name=l294 lab=GND}
C {devices/lab_pin.sym} -2830 -3680 0 0 {name=p836 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2700 -3610 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3540 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3540 3 0 {name=l295 lab=GND}
C {devices/lab_pin.sym} -2700 -3500 2 0 {name=p838 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3540 0 0 {name=p839 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3500 0 0 {name=x91}
C {devices/lab_pin.sym} -2760 -3730 0 0 {name=p840 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3610 0 0 {name=l296 lab=GND}
C {devices/lab_pin.sym} -2510 -3680 0 0 {name=p841 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2380 -3610 0 0 {name=Vmeas92 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3540 0 0 {name=M92
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3540 3 0 {name=l297 lab=GND}
C {devices/lab_pin.sym} -2380 -3500 2 0 {name=p843 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3540 0 0 {name=p844 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3500 0 0 {name=x92}
C {devices/lab_pin.sym} -2440 -3730 0 0 {name=p845 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3610 0 0 {name=l298 lab=GND}
C {devices/lab_pin.sym} -2190 -3680 0 0 {name=p846 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2060 -3610 0 0 {name=Vmeas93 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3540 0 0 {name=M93
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3540 3 0 {name=l299 lab=GND}
C {devices/lab_pin.sym} -2060 -3500 2 0 {name=p848 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3540 0 0 {name=p849 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3500 0 0 {name=x93}
C {devices/lab_pin.sym} -2120 -3730 0 0 {name=p850 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3610 0 0 {name=l300 lab=GND}
C {devices/lab_pin.sym} -1870 -3680 0 0 {name=p851 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1740 -3610 0 0 {name=Vmeas94 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3540 0 0 {name=M94
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3540 3 0 {name=l301 lab=GND}
C {devices/lab_pin.sym} -1740 -3500 2 0 {name=p853 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3540 0 0 {name=p854 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3500 0 0 {name=x94}
C {devices/lab_pin.sym} -1800 -3730 0 0 {name=p855 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3610 0 0 {name=l302 lab=GND}
C {devices/lab_pin.sym} -1550 -3680 0 0 {name=p856 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1420 -3610 0 0 {name=Vmeas95 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3540 0 0 {name=M95
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3540 3 0 {name=l303 lab=GND}
C {devices/lab_pin.sym} -1420 -3500 2 0 {name=p858 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3540 0 0 {name=p859 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3500 0 0 {name=x95}
C {devices/lab_pin.sym} -1480 -3730 0 0 {name=p860 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3610 0 0 {name=l304 lab=GND}
C {devices/lab_pin.sym} -1230 -3680 0 0 {name=p861 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1100 -3610 0 0 {name=Vmeas96 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3540 0 0 {name=M96
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3540 3 0 {name=l305 lab=GND}
C {devices/lab_pin.sym} -1100 -3500 2 0 {name=p863 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3540 0 0 {name=p864 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3500 0 0 {name=x96}
C {devices/lab_pin.sym} -1160 -3730 0 0 {name=p865 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3610 0 0 {name=l306 lab=GND}
C {devices/lab_pin.sym} -910 -3680 0 0 {name=p866 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -780 -3610 0 0 {name=Vmeas97 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3540 0 0 {name=M97
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3540 3 0 {name=l307 lab=GND}
C {devices/lab_pin.sym} -780 -3500 2 0 {name=p868 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3540 0 0 {name=p869 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3500 0 0 {name=x97}
C {devices/lab_pin.sym} -840 -3730 0 0 {name=p870 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3610 0 0 {name=l308 lab=GND}
C {devices/lab_pin.sym} -590 -3680 0 0 {name=p871 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -460 -3610 0 0 {name=Vmeas98 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3540 0 0 {name=M98
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3540 3 0 {name=l309 lab=GND}
C {devices/lab_pin.sym} -460 -3500 2 0 {name=p873 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3540 0 0 {name=p874 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3500 0 0 {name=x98}
C {devices/lab_pin.sym} -520 -3730 0 0 {name=p875 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3610 0 0 {name=l310 lab=GND}
C {devices/lab_pin.sym} -270 -3680 0 0 {name=p876 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -140 -3610 0 0 {name=Vmeas99 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3540 0 0 {name=M99
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3540 3 0 {name=l311 lab=GND}
C {devices/lab_pin.sym} -140 -3500 2 0 {name=p878 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3540 0 0 {name=p879 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3500 0 0 {name=x99}
C {devices/lab_pin.sym} -200 -3730 0 0 {name=p880 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3090 0 0 {name=l312 lab=GND}
C {devices/lab_pin.sym} -2830 -3160 0 0 {name=p881 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2700 -3090 0 0 {name=Vmeas101 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3020 0 0 {name=M101
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3020 3 0 {name=l313 lab=GND}
C {devices/lab_pin.sym} -2700 -2980 2 0 {name=p883 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3020 0 0 {name=p884 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2980 0 0 {name=x101}
C {devices/lab_pin.sym} -2760 -3210 0 0 {name=p885 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3090 0 0 {name=l314 lab=GND}
C {devices/lab_pin.sym} -2510 -3160 0 0 {name=p886 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2380 -3090 0 0 {name=Vmeas102 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3020 0 0 {name=M102
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3020 3 0 {name=l315 lab=GND}
C {devices/lab_pin.sym} -2380 -2980 2 0 {name=p888 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3020 0 0 {name=p889 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2980 0 0 {name=x102}
C {devices/lab_pin.sym} -2440 -3210 0 0 {name=p890 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3090 0 0 {name=l316 lab=GND}
C {devices/lab_pin.sym} -2190 -3160 0 0 {name=p891 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2060 -3090 0 0 {name=Vmeas103 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3020 0 0 {name=M103
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3020 3 0 {name=l317 lab=GND}
C {devices/lab_pin.sym} -2060 -2980 2 0 {name=p893 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3020 0 0 {name=p894 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2980 0 0 {name=x103}
C {devices/lab_pin.sym} -2120 -3210 0 0 {name=p895 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3090 0 0 {name=l318 lab=GND}
C {devices/lab_pin.sym} -1870 -3160 0 0 {name=p896 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1740 -3090 0 0 {name=Vmeas104 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3020 0 0 {name=M104
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3020 3 0 {name=l319 lab=GND}
C {devices/lab_pin.sym} -1740 -2980 2 0 {name=p898 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3020 0 0 {name=p899 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2980 0 0 {name=x104}
C {devices/lab_pin.sym} -1800 -3210 0 0 {name=p900 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3090 0 0 {name=l320 lab=GND}
C {devices/lab_pin.sym} -1550 -3160 0 0 {name=p901 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1420 -3090 0 0 {name=Vmeas105 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3020 0 0 {name=M105
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3020 3 0 {name=l321 lab=GND}
C {devices/lab_pin.sym} -1420 -2980 2 0 {name=p903 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3020 0 0 {name=p904 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2980 0 0 {name=x105}
C {devices/lab_pin.sym} -1480 -3210 0 0 {name=p905 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3090 0 0 {name=l322 lab=GND}
C {devices/lab_pin.sym} -1230 -3160 0 0 {name=p906 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1100 -3090 0 0 {name=Vmeas106 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3020 0 0 {name=M106
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3020 3 0 {name=l323 lab=GND}
C {devices/lab_pin.sym} -1100 -2980 2 0 {name=p908 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3020 0 0 {name=p909 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2980 0 0 {name=x106}
C {devices/lab_pin.sym} -1160 -3210 0 0 {name=p910 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3090 0 0 {name=l324 lab=GND}
C {devices/lab_pin.sym} -910 -3160 0 0 {name=p911 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -780 -3090 0 0 {name=Vmeas107 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3020 0 0 {name=M107
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3020 3 0 {name=l325 lab=GND}
C {devices/lab_pin.sym} -780 -2980 2 0 {name=p913 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3020 0 0 {name=p914 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2980 0 0 {name=x107}
C {devices/lab_pin.sym} -840 -3210 0 0 {name=p915 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3090 0 0 {name=l326 lab=GND}
C {devices/lab_pin.sym} -590 -3160 0 0 {name=p916 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -460 -3090 0 0 {name=Vmeas108 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3020 0 0 {name=M108
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3020 3 0 {name=l327 lab=GND}
C {devices/lab_pin.sym} -460 -2980 2 0 {name=p918 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3020 0 0 {name=p919 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2980 0 0 {name=x108}
C {devices/lab_pin.sym} -520 -3210 0 0 {name=p920 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3090 0 0 {name=l328 lab=GND}
C {devices/lab_pin.sym} -270 -3160 0 0 {name=p921 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -140 -3090 0 0 {name=Vmeas109 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3020 0 0 {name=M109
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3020 3 0 {name=l329 lab=GND}
C {devices/lab_pin.sym} -140 -2980 2 0 {name=p923 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3020 0 0 {name=p924 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2980 0 0 {name=x109}
C {devices/lab_pin.sym} -200 -3210 0 0 {name=p925 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2570 0 0 {name=l330 lab=GND}
C {devices/lab_pin.sym} -2830 -2640 0 0 {name=p926 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2700 -2570 0 0 {name=Vmeas111 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2500 0 0 {name=M111
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2500 3 0 {name=l331 lab=GND}
C {devices/lab_pin.sym} -2700 -2460 2 0 {name=p928 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2500 0 0 {name=p929 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2460 0 0 {name=x111}
C {devices/lab_pin.sym} -2760 -2690 0 0 {name=p930 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2570 0 0 {name=l332 lab=GND}
C {devices/lab_pin.sym} -2510 -2640 0 0 {name=p931 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2380 -2570 0 0 {name=Vmeas112 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2500 0 0 {name=M112
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2500 3 0 {name=l333 lab=GND}
C {devices/lab_pin.sym} -2380 -2460 2 0 {name=p933 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2500 0 0 {name=p934 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2460 0 0 {name=x112}
C {devices/lab_pin.sym} -2440 -2690 0 0 {name=p935 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2570 0 0 {name=l334 lab=GND}
C {devices/lab_pin.sym} -2190 -2640 0 0 {name=p936 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2060 -2570 0 0 {name=Vmeas113 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2500 0 0 {name=M113
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2500 3 0 {name=l335 lab=GND}
C {devices/lab_pin.sym} -2060 -2460 2 0 {name=p938 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2500 0 0 {name=p939 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2460 0 0 {name=x113}
C {devices/lab_pin.sym} -2120 -2690 0 0 {name=p940 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2570 0 0 {name=l336 lab=GND}
C {devices/lab_pin.sym} -1870 -2640 0 0 {name=p941 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1740 -2570 0 0 {name=Vmeas114 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2500 0 0 {name=M114
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2500 3 0 {name=l337 lab=GND}
C {devices/lab_pin.sym} -1740 -2460 2 0 {name=p943 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2500 0 0 {name=p944 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2460 0 0 {name=x114}
C {devices/lab_pin.sym} -1800 -2690 0 0 {name=p945 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2570 0 0 {name=l338 lab=GND}
C {devices/lab_pin.sym} -1550 -2640 0 0 {name=p946 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1420 -2570 0 0 {name=Vmeas115 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2500 0 0 {name=M115
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2500 3 0 {name=l339 lab=GND}
C {devices/lab_pin.sym} -1420 -2460 2 0 {name=p948 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2500 0 0 {name=p949 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2460 0 0 {name=x115}
C {devices/lab_pin.sym} -1480 -2690 0 0 {name=p950 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2570 0 0 {name=l340 lab=GND}
C {devices/lab_pin.sym} -1230 -2640 0 0 {name=p951 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1100 -2570 0 0 {name=Vmeas116 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2500 0 0 {name=M116
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2500 3 0 {name=l341 lab=GND}
C {devices/lab_pin.sym} -1100 -2460 2 0 {name=p953 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2500 0 0 {name=p954 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2460 0 0 {name=x116}
C {devices/lab_pin.sym} -1160 -2690 0 0 {name=p955 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2570 0 0 {name=l342 lab=GND}
C {devices/lab_pin.sym} -910 -2640 0 0 {name=p956 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -780 -2570 0 0 {name=Vmeas117 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2500 0 0 {name=M117
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2500 3 0 {name=l343 lab=GND}
C {devices/lab_pin.sym} -780 -2460 2 0 {name=p958 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2500 0 0 {name=p959 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2460 0 0 {name=x117}
C {devices/lab_pin.sym} -840 -2690 0 0 {name=p960 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2570 0 0 {name=l344 lab=GND}
C {devices/lab_pin.sym} -590 -2640 0 0 {name=p961 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -460 -2570 0 0 {name=Vmeas118 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2500 0 0 {name=M118
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2500 3 0 {name=l345 lab=GND}
C {devices/lab_pin.sym} -460 -2460 2 0 {name=p963 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2500 0 0 {name=p964 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2460 0 0 {name=x118}
C {devices/lab_pin.sym} -520 -2690 0 0 {name=p965 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2570 0 0 {name=l346 lab=GND}
C {devices/lab_pin.sym} -270 -2640 0 0 {name=p966 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -140 -2570 0 0 {name=Vmeas119 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2500 0 0 {name=M119
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2500 3 0 {name=l347 lab=GND}
C {devices/lab_pin.sym} -140 -2460 2 0 {name=p968 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2500 0 0 {name=p969 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2460 0 0 {name=x119}
C {devices/lab_pin.sym} -200 -2690 0 0 {name=p970 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2050 0 0 {name=l348 lab=GND}
C {devices/lab_pin.sym} -2830 -2120 0 0 {name=p971 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2700 -2050 0 0 {name=Vmeas121 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1980 0 0 {name=M121
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1980 3 0 {name=l349 lab=GND}
C {devices/lab_pin.sym} -2700 -1940 2 0 {name=p973 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1980 0 0 {name=p974 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1940 0 0 {name=x121}
C {devices/lab_pin.sym} -2760 -2170 0 0 {name=p975 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2050 0 0 {name=l350 lab=GND}
C {devices/lab_pin.sym} -2510 -2120 0 0 {name=p976 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2380 -2050 0 0 {name=Vmeas122 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1980 0 0 {name=M122
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1980 3 0 {name=l351 lab=GND}
C {devices/lab_pin.sym} -2380 -1940 2 0 {name=p978 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1980 0 0 {name=p979 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1940 0 0 {name=x122}
C {devices/lab_pin.sym} -2440 -2170 0 0 {name=p980 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2050 0 0 {name=l352 lab=GND}
C {devices/lab_pin.sym} -2190 -2120 0 0 {name=p981 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2060 -2050 0 0 {name=Vmeas123 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1980 0 0 {name=M123
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1980 3 0 {name=l353 lab=GND}
C {devices/lab_pin.sym} -2060 -1940 2 0 {name=p983 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1980 0 0 {name=p984 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1940 0 0 {name=x123}
C {devices/lab_pin.sym} -2120 -2170 0 0 {name=p985 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2050 0 0 {name=l354 lab=GND}
C {devices/lab_pin.sym} -1870 -2120 0 0 {name=p986 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1740 -2050 0 0 {name=Vmeas124 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1980 0 0 {name=M124
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1980 3 0 {name=l355 lab=GND}
C {devices/lab_pin.sym} -1740 -1940 2 0 {name=p988 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1980 0 0 {name=p989 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1940 0 0 {name=x124}
C {devices/lab_pin.sym} -1800 -2170 0 0 {name=p990 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2050 0 0 {name=l356 lab=GND}
C {devices/lab_pin.sym} -1550 -2120 0 0 {name=p991 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1420 -2050 0 0 {name=Vmeas125 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1980 0 0 {name=M125
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1980 3 0 {name=l357 lab=GND}
C {devices/lab_pin.sym} -1420 -1940 2 0 {name=p993 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1980 0 0 {name=p994 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1940 0 0 {name=x125}
C {devices/lab_pin.sym} -1480 -2170 0 0 {name=p995 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2050 0 0 {name=l358 lab=GND}
C {devices/lab_pin.sym} -1230 -2120 0 0 {name=p996 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1100 -2050 0 0 {name=Vmeas126 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1980 0 0 {name=M126
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1980 3 0 {name=l359 lab=GND}
C {devices/lab_pin.sym} -1100 -1940 2 0 {name=p998 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1980 0 0 {name=p999 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1940 0 0 {name=x126}
C {devices/lab_pin.sym} -1160 -2170 0 0 {name=p1000 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2050 0 0 {name=l360 lab=GND}
C {devices/lab_pin.sym} -910 -2120 0 0 {name=p1001 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -780 -2050 0 0 {name=Vmeas127 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1980 0 0 {name=M127
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1980 3 0 {name=l361 lab=GND}
C {devices/lab_pin.sym} -780 -1940 2 0 {name=p1003 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1980 0 0 {name=p1004 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1940 0 0 {name=x127}
C {devices/lab_pin.sym} -840 -2170 0 0 {name=p1005 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2050 0 0 {name=l362 lab=GND}
C {devices/lab_pin.sym} -590 -2120 0 0 {name=p1006 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -460 -2050 0 0 {name=Vmeas128 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1980 0 0 {name=M128
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1980 3 0 {name=l363 lab=GND}
C {devices/lab_pin.sym} -460 -1940 2 0 {name=p1008 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1980 0 0 {name=p1009 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1940 0 0 {name=x128}
C {devices/lab_pin.sym} -520 -2170 0 0 {name=p1010 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2050 0 0 {name=l364 lab=GND}
C {devices/lab_pin.sym} -270 -2120 0 0 {name=p1011 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -140 -2050 0 0 {name=Vmeas129 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1980 0 0 {name=M129
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1980 3 0 {name=l365 lab=GND}
C {devices/lab_pin.sym} -140 -1940 2 0 {name=p1013 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1980 0 0 {name=p1014 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1940 0 0 {name=x129}
C {devices/lab_pin.sym} -200 -2170 0 0 {name=p1015 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1530 0 0 {name=l366 lab=GND}
C {devices/lab_pin.sym} -2830 -1600 0 0 {name=p1016 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2700 -1530 0 0 {name=Vmeas131 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1460 0 0 {name=M131
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1460 3 0 {name=l367 lab=GND}
C {devices/lab_pin.sym} -2700 -1420 2 0 {name=p1018 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1460 0 0 {name=p1019 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1420 0 0 {name=x131}
C {devices/lab_pin.sym} -2760 -1650 0 0 {name=p1020 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1530 0 0 {name=l368 lab=GND}
C {devices/lab_pin.sym} -2510 -1600 0 0 {name=p1021 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2380 -1530 0 0 {name=Vmeas132 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1460 0 0 {name=M132
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1460 3 0 {name=l369 lab=GND}
C {devices/lab_pin.sym} -2380 -1420 2 0 {name=p1023 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1460 0 0 {name=p1024 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1420 0 0 {name=x132}
C {devices/lab_pin.sym} -2440 -1650 0 0 {name=p1025 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1530 0 0 {name=l370 lab=GND}
C {devices/lab_pin.sym} -2190 -1600 0 0 {name=p1026 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2060 -1530 0 0 {name=Vmeas133 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1460 0 0 {name=M133
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1460 3 0 {name=l371 lab=GND}
C {devices/lab_pin.sym} -2060 -1420 2 0 {name=p1028 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1460 0 0 {name=p1029 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1420 0 0 {name=x133}
C {devices/lab_pin.sym} -2120 -1650 0 0 {name=p1030 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1530 0 0 {name=l372 lab=GND}
C {devices/lab_pin.sym} -1870 -1600 0 0 {name=p1031 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1740 -1530 0 0 {name=Vmeas134 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1460 0 0 {name=M134
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1460 3 0 {name=l373 lab=GND}
C {devices/lab_pin.sym} -1740 -1420 2 0 {name=p1033 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1460 0 0 {name=p1034 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1420 0 0 {name=x134}
C {devices/lab_pin.sym} -1800 -1650 0 0 {name=p1035 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1530 0 0 {name=l374 lab=GND}
C {devices/lab_pin.sym} -1550 -1600 0 0 {name=p1036 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1420 -1530 0 0 {name=Vmeas135 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1460 0 0 {name=M135
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1460 3 0 {name=l375 lab=GND}
C {devices/lab_pin.sym} -1420 -1420 2 0 {name=p1038 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1460 0 0 {name=p1039 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1420 0 0 {name=x135}
C {devices/lab_pin.sym} -1480 -1650 0 0 {name=p1040 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1530 0 0 {name=l376 lab=GND}
C {devices/lab_pin.sym} -1230 -1600 0 0 {name=p1041 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1100 -1530 0 0 {name=Vmeas136 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1460 0 0 {name=M136
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1460 3 0 {name=l377 lab=GND}
C {devices/lab_pin.sym} -1100 -1420 2 0 {name=p1043 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1460 0 0 {name=p1044 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1420 0 0 {name=x136}
C {devices/lab_pin.sym} -1160 -1650 0 0 {name=p1045 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1530 0 0 {name=l378 lab=GND}
C {devices/lab_pin.sym} -910 -1600 0 0 {name=p1046 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -780 -1530 0 0 {name=Vmeas137 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1460 0 0 {name=M137
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1460 3 0 {name=l379 lab=GND}
C {devices/lab_pin.sym} -780 -1420 2 0 {name=p1048 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1460 0 0 {name=p1049 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1420 0 0 {name=x137}
C {devices/lab_pin.sym} -840 -1650 0 0 {name=p1050 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1530 0 0 {name=l380 lab=GND}
C {devices/lab_pin.sym} -590 -1600 0 0 {name=p1051 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -460 -1530 0 0 {name=Vmeas138 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1460 0 0 {name=M138
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1460 3 0 {name=l381 lab=GND}
C {devices/lab_pin.sym} -460 -1420 2 0 {name=p1053 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1460 0 0 {name=p1054 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1420 0 0 {name=x138}
C {devices/lab_pin.sym} -520 -1650 0 0 {name=p1055 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1530 0 0 {name=l382 lab=GND}
C {devices/lab_pin.sym} -270 -1600 0 0 {name=p1056 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -140 -1530 0 0 {name=Vmeas139 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1460 0 0 {name=M139
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1460 3 0 {name=l383 lab=GND}
C {devices/lab_pin.sym} -140 -1420 2 0 {name=p1058 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1460 0 0 {name=p1059 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1420 0 0 {name=x139}
C {devices/lab_pin.sym} -200 -1650 0 0 {name=p1060 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1010 0 0 {name=l384 lab=GND}
C {devices/lab_pin.sym} -2830 -1080 0 0 {name=p1061 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2700 -1010 0 0 {name=Vmeas141 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -940 0 0 {name=M141
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -940 3 0 {name=l385 lab=GND}
C {devices/lab_pin.sym} -2700 -900 2 0 {name=p1063 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -940 0 0 {name=p1064 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -900 0 0 {name=x141}
C {devices/lab_pin.sym} -2760 -1130 0 0 {name=p1065 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1010 0 0 {name=l386 lab=GND}
C {devices/lab_pin.sym} -2510 -1080 0 0 {name=p1066 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2380 -1010 0 0 {name=Vmeas142 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -940 0 0 {name=M142
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -940 3 0 {name=l387 lab=GND}
C {devices/lab_pin.sym} -2380 -900 2 0 {name=p1068 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -940 0 0 {name=p1069 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -900 0 0 {name=x142}
C {devices/lab_pin.sym} -2440 -1130 0 0 {name=p1070 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1010 0 0 {name=l388 lab=GND}
C {devices/lab_pin.sym} -2190 -1080 0 0 {name=p1071 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2060 -1010 0 0 {name=Vmeas143 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -940 0 0 {name=M143
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -940 3 0 {name=l389 lab=GND}
C {devices/lab_pin.sym} -2060 -900 2 0 {name=p1073 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -940 0 0 {name=p1074 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -900 0 0 {name=x143}
C {devices/lab_pin.sym} -2120 -1130 0 0 {name=p1075 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1010 0 0 {name=l390 lab=GND}
C {devices/lab_pin.sym} -1870 -1080 0 0 {name=p1076 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1740 -1010 0 0 {name=Vmeas144 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -940 0 0 {name=M144
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -940 3 0 {name=l391 lab=GND}
C {devices/lab_pin.sym} -1740 -900 2 0 {name=p1078 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -940 0 0 {name=p1079 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -900 0 0 {name=x144}
C {devices/lab_pin.sym} -1800 -1130 0 0 {name=p1080 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1010 0 0 {name=l392 lab=GND}
C {devices/lab_pin.sym} -1550 -1080 0 0 {name=p1081 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1420 -1010 0 0 {name=Vmeas145 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -940 0 0 {name=M145
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -940 3 0 {name=l393 lab=GND}
C {devices/lab_pin.sym} -1420 -900 2 0 {name=p1083 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -940 0 0 {name=p1084 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -900 0 0 {name=x145}
C {devices/lab_pin.sym} -1480 -1130 0 0 {name=p1085 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1010 0 0 {name=l394 lab=GND}
C {devices/lab_pin.sym} -1230 -1080 0 0 {name=p1086 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1100 -1010 0 0 {name=Vmeas146 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -940 0 0 {name=M146
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -940 3 0 {name=l395 lab=GND}
C {devices/lab_pin.sym} -1100 -900 2 0 {name=p1088 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -940 0 0 {name=p1089 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -900 0 0 {name=x146}
C {devices/lab_pin.sym} -1160 -1130 0 0 {name=p1090 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1010 0 0 {name=l396 lab=GND}
C {devices/lab_pin.sym} -910 -1080 0 0 {name=p1091 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -780 -1010 0 0 {name=Vmeas147 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -940 0 0 {name=M147
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -940 3 0 {name=l397 lab=GND}
C {devices/lab_pin.sym} -780 -900 2 0 {name=p1093 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -940 0 0 {name=p1094 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -900 0 0 {name=x147}
C {devices/lab_pin.sym} -840 -1130 0 0 {name=p1095 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1010 0 0 {name=l398 lab=GND}
C {devices/lab_pin.sym} -590 -1080 0 0 {name=p1096 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -460 -1010 0 0 {name=Vmeas148 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -940 0 0 {name=M148
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -940 3 0 {name=l399 lab=GND}
C {devices/lab_pin.sym} -460 -900 2 0 {name=p1098 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -940 0 0 {name=p1099 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -900 0 0 {name=x148}
C {devices/lab_pin.sym} -520 -1130 0 0 {name=p1100 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1010 0 0 {name=l400 lab=GND}
C {devices/lab_pin.sym} -270 -1080 0 0 {name=p1101 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -140 -1010 0 0 {name=Vmeas149 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -940 0 0 {name=M149
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -940 3 0 {name=l401 lab=GND}
C {devices/lab_pin.sym} -140 -900 2 0 {name=p1103 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -940 0 0 {name=p1104 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -900 0 0 {name=x149}
C {devices/lab_pin.sym} -200 -1130 0 0 {name=p1105 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -490 0 0 {name=l402 lab=GND}
C {devices/lab_pin.sym} -2830 -560 0 0 {name=p1106 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2700 -490 0 0 {name=Vmeas151 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -420 0 0 {name=M151
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -420 3 0 {name=l403 lab=GND}
C {devices/lab_pin.sym} -2700 -380 2 0 {name=p1108 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -420 0 0 {name=p1109 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -380 0 0 {name=x151}
C {devices/lab_pin.sym} -2760 -610 0 0 {name=p1110 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -490 0 0 {name=l404 lab=GND}
C {devices/lab_pin.sym} -2510 -560 0 0 {name=p1111 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2380 -490 0 0 {name=Vmeas152 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -420 0 0 {name=M152
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -420 3 0 {name=l405 lab=GND}
C {devices/lab_pin.sym} -2380 -380 2 0 {name=p1113 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -420 0 0 {name=p1114 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -380 0 0 {name=x152}
C {devices/lab_pin.sym} -2440 -610 0 0 {name=p1115 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -490 0 0 {name=l406 lab=GND}
C {devices/lab_pin.sym} -2190 -560 0 0 {name=p1116 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2060 -490 0 0 {name=Vmeas153 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -420 0 0 {name=M153
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -420 3 0 {name=l407 lab=GND}
C {devices/lab_pin.sym} -2060 -380 2 0 {name=p1118 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -420 0 0 {name=p1119 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -380 0 0 {name=x153}
C {devices/lab_pin.sym} -2120 -610 0 0 {name=p1120 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -490 0 0 {name=l408 lab=GND}
C {devices/lab_pin.sym} -1870 -560 0 0 {name=p1121 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas154 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M154
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l409 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p1123 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p1124 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x154}
C {devices/lab_pin.sym} -1800 -610 0 0 {name=p1125 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -490 0 0 {name=l410 lab=GND}
C {devices/lab_pin.sym} -1550 -560 0 0 {name=p1126 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1420 -490 0 0 {name=Vmeas155 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -420 0 0 {name=M155
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -420 3 0 {name=l411 lab=GND}
C {devices/lab_pin.sym} -1420 -380 2 0 {name=p1128 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -420 0 0 {name=p1129 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -380 0 0 {name=x155}
C {devices/lab_pin.sym} -1480 -610 0 0 {name=p1130 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -490 0 0 {name=l412 lab=GND}
C {devices/lab_pin.sym} -1230 -560 0 0 {name=p1131 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1100 -490 0 0 {name=Vmeas156 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -420 0 0 {name=M156
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -420 3 0 {name=l413 lab=GND}
C {devices/lab_pin.sym} -1100 -380 2 0 {name=p1133 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -420 0 0 {name=p1134 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -380 0 0 {name=x156}
C {devices/lab_pin.sym} -1160 -610 0 0 {name=p1135 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -490 0 0 {name=l414 lab=GND}
C {devices/lab_pin.sym} -910 -560 0 0 {name=p1136 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -780 -490 0 0 {name=Vmeas157 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -420 0 0 {name=M157
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -420 3 0 {name=l415 lab=GND}
C {devices/lab_pin.sym} -780 -380 2 0 {name=p1138 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -420 0 0 {name=p1139 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -380 0 0 {name=x157}
C {devices/lab_pin.sym} -840 -610 0 0 {name=p1140 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -490 0 0 {name=l416 lab=GND}
C {devices/lab_pin.sym} -590 -560 0 0 {name=p1141 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -460 -490 0 0 {name=Vmeas158 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -420 0 0 {name=M158
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -420 3 0 {name=l417 lab=GND}
C {devices/lab_pin.sym} -460 -380 2 0 {name=p1143 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -420 0 0 {name=p1144 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -380 0 0 {name=x158}
C {devices/lab_pin.sym} -520 -610 0 0 {name=p1145 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -490 0 0 {name=l418 lab=GND}
C {devices/lab_pin.sym} -270 -560 0 0 {name=p1146 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -140 -490 0 0 {name=Vmeas159 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -420 0 0 {name=M159
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -420 3 0 {name=l419 lab=GND}
C {devices/lab_pin.sym} -140 -380 2 0 {name=p1148 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -420 0 0 {name=p1149 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -380 0 0 {name=x159}
C {devices/lab_pin.sym} -200 -610 0 0 {name=p1150 sig_type=std_logic lab=vdd_syn9}
C {devices/lab_pin.sym} -2510 -5760 0 0 {name=p626 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2190 -5760 0 0 {name=p627 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1870 -5760 0 0 {name=p631 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1550 -5760 0 0 {name=p632 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1230 -5760 0 0 {name=p636 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -910 -5760 0 0 {name=p637 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -590 -5760 0 0 {name=p641 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -270 -5760 0 0 {name=p642 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2830 -6280 0 0 {name=p478 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2510 -6280 0 0 {name=p479 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2190 -6280 0 0 {name=p483 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1870 -6280 0 0 {name=p484 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1550 -6280 0 0 {name=p488 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1230 -6280 0 0 {name=p489 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -910 -6280 0 0 {name=p493 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -590 -6280 0 0 {name=p494 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -270 -6280 0 0 {name=p498 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2830 -6800 0 0 {name=p525 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2510 -6800 0 0 {name=p526 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2190 -6800 0 0 {name=p530 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1870 -6800 0 0 {name=p531 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1550 -6800 0 0 {name=p535 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1230 -6800 0 0 {name=p536 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -910 -6800 0 0 {name=p540 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -590 -6800 0 0 {name=p541 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -270 -6800 0 0 {name=p545 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2830 -7320 0 0 {name=p572 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2510 -7320 0 0 {name=p573 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2190 -7320 0 0 {name=p577 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1870 -7320 0 0 {name=p578 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1550 -7320 0 0 {name=p582 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1230 -7320 0 0 {name=p583 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -910 -7320 0 0 {name=p587 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -590 -7320 0 0 {name=p588 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -270 -7320 0 0 {name=p592 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} 30 -4370 0 0 {name=p1151 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} 30 -4390 0 0 {name=p1152 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} 30 -4410 0 0 {name=p1153 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} 30 -4430 0 0 {name=p1154 sig_type=std_logic lab=4}
C {devices/lab_pin.sym} 30 -4450 0 0 {name=p1155 sig_type=std_logic lab=5}
C {devices/lab_pin.sym} 30 -4470 0 0 {name=p1156 sig_type=std_logic lab=6}
C {devices/lab_pin.sym} 30 -4490 0 0 {name=p1157 sig_type=std_logic lab=7}
C {devices/lab_pin.sym} 30 -4510 0 0 {name=p1158 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} 30 -4530 0 0 {name=p1159 sig_type=std_logic lab=9}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/WTA_circuit.sym} 160 -4440 0 0 {name=x160}
C {devices/vsource.sym} 120 -2790 0 0 {name=V23 value=1.8}
C {devices/gnd.sym} 120 -2740 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 120 -2840 2 0 {name=p1160 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} 220 -2790 0 0 {name=V24 value=1.8}
C {devices/gnd.sym} 220 -2740 0 0 {name=l420 lab=GND}
C {devices/lab_pin.sym} 220 -2840 2 0 {name=p1161 sig_type=std_logic lab=vdd_syn2}
C {devices/vsource.sym} 320 -2790 0 0 {name=V25 value=1.8}
C {devices/gnd.sym} 320 -2740 0 0 {name=l421 lab=GND}
C {devices/lab_pin.sym} 320 -2840 2 0 {name=p1162 sig_type=std_logic lab=vdd_syn3}
C {devices/vsource.sym} 420 -2790 0 0 {name=V26 value=1.8}
C {devices/gnd.sym} 420 -2740 0 0 {name=l422 lab=GND}
C {devices/lab_pin.sym} 420 -2840 2 0 {name=p1163 sig_type=std_logic lab=vdd_syn4}
C {devices/vsource.sym} 520 -2790 0 0 {name=V27 value=1.8}
C {devices/gnd.sym} 520 -2740 0 0 {name=l423 lab=GND}
C {devices/lab_pin.sym} 520 -2840 2 0 {name=p1164 sig_type=std_logic lab=vdd_syn5}
C {devices/vsource.sym} 620 -2790 0 0 {name=V28 value=1.8}
C {devices/gnd.sym} 620 -2740 0 0 {name=l424 lab=GND}
C {devices/lab_pin.sym} 620 -2840 2 0 {name=p1165 sig_type=std_logic lab=vdd_syn6}
C {devices/vsource.sym} 720 -2790 0 0 {name=V29 value=1.8}
C {devices/gnd.sym} 720 -2740 0 0 {name=l425 lab=GND}
C {devices/lab_pin.sym} 720 -2840 2 0 {name=p1166 sig_type=std_logic lab=vdd_syn7}
C {devices/vsource.sym} 820 -2790 0 0 {name=V30 value=1.8}
C {devices/gnd.sym} 820 -2740 0 0 {name=l426 lab=GND}
C {devices/lab_pin.sym} 820 -2840 2 0 {name=p1167 sig_type=std_logic lab=vdd_syn8}
C {devices/vsource.sym} 920 -2790 0 0 {name=V31 value=1.8}
C {devices/gnd.sym} 920 -2740 0 0 {name=l427 lab=GND}
C {devices/lab_pin.sym} 920 -2840 2 0 {name=p1168 sig_type=std_logic lab=vdd_syn9}
C {devices/vsource.sym} 800 -2650 0 0 {name=V32 value=1.8}
C {devices/gnd.sym} 800 -2600 0 0 {name=l428 lab=GND}
C {devices/lab_pin.sym} 800 -2700 2 0 {name=p1169 sig_type=std_logic lab=b_px}
C {devices/vsource.sym} 720 -2650 0 0 {name=V33 value=0}
C {devices/gnd.sym} 720 -2600 0 0 {name=l429 lab=GND}
C {devices/lab_pin.sym} 720 -2700 2 0 {name=p1170 sig_type=std_logic lab=w_px}
