v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -1200 800 -800 {flags=graph
y1=-0.053
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vps1; vpre1\\"
\\"vps2; vpre2\\"
\\"vps3; vpre3\\"
\\"vps4; vpre4\\"
\\"vps5; vpre5\\"
\\"vps6; vpre6\\"
\\"vps7; vpre7\\"
\\"vps8; vpre8\\"
\\"vps9; vpre9\\""}
B 2 800 -400 1600 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Weights updating ;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 1600 -2800 2400 -2400 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas1000)\\"
\\"Ip1;i(vmeas8)\\"
\\"Ip2;i(vmeas6)\\""}
B 2 3200 -2400 4000 -2000 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="\\"0; N0\\"
1
2
3
4
5
6
7
8
9"}
B 2 0 -800 800 -400 {flags=graph
y1=2.2
y2=4.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 800 -800 1600 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=0.019
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 2400 -1200 3200 -800 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 3200 -2000 4000 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 3200 -1600 4000 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 3200 -1200 4000 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 2400 -800 3200 -400 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 2400 -400 3200 0 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 3200 -800 4000 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 3200 -400 4000 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 800 -1200 1600 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
B 2 0 -400 800 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 2400 -2400 3200 -2000 {flags=graph
y1=-0.014
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="p0
p1
p2
p3
p4
p5
p6
p7
p8
p9"}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="inh0
inh1
inh2
inh3
inh4
inh5
inh6
inh7
inh8
inh9"}
B 2 2400 -2800 3200 -2400 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="4 7"
node="p0
p8"}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=0.3848
y2=2.4038
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=7.84475e-05
x2=7.91705e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color=9
node=inh_d}
N 20 -2620 20 -2600 {
lab=GND}
N 20 -2700 20 -2680 {
lab=vdd_in}
N 100 -2620 100 -2600 {
lab=GND}
N 100 -2700 100 -2680 {
lab=vdd_pre}
N -3760 -4390 -3760 -4370 {
lab=GND}
N -3760 -4550 -3760 -4530 {
lab=vdd_pre}
N -4140 -4380 -4140 -4360 {
lab=GND}
N -3940 -4480 -3940 -4460 {
lab=vc2}
N -3940 -4510 -3930 -4510 {
lab=vdd_in}
N -3930 -4540 -3930 -4510 {
lab=vdd_in}
N -3940 -4540 -3930 -4540 {
lab=vdd_in}
N -4020 -4510 -3980 -4510 {
lab=#net1}
N -4060 -4540 -3940 -4540 {
lab=vdd_in}
N -4070 -4510 -4060 -4510 {
lab=vdd_in}
N -4070 -4540 -4070 -4510 {
lab=vdd_in}
N -4070 -4540 -4060 -4540 {
lab=vdd_in}
N -4060 -4480 -4060 -4460 {
lab=#net1}
N -4060 -4460 -4000 -4460 {
lab=#net1}
N -4000 -4510 -4000 -4460 {
lab=#net1}
N -4140 -4460 -4140 -4440 {
lab=#net2}
N -3080 -4700 -3080 -4690 {
lab=GND}
N -3080 -4810 -3080 -4800 {
lab=vdd_syn0}
N -3020 -4620 -3010 -4620 {
lab=GND}
N -3020 -4590 -3020 -4580 {
lab=p0}
N 20 -2200 20 -2180 {
lab=GND}
N 20 -2280 20 -2260 {
lab=uw}
N 200 -2200 200 -2180 {
lab=GND}
N 200 -2280 200 -2260 {
lab=training}
N -3620 -4460 -3610 -4460 {
lab=vpre2}
N 460 -2200 460 -2180 {
lab=GND}
N 460 -2280 460 -2260 {
lab=inference}
N -4080 -4460 -4060 -4460 {
lab=#net1}
N 20 -2340 20 -2320 {
lab=GND}
N 20 -2420 20 -2400 {
lab=ctrl_wu}
N 180 -2480 180 -2460 {
lab=GND}
N 180 -2560 180 -2540 {
lab=vb_wu}
N 190 -2620 190 -2600 {
lab=GND}
N 190 -2700 190 -2680 {
lab=vdd_pos}
N 280 -2620 280 -2600 {
lab=GND}
N 280 -2700 280 -2680 {
lab=vdd_wu}
N 360 -2620 360 -2600 {
lab=GND}
N 360 -2700 360 -2680 {
lab=vdd_tr}
N 20 -2480 20 -2460 {
lab=GND}
N 20 -2560 20 -2540 {
lab=vb_pre}
N 100 -2480 100 -2460 {
lab=GND}
N 100 -2560 100 -2540 {
lab=vb_pos}
N -3150 -4760 -3140 -4760 {
lab=vpres1}
N -3020 -4760 -3010 -4760 {
lab=w_px}
N -3760 -4690 -3760 -4670 {
lab=GND}
N -3760 -4850 -3760 -4830 {
lab=vdd_pre}
N -4140 -4680 -4140 -4660 {
lab=GND}
N -3940 -4780 -3940 -4760 {
lab=vc1}
N -3940 -4810 -3930 -4810 {
lab=vdd_in}
N -3930 -4840 -3930 -4810 {
lab=vdd_in}
N -3940 -4840 -3930 -4840 {
lab=vdd_in}
N -4020 -4810 -3980 -4810 {
lab=#net3}
N -4060 -4840 -3940 -4840 {
lab=vdd_in}
N -4070 -4810 -4060 -4810 {
lab=vdd_in}
N -4070 -4840 -4070 -4810 {
lab=vdd_in}
N -4070 -4840 -4060 -4840 {
lab=vdd_in}
N -4060 -4780 -4060 -4760 {
lab=#net3}
N -4060 -4760 -4000 -4760 {
lab=#net3}
N -4000 -4810 -4000 -4760 {
lab=#net3}
N -4140 -4760 -4140 -4740 {
lab=#net4}
N -3080 -4400 -3080 -4390 {
lab=GND}
N -3080 -4510 -3080 -4500 {
lab=vdd_syn0}
N -3020 -4320 -3010 -4320 {
lab=GND}
N -3020 -4290 -3020 -4280 {
lab=p0}
N -3620 -4760 -3610 -4760 {
lab=vpre1}
N -4080 -4760 -4060 -4760 {
lab=#net3}
N -3390 -4570 -3390 -4560 {
lab=GND}
N -3340 -4610 -3330 -4610 {
lab=vpres1}
N -3390 -4720 -3390 -4710 {
lab=GND}
N -3340 -4760 -3330 -4760 {
lab=vpres1}
N -3150 -4460 -3140 -4460 {
lab=vpres2}
N -3020 -4460 -3010 -4460 {
lab=b_px}
N -3070 -4320 -3060 -4320 {
lab=ctrl_pos}
N -3070 -4620 -3060 -4620 {
lab=ctrl_pos}
N 100 -2340 100 -2320 {
lab=GND}
N 100 -2420 100 -2400 {
lab=ctrl_inf}
N 520 -2620 520 -2600 {
lab=GND}
N 520 -2700 520 -2680 {
lab=vdd_inh}
N 120 -4590 120 -4580 {
lab=vdd_inh}
N 260 -2340 260 -2320 {
lab=GND}
N 260 -2420 260 -2400 {
lab=ctrl_vinh}
N 120 -4300 120 -4290 {
lab=GND}
N 300 -4440 310 -4440 {
lab=inh_d}
N 150 -4040 160 -4040 {
lab=inh1}
N 120 -4050 120 -4040 {
lab=GND}
N 120 -4000 120 -3990 {
lab=inh_d}
N 80 -4040 90 -4040 {
lab=ctrl_vinh}
N 260 -2480 260 -2460 {
lab=GND}
N 260 -2560 260 -2540 {
lab=vlky}
N -3940 -4760 -3860 -4760 {
lab=vc1}
N -3860 -4800 -3850 -4800 {
lab=vlky}
N -3860 -4720 -3850 -4720 {
lab=vb_pre}
N -3860 -4500 -3850 -4500 {
lab=vlky}
N -3940 -4460 -3860 -4460 {
lab=vc2}
N -3860 -4420 -3850 -4420 {
lab=vb_pre}
N 20 -2760 20 -2740 {
lab=GND}
N 20 -2840 20 -2820 {
lab=vdd_syn0}
N -3450 -4580 -3440 -4580 {
lab=vb_wu}
N -3020 -4740 -3020 -4720 {
lab=#net5}
N -3020 -4660 -3020 -4650 {
lab=#net6}
N -3020 -4440 -3020 -4420 {
lab=#net7}
N -3020 -4360 -3020 -4350 {
lab=#net8}
N -3080 -4100 -3080 -4090 {
lab=GND}
N -3080 -4210 -3080 -4200 {
lab=vdd_syn0}
N -3020 -4020 -3010 -4020 {
lab=GND}
N -3020 -3990 -3020 -3980 {
lab=p0}
N -3150 -4160 -3140 -4160 {
lab=vpres3}
N -3020 -4160 -3010 -4160 {
lab=w_px}
N -3070 -4020 -3060 -4020 {
lab=ctrl_pos}
N -3020 -4140 -3020 -4120 {
lab=#net9}
N -3020 -4060 -3020 -4050 {
lab=#net10}
N -3080 -3800 -3080 -3790 {
lab=GND}
N -3080 -3910 -3080 -3900 {
lab=vdd_syn0}
N -3020 -3720 -3010 -3720 {
lab=GND}
N -3020 -3690 -3020 -3680 {
lab=p0}
N -3150 -3860 -3140 -3860 {
lab=vpres4}
N -3020 -3860 -3010 -3860 {
lab=b_px}
N -3070 -3720 -3060 -3720 {
lab=ctrl_pos}
N -3020 -3840 -3020 -3820 {
lab=#net11}
N -3020 -3760 -3020 -3750 {
lab=#net12}
N -3080 -3500 -3080 -3490 {
lab=GND}
N -3080 -3610 -3080 -3600 {
lab=vdd_syn0}
N -3020 -3420 -3010 -3420 {
lab=GND}
N -3020 -3390 -3020 -3380 {
lab=p0}
N -3150 -3560 -3140 -3560 {
lab=vpres5}
N -3020 -3560 -3010 -3560 {
lab=w_px}
N -3070 -3420 -3060 -3420 {
lab=ctrl_pos}
N -3020 -3540 -3020 -3520 {
lab=#net13}
N -3020 -3460 -3020 -3450 {
lab=#net14}
N -3080 -3200 -3080 -3190 {
lab=GND}
N -3080 -3310 -3080 -3300 {
lab=vdd_syn0}
N -3020 -3120 -3010 -3120 {
lab=GND}
N -3020 -3090 -3020 -3080 {
lab=p0}
N -3150 -3260 -3140 -3260 {
lab=vpres6}
N -3020 -3260 -3010 -3260 {
lab=b_px}
N -3070 -3120 -3060 -3120 {
lab=ctrl_pos}
N -3020 -3240 -3020 -3220 {
lab=#net15}
N -3020 -3160 -3020 -3150 {
lab=#net16}
N -3080 -2900 -3080 -2890 {
lab=GND}
N -3080 -3010 -3080 -3000 {
lab=vdd_syn0}
N -3020 -2820 -3010 -2820 {
lab=GND}
N -3020 -2790 -3020 -2780 {
lab=p0}
N -3150 -2960 -3140 -2960 {
lab=vpres7}
N -3020 -2960 -3010 -2960 {
lab=b_px}
N -3070 -2820 -3060 -2820 {
lab=ctrl_pos}
N -3020 -2940 -3020 -2920 {
lab=#net17}
N -3020 -2860 -3020 -2850 {
lab=#net18}
N -3080 -2600 -3080 -2590 {
lab=GND}
N -3080 -2710 -3080 -2700 {
lab=vdd_syn0}
N -3020 -2520 -3010 -2520 {
lab=GND}
N -3020 -2490 -3020 -2480 {
lab=p0}
N -3150 -2660 -3140 -2660 {
lab=vpres8}
N -3020 -2660 -3010 -2660 {
lab=w_px}
N -3070 -2520 -3060 -2520 {
lab=ctrl_pos}
N -3020 -2640 -3020 -2620 {
lab=#net19}
N -3020 -2560 -3020 -2550 {
lab=#net20}
N -3080 -2300 -3080 -2290 {
lab=GND}
N -3080 -2410 -3080 -2400 {
lab=vdd_syn0}
N -3020 -2220 -3010 -2220 {
lab=GND}
N -3020 -2190 -3020 -2180 {
lab=p0}
N -3150 -2360 -3140 -2360 {
lab=vpres9}
N -3020 -2360 -3010 -2360 {
lab=b_px}
N -3070 -2220 -3060 -2220 {
lab=ctrl_pos}
N -3020 -2340 -3020 -2320 {
lab=#net21}
N -3020 -2260 -3020 -2250 {
lab=#net22}
N -3760 -3790 -3760 -3770 {
lab=GND}
N -3760 -3950 -3760 -3930 {
lab=vdd_pre}
N -4140 -3780 -4140 -3760 {
lab=GND}
N -3940 -3880 -3940 -3860 {
lab=vc4}
N -3940 -3910 -3930 -3910 {
lab=vdd_in}
N -3930 -3940 -3930 -3910 {
lab=vdd_in}
N -3940 -3940 -3930 -3940 {
lab=vdd_in}
N -4020 -3910 -3980 -3910 {
lab=#net23}
N -4060 -3940 -3940 -3940 {
lab=vdd_in}
N -4070 -3910 -4060 -3910 {
lab=vdd_in}
N -4070 -3940 -4070 -3910 {
lab=vdd_in}
N -4070 -3940 -4060 -3940 {
lab=vdd_in}
N -4060 -3880 -4060 -3860 {
lab=#net23}
N -4060 -3860 -4000 -3860 {
lab=#net23}
N -4000 -3910 -4000 -3860 {
lab=#net23}
N -4140 -3860 -4140 -3840 {
lab=#net24}
N -3620 -3860 -3610 -3860 {
lab=vpre4}
N -4080 -3860 -4060 -3860 {
lab=#net23}
N -3760 -4090 -3760 -4070 {
lab=GND}
N -3760 -4250 -3760 -4230 {
lab=vdd_pre}
N -4140 -4080 -4140 -4060 {
lab=GND}
N -3940 -4180 -3940 -4160 {
lab=vc3}
N -3940 -4210 -3930 -4210 {
lab=vdd_in}
N -3930 -4240 -3930 -4210 {
lab=vdd_in}
N -3940 -4240 -3930 -4240 {
lab=vdd_in}
N -4020 -4210 -3980 -4210 {
lab=#net25}
N -4060 -4240 -3940 -4240 {
lab=vdd_in}
N -4070 -4210 -4060 -4210 {
lab=vdd_in}
N -4070 -4240 -4070 -4210 {
lab=vdd_in}
N -4070 -4240 -4060 -4240 {
lab=vdd_in}
N -4060 -4180 -4060 -4160 {
lab=#net25}
N -4060 -4160 -4000 -4160 {
lab=#net25}
N -4000 -4210 -4000 -4160 {
lab=#net25}
N -4140 -4160 -4140 -4140 {
lab=#net26}
N -3620 -4160 -3610 -4160 {
lab=vpre3}
N -4080 -4160 -4060 -4160 {
lab=#net25}
N -3940 -4160 -3860 -4160 {
lab=vc3}
N -3860 -4200 -3850 -4200 {
lab=vlky}
N -3860 -4120 -3850 -4120 {
lab=vb_pre}
N -3860 -3900 -3850 -3900 {
lab=vlky}
N -3940 -3860 -3860 -3860 {
lab=vc4}
N -3860 -3820 -3850 -3820 {
lab=vb_pre}
N -3760 -3190 -3760 -3170 {
lab=GND}
N -3760 -3350 -3760 -3330 {
lab=vdd_pre}
N -4140 -3180 -4140 -3160 {
lab=GND}
N -3940 -3280 -3940 -3260 {
lab=vc6}
N -3940 -3310 -3930 -3310 {
lab=vdd_in}
N -3930 -3340 -3930 -3310 {
lab=vdd_in}
N -3940 -3340 -3930 -3340 {
lab=vdd_in}
N -4020 -3310 -3980 -3310 {
lab=#net27}
N -4060 -3340 -3940 -3340 {
lab=vdd_in}
N -4070 -3310 -4060 -3310 {
lab=vdd_in}
N -4070 -3340 -4070 -3310 {
lab=vdd_in}
N -4070 -3340 -4060 -3340 {
lab=vdd_in}
N -4060 -3280 -4060 -3260 {
lab=#net27}
N -4060 -3260 -4000 -3260 {
lab=#net27}
N -4000 -3310 -4000 -3260 {
lab=#net27}
N -4140 -3260 -4140 -3240 {
lab=#net28}
N -3620 -3260 -3610 -3260 {
lab=vpre6}
N -4080 -3260 -4060 -3260 {
lab=#net27}
N -3760 -3490 -3760 -3470 {
lab=GND}
N -3760 -3650 -3760 -3630 {
lab=vdd_pre}
N -4140 -3480 -4140 -3460 {
lab=GND}
N -3940 -3580 -3940 -3560 {
lab=vc5}
N -3940 -3610 -3930 -3610 {
lab=vdd_in}
N -3930 -3640 -3930 -3610 {
lab=vdd_in}
N -3940 -3640 -3930 -3640 {
lab=vdd_in}
N -4020 -3610 -3980 -3610 {
lab=#net29}
N -4060 -3640 -3940 -3640 {
lab=vdd_in}
N -4070 -3610 -4060 -3610 {
lab=vdd_in}
N -4070 -3640 -4070 -3610 {
lab=vdd_in}
N -4070 -3640 -4060 -3640 {
lab=vdd_in}
N -4060 -3580 -4060 -3560 {
lab=#net29}
N -4060 -3560 -4000 -3560 {
lab=#net29}
N -4000 -3610 -4000 -3560 {
lab=#net29}
N -4140 -3560 -4140 -3540 {
lab=#net30}
N -3620 -3560 -3610 -3560 {
lab=vpre5}
N -4080 -3560 -4060 -3560 {
lab=#net29}
N -3940 -3560 -3860 -3560 {
lab=vc5}
N -3860 -3600 -3850 -3600 {
lab=vlky}
N -3860 -3520 -3850 -3520 {
lab=vb_pre}
N -3860 -3300 -3850 -3300 {
lab=vlky}
N -3940 -3260 -3860 -3260 {
lab=vc6}
N -3860 -3220 -3850 -3220 {
lab=vb_pre}
N -3760 -2590 -3760 -2570 {
lab=GND}
N -3760 -2750 -3760 -2730 {
lab=vdd_pre}
N -4140 -2580 -4140 -2560 {
lab=GND}
N -3940 -2680 -3940 -2660 {
lab=vc8}
N -3940 -2710 -3930 -2710 {
lab=vdd_in}
N -3930 -2740 -3930 -2710 {
lab=vdd_in}
N -3940 -2740 -3930 -2740 {
lab=vdd_in}
N -4020 -2710 -3980 -2710 {
lab=#net31}
N -4060 -2740 -3940 -2740 {
lab=vdd_in}
N -4070 -2710 -4060 -2710 {
lab=vdd_in}
N -4070 -2740 -4070 -2710 {
lab=vdd_in}
N -4070 -2740 -4060 -2740 {
lab=vdd_in}
N -4060 -2680 -4060 -2660 {
lab=#net31}
N -4060 -2660 -4000 -2660 {
lab=#net31}
N -4000 -2710 -4000 -2660 {
lab=#net31}
N -4140 -2660 -4140 -2640 {
lab=#net32}
N -3620 -2660 -3610 -2660 {
lab=vpre8}
N -4080 -2660 -4060 -2660 {
lab=#net31}
N -3760 -2890 -3760 -2870 {
lab=GND}
N -3760 -3050 -3760 -3030 {
lab=vdd_pre}
N -4140 -2880 -4140 -2860 {
lab=GND}
N -3940 -2980 -3940 -2960 {
lab=vc7}
N -3940 -3010 -3930 -3010 {
lab=vdd_in}
N -3930 -3040 -3930 -3010 {
lab=vdd_in}
N -3940 -3040 -3930 -3040 {
lab=vdd_in}
N -4020 -3010 -3980 -3010 {
lab=#net33}
N -4060 -3040 -3940 -3040 {
lab=vdd_in}
N -4070 -3010 -4060 -3010 {
lab=vdd_in}
N -4070 -3040 -4070 -3010 {
lab=vdd_in}
N -4070 -3040 -4060 -3040 {
lab=vdd_in}
N -4060 -2980 -4060 -2960 {
lab=#net33}
N -4060 -2960 -4000 -2960 {
lab=#net33}
N -4000 -3010 -4000 -2960 {
lab=#net33}
N -4140 -2960 -4140 -2940 {
lab=#net34}
N -3620 -2960 -3610 -2960 {
lab=vpre7}
N -4080 -2960 -4060 -2960 {
lab=#net33}
N -3940 -2960 -3860 -2960 {
lab=vc7}
N -3860 -3000 -3850 -3000 {
lab=vlky}
N -3860 -2920 -3850 -2920 {
lab=vb_pre}
N -3860 -2700 -3850 -2700 {
lab=vlky}
N -3940 -2660 -3860 -2660 {
lab=vc8}
N -3860 -2620 -3850 -2620 {
lab=vb_pre}
N -3760 -2290 -3760 -2270 {
lab=GND}
N -3760 -2450 -3760 -2430 {
lab=vdd_pre}
N -4140 -2280 -4140 -2260 {
lab=GND}
N -3940 -2380 -3940 -2360 {
lab=vc9}
N -3940 -2410 -3930 -2410 {
lab=vdd_in}
N -3930 -2440 -3930 -2410 {
lab=vdd_in}
N -3940 -2440 -3930 -2440 {
lab=vdd_in}
N -4020 -2410 -3980 -2410 {
lab=#net35}
N -4060 -2440 -3940 -2440 {
lab=vdd_in}
N -4070 -2410 -4060 -2410 {
lab=vdd_in}
N -4070 -2440 -4070 -2410 {
lab=vdd_in}
N -4070 -2440 -4060 -2440 {
lab=vdd_in}
N -4060 -2380 -4060 -2360 {
lab=#net35}
N -4060 -2360 -4000 -2360 {
lab=#net35}
N -4000 -2410 -4000 -2360 {
lab=#net35}
N -4140 -2360 -4140 -2340 {
lab=#net36}
N -3620 -2360 -3610 -2360 {
lab=vpre9}
N -4080 -2360 -4060 -2360 {
lab=#net35}
N -3860 -2400 -3850 -2400 {
lab=vlky}
N -3940 -2360 -3860 -2360 {
lab=vc9}
N -3860 -2320 -3850 -2320 {
lab=vb_pre}
N 30 -4350 40 -4350 {
lab=N0}
N -3080 -2000 -3080 -1990 {
lab=GND}
N -3080 -2110 -3080 -2100 {
lab=vdd_syn0}
N -3020 -1920 -3010 -1920 {
lab=GND}
N -3020 -1890 -3020 -1880 {
lab=p0}
N -3150 -2060 -3140 -2060 {
lab=vpres10}
N -3020 -2060 -3010 -2060 {
lab=b_px}
N -3070 -1920 -3060 -1920 {
lab=ctrl_pos}
N -3020 -2040 -3020 -2020 {
lab=#net37}
N -3020 -1960 -3020 -1950 {
lab=#net38}
N -3080 -1700 -3080 -1690 {
lab=GND}
N -3080 -1810 -3080 -1800 {
lab=vdd_syn0}
N -3020 -1620 -3010 -1620 {
lab=GND}
N -3020 -1590 -3020 -1580 {
lab=p0}
N -3150 -1760 -3140 -1760 {
lab=vpres11}
N -3020 -1760 -3010 -1760 {
lab=w_px}
N -3070 -1620 -3060 -1620 {
lab=ctrl_pos}
N -3020 -1740 -3020 -1720 {
lab=#net39}
N -3020 -1660 -3020 -1650 {
lab=#net40}
N -3080 -1400 -3080 -1390 {
lab=GND}
N -3080 -1510 -3080 -1500 {
lab=vdd_syn0}
N -3020 -1320 -3010 -1320 {
lab=GND}
N -3020 -1290 -3020 -1280 {
lab=p0}
N -3150 -1460 -3140 -1460 {
lab=vpres12}
N -3020 -1460 -3010 -1460 {
lab=b_px}
N -3070 -1320 -3060 -1320 {
lab=ctrl_pos}
N -3020 -1440 -3020 -1420 {
lab=#net41}
N -3020 -1360 -3020 -1350 {
lab=#net42}
N -3080 -1100 -3080 -1090 {
lab=GND}
N -3080 -1210 -3080 -1200 {
lab=vdd_syn0}
N -3020 -1020 -3010 -1020 {
lab=GND}
N -3020 -990 -3020 -980 {
lab=p0}
N -3150 -1160 -3140 -1160 {
lab=vpres13}
N -3020 -1160 -3010 -1160 {
lab=w_px}
N -3070 -1020 -3060 -1020 {
lab=ctrl_pos}
N -3020 -1140 -3020 -1120 {
lab=#net43}
N -3020 -1060 -3020 -1050 {
lab=#net44}
N -3080 -800 -3080 -790 {
lab=GND}
N -3080 -910 -3080 -900 {
lab=vdd_syn0}
N -3020 -720 -3010 -720 {
lab=GND}
N -3020 -690 -3020 -680 {
lab=p0}
N -3070 -720 -3060 -720 {
lab=ctrl_pos}
N -3020 -840 -3020 -820 {
lab=#net45}
N -3020 -760 -3020 -750 {
lab=#net46}
N -3080 -500 -3080 -490 {
lab=GND}
N -3080 -610 -3080 -600 {
lab=vdd_syn0}
N -3020 -420 -3010 -420 {
lab=GND}
N -3020 -390 -3020 -380 {
lab=p0}
N -3020 -560 -3010 -560 {
lab=w_px}
N -3070 -420 -3060 -420 {
lab=ctrl_pos}
N -3020 -540 -3020 -520 {
lab=#net47}
N -3020 -460 -3020 -450 {
lab=#net48}
N -3760 -1990 -3760 -1970 {
lab=GND}
N -3760 -2150 -3760 -2130 {
lab=vdd_pre}
N -4140 -1980 -4140 -1960 {
lab=GND}
N -3940 -2080 -3940 -2060 {
lab=vc10}
N -3940 -2110 -3930 -2110 {
lab=vdd_in}
N -3930 -2140 -3930 -2110 {
lab=vdd_in}
N -3940 -2140 -3930 -2140 {
lab=vdd_in}
N -4020 -2110 -3980 -2110 {
lab=#net49}
N -4060 -2140 -3940 -2140 {
lab=vdd_in}
N -4070 -2110 -4060 -2110 {
lab=vdd_in}
N -4070 -2140 -4070 -2110 {
lab=vdd_in}
N -4070 -2140 -4060 -2140 {
lab=vdd_in}
N -4060 -2080 -4060 -2060 {
lab=#net49}
N -4060 -2060 -4000 -2060 {
lab=#net49}
N -4000 -2110 -4000 -2060 {
lab=#net49}
N -4140 -2060 -4140 -2040 {
lab=#net50}
N -3620 -2060 -3610 -2060 {
lab=vpre10}
N -4080 -2060 -4060 -2060 {
lab=#net49}
N -3860 -2100 -3850 -2100 {
lab=vlky}
N -3940 -2060 -3860 -2060 {
lab=vc10}
N -3860 -2020 -3850 -2020 {
lab=vb_pre}
N -3760 -1390 -3760 -1370 {
lab=GND}
N -3760 -1550 -3760 -1530 {
lab=vdd_pre}
N -4140 -1380 -4140 -1360 {
lab=GND}
N -3940 -1480 -3940 -1460 {
lab=vc12}
N -3940 -1510 -3930 -1510 {
lab=vdd_in}
N -3930 -1540 -3930 -1510 {
lab=vdd_in}
N -3940 -1540 -3930 -1540 {
lab=vdd_in}
N -4020 -1510 -3980 -1510 {
lab=#net51}
N -4060 -1540 -3940 -1540 {
lab=vdd_in}
N -4070 -1510 -4060 -1510 {
lab=vdd_in}
N -4070 -1540 -4070 -1510 {
lab=vdd_in}
N -4070 -1540 -4060 -1540 {
lab=vdd_in}
N -4060 -1480 -4060 -1460 {
lab=#net51}
N -4060 -1460 -4000 -1460 {
lab=#net51}
N -4000 -1510 -4000 -1460 {
lab=#net51}
N -4140 -1460 -4140 -1440 {
lab=#net52}
N -3620 -1460 -3610 -1460 {
lab=vpre12}
N -4080 -1460 -4060 -1460 {
lab=#net51}
N -3760 -1690 -3760 -1670 {
lab=GND}
N -3760 -1850 -3760 -1830 {
lab=vdd_pre}
N -4140 -1680 -4140 -1660 {
lab=GND}
N -3940 -1780 -3940 -1760 {
lab=vc11}
N -3940 -1810 -3930 -1810 {
lab=vdd_in}
N -3930 -1840 -3930 -1810 {
lab=vdd_in}
N -3940 -1840 -3930 -1840 {
lab=vdd_in}
N -4020 -1810 -3980 -1810 {
lab=#net53}
N -4060 -1840 -3940 -1840 {
lab=vdd_in}
N -4070 -1810 -4060 -1810 {
lab=vdd_in}
N -4070 -1840 -4070 -1810 {
lab=vdd_in}
N -4070 -1840 -4060 -1840 {
lab=vdd_in}
N -4060 -1780 -4060 -1760 {
lab=#net53}
N -4060 -1760 -4000 -1760 {
lab=#net53}
N -4000 -1810 -4000 -1760 {
lab=#net53}
N -4140 -1760 -4140 -1740 {
lab=#net54}
N -3620 -1760 -3610 -1760 {
lab=vpre11}
N -4080 -1760 -4060 -1760 {
lab=#net53}
N -3940 -1760 -3860 -1760 {
lab=vc11}
N -3860 -1800 -3850 -1800 {
lab=vlky}
N -3860 -1720 -3850 -1720 {
lab=vb_pre}
N -3860 -1500 -3850 -1500 {
lab=vlky}
N -3940 -1460 -3860 -1460 {
lab=vc12}
N -3860 -1420 -3850 -1420 {
lab=vb_pre}
N -3760 -790 -3760 -770 {
lab=GND}
N -3760 -950 -3760 -930 {
lab=vdd_pre}
N -4140 -780 -4140 -760 {
lab=GND}
N -3940 -880 -3940 -860 {
lab=vc14}
N -3940 -910 -3930 -910 {
lab=vdd_in}
N -3930 -940 -3930 -910 {
lab=vdd_in}
N -3940 -940 -3930 -940 {
lab=vdd_in}
N -4020 -910 -3980 -910 {
lab=#net55}
N -4060 -940 -3940 -940 {
lab=vdd_in}
N -4070 -910 -4060 -910 {
lab=vdd_in}
N -4070 -940 -4070 -910 {
lab=vdd_in}
N -4070 -940 -4060 -940 {
lab=vdd_in}
N -4060 -880 -4060 -860 {
lab=#net55}
N -4060 -860 -4000 -860 {
lab=#net55}
N -4000 -910 -4000 -860 {
lab=#net55}
N -4140 -860 -4140 -840 {
lab=#net56}
N -3620 -860 -3610 -860 {
lab=vpre14}
N -4080 -860 -4060 -860 {
lab=#net55}
N -3760 -1090 -3760 -1070 {
lab=GND}
N -3760 -1250 -3760 -1230 {
lab=vdd_pre}
N -4140 -1080 -4140 -1060 {
lab=GND}
N -3940 -1180 -3940 -1160 {
lab=vc13}
N -3940 -1210 -3930 -1210 {
lab=vdd_in}
N -3930 -1240 -3930 -1210 {
lab=vdd_in}
N -3940 -1240 -3930 -1240 {
lab=vdd_in}
N -4020 -1210 -3980 -1210 {
lab=#net57}
N -4060 -1240 -3940 -1240 {
lab=vdd_in}
N -4070 -1210 -4060 -1210 {
lab=vdd_in}
N -4070 -1240 -4070 -1210 {
lab=vdd_in}
N -4070 -1240 -4060 -1240 {
lab=vdd_in}
N -4060 -1180 -4060 -1160 {
lab=#net57}
N -4060 -1160 -4000 -1160 {
lab=#net57}
N -4000 -1210 -4000 -1160 {
lab=#net57}
N -4140 -1160 -4140 -1140 {
lab=#net58}
N -3620 -1160 -3610 -1160 {
lab=vpre13}
N -4080 -1160 -4060 -1160 {
lab=#net57}
N -3940 -1160 -3860 -1160 {
lab=vc13}
N -3860 -1200 -3850 -1200 {
lab=vlky}
N -3860 -1120 -3850 -1120 {
lab=vb_pre}
N -3860 -900 -3850 -900 {
lab=vlky}
N -3940 -860 -3860 -860 {
lab=vc14}
N -3860 -820 -3850 -820 {
lab=vb_pre}
N -3760 -490 -3760 -470 {
lab=GND}
N -3760 -650 -3760 -630 {
lab=vdd_pre}
N -4140 -480 -4140 -460 {
lab=GND}
N -3940 -580 -3940 -560 {
lab=vc15}
N -3940 -610 -3930 -610 {
lab=vdd_in}
N -3930 -640 -3930 -610 {
lab=vdd_in}
N -3940 -640 -3930 -640 {
lab=vdd_in}
N -4020 -610 -3980 -610 {
lab=#net59}
N -4060 -640 -3940 -640 {
lab=vdd_in}
N -4070 -610 -4060 -610 {
lab=vdd_in}
N -4070 -640 -4070 -610 {
lab=vdd_in}
N -4070 -640 -4060 -640 {
lab=vdd_in}
N -4060 -580 -4060 -560 {
lab=#net59}
N -4060 -560 -4000 -560 {
lab=#net59}
N -4000 -610 -4000 -560 {
lab=#net59}
N -4140 -560 -4140 -540 {
lab=#net60}
N -3620 -560 -3610 -560 {
lab=vpre15}
N -4080 -560 -4060 -560 {
lab=#net59}
N -3860 -600 -3850 -600 {
lab=vlky}
N -3940 -560 -3860 -560 {
lab=vc15}
N -3860 -520 -3850 -520 {
lab=vb_pre}
N -3450 -4790 -3440 -4790 {
lab=ctrl_inf}
N -3390 -4670 -3390 -4650 {
lab=vdd_wu}
N -3390 -4820 -3390 -4800 {
lab=vdd_inf}
N -3450 -4640 -3440 -4640 {
lab=ctrl_wu}
N -3440 -4640 -3440 -4610 {
lab=ctrl_wu}
N 180 -2340 180 -2320 {
lab=GND}
N 180 -2420 180 -2400 {
lab=ctrl_pos}
N -3390 -4270 -3390 -4260 {
lab=GND}
N -3340 -4310 -3330 -4310 {
lab=vpres2}
N -3390 -4420 -3390 -4410 {
lab=GND}
N -3340 -4460 -3330 -4460 {
lab=vpres2}
N -3450 -4280 -3440 -4280 {
lab=vb_wu}
N -3450 -4490 -3440 -4490 {
lab=ctrl_inf}
N -3390 -4370 -3390 -4350 {
lab=vdd_wu}
N -3390 -4520 -3390 -4500 {
lab=vdd_inf}
N -3450 -4340 -3440 -4340 {
lab=ctrl_wu}
N -3440 -4340 -3440 -4310 {
lab=ctrl_wu}
N -3390 -3970 -3390 -3960 {
lab=GND}
N -3340 -4010 -3330 -4010 {
lab=vpres3}
N -3390 -4120 -3390 -4110 {
lab=GND}
N -3450 -4160 -3440 -4160 {
lab=vpre3}
N -3340 -4160 -3330 -4160 {
lab=vpres3}
N -3450 -3980 -3440 -3980 {
lab=vb_wu}
N -3450 -4190 -3440 -4190 {
lab=ctrl_inf}
N -3390 -4070 -3390 -4050 {
lab=vdd_wu}
N -3390 -4220 -3390 -4200 {
lab=vdd_inf}
N -3450 -4040 -3440 -4040 {
lab=ctrl_wu}
N -3440 -4040 -3440 -4010 {
lab=ctrl_wu}
N -3390 -3670 -3390 -3660 {
lab=GND}
N -3340 -3710 -3330 -3710 {
lab=vpres4}
N -3390 -3820 -3390 -3810 {
lab=GND}
N -3450 -3860 -3440 -3860 {
lab=vpre4}
N -3340 -3860 -3330 -3860 {
lab=vpres4}
N -3450 -3680 -3440 -3680 {
lab=vb_wu}
N -3450 -3890 -3440 -3890 {
lab=ctrl_inf}
N -3390 -3770 -3390 -3750 {
lab=vdd_wu}
N -3390 -3920 -3390 -3900 {
lab=vdd_inf}
N -3450 -3740 -3440 -3740 {
lab=ctrl_wu}
N -3440 -3740 -3440 -3710 {
lab=ctrl_wu}
N -3390 -3370 -3390 -3360 {
lab=GND}
N -3340 -3410 -3330 -3410 {
lab=vpres5}
N -3390 -3520 -3390 -3510 {
lab=GND}
N -3450 -3560 -3440 -3560 {
lab=vpre5}
N -3340 -3560 -3330 -3560 {
lab=vpres5}
N -3450 -3380 -3440 -3380 {
lab=vb_wu}
N -3450 -3590 -3440 -3590 {
lab=ctrl_inf}
N -3390 -3470 -3390 -3450 {
lab=vdd_wu}
N -3390 -3620 -3390 -3600 {
lab=vdd_inf}
N -3450 -3440 -3440 -3440 {
lab=ctrl_wu}
N -3440 -3440 -3440 -3410 {
lab=ctrl_wu}
N -3390 -3070 -3390 -3060 {
lab=GND}
N -3340 -3110 -3330 -3110 {
lab=vpres6}
N -3390 -3220 -3390 -3210 {
lab=GND}
N -3450 -3260 -3440 -3260 {
lab=vpre6}
N -3340 -3260 -3330 -3260 {
lab=vpres6}
N -3450 -3080 -3440 -3080 {
lab=vb_wu}
N -3450 -3290 -3440 -3290 {
lab=ctrl_inf}
N -3390 -3170 -3390 -3150 {
lab=vdd_wu}
N -3390 -3320 -3390 -3300 {
lab=vdd_inf}
N -3450 -3140 -3440 -3140 {
lab=ctrl_wu}
N -3440 -3140 -3440 -3110 {
lab=ctrl_wu}
N -3390 -2770 -3390 -2760 {
lab=GND}
N -3340 -2810 -3330 -2810 {
lab=vpres7}
N -3390 -2920 -3390 -2910 {
lab=GND}
N -3450 -2960 -3440 -2960 {
lab=vpre7}
N -3340 -2960 -3330 -2960 {
lab=vpres7}
N -3450 -2780 -3440 -2780 {
lab=vb_wu}
N -3450 -2990 -3440 -2990 {
lab=ctrl_inf}
N -3390 -2870 -3390 -2850 {
lab=vdd_wu}
N -3390 -3020 -3390 -3000 {
lab=vdd_inf}
N -3450 -2840 -3440 -2840 {
lab=ctrl_wu}
N -3440 -2840 -3440 -2810 {
lab=ctrl_wu}
N -3390 -2470 -3390 -2460 {
lab=GND}
N -3340 -2510 -3330 -2510 {
lab=vpres8}
N -3390 -2620 -3390 -2610 {
lab=GND}
N -3450 -2660 -3440 -2660 {
lab=vpre8}
N -3340 -2660 -3330 -2660 {
lab=vpres8}
N -3450 -2480 -3440 -2480 {
lab=vb_wu}
N -3450 -2690 -3440 -2690 {
lab=ctrl_inf}
N -3390 -2570 -3390 -2550 {
lab=vdd_wu}
N -3390 -2720 -3390 -2700 {
lab=vdd_inf}
N -3450 -2540 -3440 -2540 {
lab=ctrl_wu}
N -3440 -2540 -3440 -2510 {
lab=ctrl_wu}
N -3390 -2170 -3390 -2160 {
lab=GND}
N -3340 -2210 -3330 -2210 {
lab=vpres9}
N -3390 -2320 -3390 -2310 {
lab=GND}
N -3450 -2360 -3440 -2360 {
lab=vpre9}
N -3340 -2360 -3330 -2360 {
lab=vpres9}
N -3450 -2180 -3440 -2180 {
lab=vb_wu}
N -3450 -2390 -3440 -2390 {
lab=ctrl_inf}
N -3390 -2270 -3390 -2250 {
lab=vdd_wu}
N -3390 -2420 -3390 -2400 {
lab=vdd_inf}
N -3450 -2240 -3440 -2240 {
lab=ctrl_wu}
N -3440 -2240 -3440 -2210 {
lab=ctrl_wu}
N -3390 -1870 -3390 -1860 {
lab=GND}
N -3340 -1910 -3330 -1910 {
lab=vpres10}
N -3390 -2020 -3390 -2010 {
lab=GND}
N -3450 -2060 -3440 -2060 {
lab=vpre10}
N -3340 -2060 -3330 -2060 {
lab=vpres10}
N -3450 -1880 -3440 -1880 {
lab=vb_wu}
N -3450 -2090 -3440 -2090 {
lab=ctrl_inf}
N -3390 -1970 -3390 -1950 {
lab=vdd_wu}
N -3390 -2120 -3390 -2100 {
lab=vdd_inf}
N -3450 -1940 -3440 -1940 {
lab=ctrl_wu}
N -3440 -1940 -3440 -1910 {
lab=ctrl_wu}
N -3390 -1570 -3390 -1560 {
lab=GND}
N -3340 -1610 -3330 -1610 {
lab=vpres11}
N -3390 -1720 -3390 -1710 {
lab=GND}
N -3450 -1760 -3440 -1760 {
lab=vpre11}
N -3340 -1760 -3330 -1760 {
lab=vpres11}
N -3450 -1580 -3440 -1580 {
lab=vb_wu}
N -3450 -1790 -3440 -1790 {
lab=ctrl_inf}
N -3390 -1670 -3390 -1650 {
lab=vdd_wu}
N -3390 -1820 -3390 -1800 {
lab=vdd_inf}
N -3450 -1640 -3440 -1640 {
lab=ctrl_wu}
N -3440 -1640 -3440 -1610 {
lab=ctrl_wu}
N -3390 -1270 -3390 -1260 {
lab=GND}
N -3340 -1310 -3330 -1310 {
lab=vpres12}
N -3390 -1420 -3390 -1410 {
lab=GND}
N -3450 -1460 -3440 -1460 {
lab=vpre12}
N -3340 -1460 -3330 -1460 {
lab=vpres12}
N -3450 -1280 -3440 -1280 {
lab=vb_wu}
N -3450 -1490 -3440 -1490 {
lab=ctrl_inf}
N -3390 -1370 -3390 -1350 {
lab=vdd_wu}
N -3390 -1520 -3390 -1500 {
lab=vdd_inf}
N -3450 -1340 -3440 -1340 {
lab=ctrl_wu}
N -3440 -1340 -3440 -1310 {
lab=ctrl_wu}
N -3390 -970 -3390 -960 {
lab=GND}
N -3340 -1010 -3330 -1010 {
lab=vpres13}
N -3390 -1120 -3390 -1110 {
lab=GND}
N -3450 -1160 -3440 -1160 {
lab=vpre13}
N -3340 -1160 -3330 -1160 {
lab=vpres13}
N -3450 -980 -3440 -980 {
lab=vb_wu}
N -3450 -1190 -3440 -1190 {
lab=ctrl_inf}
N -3390 -1070 -3390 -1050 {
lab=vdd_wu}
N -3390 -1220 -3390 -1200 {
lab=vdd_inf}
N -3450 -1040 -3440 -1040 {
lab=ctrl_wu}
N -3440 -1040 -3440 -1010 {
lab=ctrl_wu}
N -3390 -670 -3390 -660 {
lab=GND}
N -3340 -710 -3330 -710 {
lab=vpres14}
N -3390 -820 -3390 -810 {
lab=GND}
N -3450 -860 -3440 -860 {
lab=vpre14}
N -3450 -680 -3440 -680 {
lab=vb_wu}
N -3450 -890 -3440 -890 {
lab=ctrl_inf}
N -3390 -770 -3390 -750 {
lab=vdd_wu}
N -3390 -920 -3390 -900 {
lab=vdd_inf}
N -3450 -740 -3440 -740 {
lab=ctrl_wu}
N -3440 -740 -3440 -710 {
lab=ctrl_wu}
N -3390 -370 -3390 -360 {
lab=GND}
N -3340 -410 -3330 -410 {
lab=vpres15}
N -3390 -520 -3390 -510 {
lab=GND}
N -3450 -380 -3440 -380 {
lab=vb_wu}
N -3450 -590 -3440 -590 {
lab=ctrl_inf}
N -3390 -470 -3390 -450 {
lab=vdd_wu}
N -3390 -620 -3390 -600 {
lab=vdd_inf}
N -3450 -440 -3440 -440 {
lab=ctrl_wu}
N -3440 -440 -3440 -410 {
lab=ctrl_wu}
N -3450 -4760 -3440 -4760 {
lab=vpre1}
N -3450 -4460 -3440 -4460 {
lab=vpre2}
N -3450 -560 -3440 -560 {
lab=vpre15}
N -3340 -560 -3330 -560 {
lab=vpres15}
N -3150 -560 -3140 -560 {
lab=vpres15}
N -3150 -860 -3140 -860 {
lab=vpres14}
N -3020 -860 -3010 -860 {
lab=b_px}
N -3340 -860 -3330 -860 {
lab=vpres14}
N 440 -2620 440 -2600 {
lab=GND}
N 440 -2700 440 -2680 {
lab=vdd_inf}
N -2700 -270 -2700 -260 {
lab=#net61}
N -2700 -340 -2700 -330 {
lab=p1}
N -2700 -20 -2700 -10 {
lab=1}
N -2770 -160 -2770 -140 {
lab=GND}
N -2630 -160 -2630 -140 {
lab=vdd_pos}
N -2770 -260 -2770 -250 {
lab=inh1}
N -2740 -260 -2740 -250 {
lab=vb_pos}
N -2660 -260 -2660 -250 {
lab=vlky}
N -2380 -270 -2380 -260 {
lab=#net62}
N -2380 -340 -2380 -330 {
lab=p2}
N -2380 -20 -2380 -10 {
lab=2}
N -2450 -160 -2450 -140 {
lab=GND}
N -2310 -160 -2310 -140 {
lab=vdd_pos}
N -2450 -260 -2450 -250 {
lab=inh2}
N -2420 -260 -2420 -250 {
lab=vb_pos}
N -2340 -260 -2340 -250 {
lab=vlky}
N -2060 -270 -2060 -260 {
lab=#net63}
N -2060 -340 -2060 -330 {
lab=p3}
N -2060 -20 -2060 -10 {
lab=3}
N -2130 -160 -2130 -140 {
lab=GND}
N -1990 -160 -1990 -140 {
lab=vdd_pos}
N -2130 -260 -2130 -250 {
lab=inh3}
N -2100 -260 -2100 -250 {
lab=vb_pos}
N -2020 -260 -2020 -250 {
lab=vlky}
N -1740 -270 -1740 -260 {
lab=#net64}
N -1740 -340 -1740 -330 {
lab=p4}
N -1740 -20 -1740 -10 {
lab=4}
N -1810 -160 -1810 -140 {
lab=GND}
N -1670 -160 -1670 -140 {
lab=vdd_pos}
N -1810 -260 -1810 -250 {
lab=inh4}
N -1780 -260 -1780 -250 {
lab=vb_pos}
N -1700 -260 -1700 -250 {
lab=vlky}
N -1420 -270 -1420 -260 {
lab=#net65}
N -1420 -340 -1420 -330 {
lab=p5}
N -1420 -20 -1420 -10 {
lab=5}
N -1490 -160 -1490 -140 {
lab=GND}
N -1350 -160 -1350 -140 {
lab=vdd_pos}
N -1490 -260 -1490 -250 {
lab=inh5}
N -1460 -260 -1460 -250 {
lab=vb_pos}
N -1380 -260 -1380 -250 {
lab=vlky}
N -1100 -270 -1100 -260 {
lab=#net66}
N -1100 -340 -1100 -330 {
lab=p6}
N -1100 -20 -1100 -10 {
lab=6}
N -1170 -160 -1170 -140 {
lab=GND}
N -1030 -160 -1030 -140 {
lab=vdd_pos}
N -1170 -260 -1170 -250 {
lab=inh6}
N -1140 -260 -1140 -250 {
lab=vb_pos}
N -1060 -260 -1060 -250 {
lab=vlky}
N -780 -270 -780 -260 {
lab=#net67}
N -780 -340 -780 -330 {
lab=p7}
N -780 -20 -780 -10 {
lab=7}
N -850 -160 -850 -140 {
lab=GND}
N -710 -160 -710 -140 {
lab=vdd_pos}
N -850 -260 -850 -250 {
lab=inh7}
N -820 -260 -820 -250 {
lab=vb_pos}
N -740 -260 -740 -250 {
lab=vlky}
N -460 -270 -460 -260 {
lab=#net68}
N -460 -340 -460 -330 {
lab=p8}
N -460 -20 -460 -10 {
lab=8}
N -530 -160 -530 -140 {
lab=GND}
N -390 -160 -390 -140 {
lab=vdd_pos}
N -530 -260 -530 -250 {
lab=inh8}
N -500 -260 -500 -250 {
lab=vb_pos}
N -420 -260 -420 -250 {
lab=vlky}
N -140 -270 -140 -260 {
lab=#net69}
N -140 -340 -140 -330 {
lab=p9}
N -140 -20 -140 -10 {
lab=9}
N -210 -160 -210 -140 {
lab=GND}
N -70 -160 -70 -140 {
lab=vdd_pos}
N -210 -260 -210 -250 {
lab=inh9}
N -180 -260 -180 -250 {
lab=vb_pos}
N -100 -260 -100 -250 {
lab=vlky}
N -2760 -4700 -2760 -4690 {
lab=GND}
N -2760 -4810 -2760 -4800 {
lab=vdd_syn1}
N -2700 -4620 -2690 -4620 {
lab=GND}
N -2700 -4590 -2700 -4580 {
lab=p1}
N -2830 -4760 -2820 -4760 {
lab=vpres1}
N -2700 -4760 -2690 -4760 {
lab=w_px}
N -2750 -4620 -2740 -4620 {
lab=ctrl_pos}
N -2700 -4740 -2700 -4720 {
lab=#net70}
N -2700 -4660 -2700 -4650 {
lab=#net71}
N 150 -3900 160 -3900 {
lab=inh2}
N 120 -3910 120 -3900 {
lab=GND}
N 120 -3860 120 -3850 {
lab=inh_d}
N 80 -3900 90 -3900 {
lab=ctrl_vinh}
N 150 -3760 160 -3760 {
lab=inh3}
N 120 -3770 120 -3760 {
lab=GND}
N 120 -3720 120 -3710 {
lab=inh_d}
N 80 -3760 90 -3760 {
lab=ctrl_vinh}
N 150 -3620 160 -3620 {
lab=inh4}
N 120 -3630 120 -3620 {
lab=GND}
N 120 -3580 120 -3570 {
lab=inh_d}
N 80 -3620 90 -3620 {
lab=ctrl_vinh}
N 150 -3480 160 -3480 {
lab=inh5}
N 120 -3490 120 -3480 {
lab=GND}
N 120 -3440 120 -3430 {
lab=inh_d}
N 80 -3480 90 -3480 {
lab=ctrl_vinh}
N 150 -3340 160 -3340 {
lab=inh6}
N 120 -3350 120 -3340 {
lab=GND}
N 120 -3300 120 -3290 {
lab=inh_d}
N 80 -3340 90 -3340 {
lab=ctrl_vinh}
N 150 -3200 160 -3200 {
lab=inh7}
N 120 -3210 120 -3200 {
lab=GND}
N 120 -3160 120 -3150 {
lab=inh_d}
N 80 -3200 90 -3200 {
lab=ctrl_vinh}
N 150 -3060 160 -3060 {
lab=inh8}
N 120 -3070 120 -3060 {
lab=GND}
N 120 -3020 120 -3010 {
lab=inh_d}
N 80 -3060 90 -3060 {
lab=ctrl_vinh}
N 150 -2920 160 -2920 {
lab=inh9}
N 120 -2930 120 -2920 {
lab=GND}
N 120 -2880 120 -2870 {
lab=inh_d}
N 80 -2920 90 -2920 {
lab=ctrl_vinh}
N -2440 -4700 -2440 -4690 {
lab=GND}
N -2440 -4810 -2440 -4800 {
lab=vdd_syn2}
N -2380 -4620 -2370 -4620 {
lab=GND}
N -2380 -4590 -2380 -4580 {
lab=p2}
N -2510 -4760 -2500 -4760 {
lab=vpres1}
N -2380 -4760 -2370 -4760 {
lab=b_px}
N -2430 -4620 -2420 -4620 {
lab=ctrl_pos}
N -2380 -4740 -2380 -4720 {
lab=#net72}
N -2380 -4660 -2380 -4650 {
lab=#net73}
N -2120 -4700 -2120 -4690 {
lab=GND}
N -2120 -4810 -2120 -4800 {
lab=vdd_syn3}
N -2060 -4620 -2050 -4620 {
lab=GND}
N -2060 -4590 -2060 -4580 {
lab=p3}
N -2190 -4760 -2180 -4760 {
lab=vpres1}
N -2060 -4760 -2050 -4760 {
lab=b_px}
N -2110 -4620 -2100 -4620 {
lab=ctrl_pos}
N -2060 -4740 -2060 -4720 {
lab=#net74}
N -2060 -4660 -2060 -4650 {
lab=#net75}
N -1800 -4700 -1800 -4690 {
lab=GND}
N -1800 -4810 -1800 -4800 {
lab=vdd_syn4}
N -1740 -4620 -1730 -4620 {
lab=GND}
N -1740 -4590 -1740 -4580 {
lab=p4}
N -1870 -4760 -1860 -4760 {
lab=vpres1}
N -1740 -4760 -1730 -4760 {
lab=b_px}
N -1790 -4620 -1780 -4620 {
lab=ctrl_pos}
N -1740 -4740 -1740 -4720 {
lab=#net76}
N -1740 -4660 -1740 -4650 {
lab=#net77}
N -1480 -4700 -1480 -4690 {
lab=GND}
N -1480 -4810 -1480 -4800 {
lab=vdd_syn5}
N -1420 -4620 -1410 -4620 {
lab=GND}
N -1420 -4590 -1420 -4580 {
lab=p5}
N -1550 -4760 -1540 -4760 {
lab=vpres1}
N -1420 -4760 -1410 -4760 {
lab=b_px}
N -1470 -4620 -1460 -4620 {
lab=ctrl_pos}
N -1420 -4740 -1420 -4720 {
lab=#net78}
N -1420 -4660 -1420 -4650 {
lab=#net79}
N -1160 -4700 -1160 -4690 {
lab=GND}
N -1160 -4810 -1160 -4800 {
lab=vdd_syn6}
N -1100 -4620 -1090 -4620 {
lab=GND}
N -1100 -4590 -1100 -4580 {
lab=p6}
N -1230 -4760 -1220 -4760 {
lab=vpres1}
N -1100 -4760 -1090 -4760 {
lab=w_px}
N -1150 -4620 -1140 -4620 {
lab=ctrl_pos}
N -1100 -4740 -1100 -4720 {
lab=#net80}
N -1100 -4660 -1100 -4650 {
lab=#net81}
N -840 -4700 -840 -4690 {
lab=GND}
N -840 -4810 -840 -4800 {
lab=vdd_syn7}
N -780 -4620 -770 -4620 {
lab=GND}
N -780 -4590 -780 -4580 {
lab=p7}
N -910 -4760 -900 -4760 {
lab=vpres1}
N -780 -4760 -770 -4760 {
lab=b_px}
N -830 -4620 -820 -4620 {
lab=ctrl_pos}
N -780 -4740 -780 -4720 {
lab=#net82}
N -780 -4660 -780 -4650 {
lab=#net83}
N -520 -4700 -520 -4690 {
lab=GND}
N -520 -4810 -520 -4800 {
lab=vdd_syn8}
N -460 -4620 -450 -4620 {
lab=GND}
N -460 -4590 -460 -4580 {
lab=p8}
N -590 -4760 -580 -4760 {
lab=vpres1}
N -460 -4760 -450 -4760 {
lab=w_px}
N -510 -4620 -500 -4620 {
lab=ctrl_pos}
N -460 -4740 -460 -4720 {
lab=#net84}
N -460 -4660 -460 -4650 {
lab=#net85}
N -200 -4700 -200 -4690 {
lab=GND}
N -200 -4810 -200 -4800 {
lab=vdd_syn9}
N -140 -4620 -130 -4620 {
lab=GND}
N -140 -4590 -140 -4580 {
lab=p9}
N -270 -4760 -260 -4760 {
lab=vpres1}
N -140 -4760 -130 -4760 {
lab=w_px}
N -190 -4620 -180 -4620 {
lab=ctrl_pos}
N -140 -4740 -140 -4720 {
lab=#net86}
N -140 -4660 -140 -4650 {
lab=#net87}
N -2760 -4400 -2760 -4390 {
lab=GND}
N -2760 -4510 -2760 -4500 {
lab=vdd_syn1}
N -2700 -4320 -2690 -4320 {
lab=GND}
N -2700 -4290 -2700 -4280 {
lab=p1}
N -2830 -4460 -2820 -4460 {
lab=vpres2}
N -2700 -4460 -2690 -4460 {
lab=b_px}
N -2750 -4320 -2740 -4320 {
lab=ctrl_pos}
N -2700 -4440 -2700 -4420 {
lab=#net88}
N -2700 -4360 -2700 -4350 {
lab=#net89}
N -2440 -4400 -2440 -4390 {
lab=GND}
N -2440 -4510 -2440 -4500 {
lab=vdd_syn2}
N -2380 -4320 -2370 -4320 {
lab=GND}
N -2380 -4290 -2380 -4280 {
lab=p2}
N -2510 -4460 -2500 -4460 {
lab=vpres2}
N -2380 -4460 -2370 -4460 {
lab=b_px}
N -2430 -4320 -2420 -4320 {
lab=ctrl_pos}
N -2380 -4440 -2380 -4420 {
lab=#net90}
N -2380 -4360 -2380 -4350 {
lab=#net91}
N -2120 -4400 -2120 -4390 {
lab=GND}
N -2120 -4510 -2120 -4500 {
lab=vdd_syn3}
N -2060 -4320 -2050 -4320 {
lab=GND}
N -2060 -4290 -2060 -4280 {
lab=p3}
N -2190 -4460 -2180 -4460 {
lab=vpres2}
N -2060 -4460 -2050 -4460 {
lab=b_px}
N -2110 -4320 -2100 -4320 {
lab=ctrl_pos}
N -2060 -4440 -2060 -4420 {
lab=#net92}
N -2060 -4360 -2060 -4350 {
lab=#net93}
N -1800 -4400 -1800 -4390 {
lab=GND}
N -1800 -4510 -1800 -4500 {
lab=vdd_syn4}
N -1740 -4320 -1730 -4320 {
lab=GND}
N -1740 -4290 -1740 -4280 {
lab=p4}
N -1870 -4460 -1860 -4460 {
lab=vpres2}
N -1740 -4460 -1730 -4460 {
lab=w_px}
N -1790 -4320 -1780 -4320 {
lab=ctrl_pos}
N -1740 -4440 -1740 -4420 {
lab=#net94}
N -1740 -4360 -1740 -4350 {
lab=#net95}
N -1480 -4400 -1480 -4390 {
lab=GND}
N -1480 -4510 -1480 -4500 {
lab=vdd_syn5}
N -1420 -4320 -1410 -4320 {
lab=GND}
N -1420 -4290 -1420 -4280 {
lab=p5}
N -1550 -4460 -1540 -4460 {
lab=vpres2}
N -1420 -4460 -1410 -4460 {
lab=b_px}
N -1470 -4320 -1460 -4320 {
lab=ctrl_pos}
N -1420 -4440 -1420 -4420 {
lab=#net96}
N -1420 -4360 -1420 -4350 {
lab=#net97}
N -1160 -4400 -1160 -4390 {
lab=GND}
N -1160 -4510 -1160 -4500 {
lab=vdd_syn6}
N -1100 -4320 -1090 -4320 {
lab=GND}
N -1100 -4290 -1100 -4280 {
lab=p6}
N -1230 -4460 -1220 -4460 {
lab=vpres2}
N -1100 -4460 -1090 -4460 {
lab=b_px}
N -1150 -4320 -1140 -4320 {
lab=ctrl_pos}
N -1100 -4440 -1100 -4420 {
lab=#net98}
N -1100 -4360 -1100 -4350 {
lab=#net99}
N -840 -4400 -840 -4390 {
lab=GND}
N -840 -4510 -840 -4500 {
lab=vdd_syn7}
N -780 -4320 -770 -4320 {
lab=GND}
N -780 -4290 -780 -4280 {
lab=p7}
N -910 -4460 -900 -4460 {
lab=vpres2}
N -780 -4460 -770 -4460 {
lab=b_px}
N -830 -4320 -820 -4320 {
lab=ctrl_pos}
N -780 -4440 -780 -4420 {
lab=#net100}
N -780 -4360 -780 -4350 {
lab=#net101}
N -520 -4400 -520 -4390 {
lab=GND}
N -520 -4510 -520 -4500 {
lab=vdd_syn8}
N -460 -4320 -450 -4320 {
lab=GND}
N -460 -4290 -460 -4280 {
lab=p8}
N -590 -4460 -580 -4460 {
lab=vpres2}
N -460 -4460 -450 -4460 {
lab=b_px}
N -510 -4320 -500 -4320 {
lab=ctrl_pos}
N -460 -4440 -460 -4420 {
lab=#net102}
N -460 -4360 -460 -4350 {
lab=#net103}
N -200 -4400 -200 -4390 {
lab=GND}
N -200 -4510 -200 -4500 {
lab=vdd_syn9}
N -140 -4320 -130 -4320 {
lab=GND}
N -140 -4290 -140 -4280 {
lab=p9}
N -270 -4460 -260 -4460 {
lab=vpres2}
N -140 -4460 -130 -4460 {
lab=b_px}
N -190 -4320 -180 -4320 {
lab=ctrl_pos}
N -140 -4440 -140 -4420 {
lab=#net104}
N -140 -4360 -140 -4350 {
lab=#net105}
N -2760 -4100 -2760 -4090 {
lab=GND}
N -2760 -4210 -2760 -4200 {
lab=vdd_syn1}
N -2700 -4020 -2690 -4020 {
lab=GND}
N -2700 -3990 -2700 -3980 {
lab=p1}
N -2830 -4160 -2820 -4160 {
lab=vpres3}
N -2700 -4160 -2690 -4160 {
lab=w_px}
N -2750 -4020 -2740 -4020 {
lab=ctrl_pos}
N -2700 -4140 -2700 -4120 {
lab=#net106}
N -2700 -4060 -2700 -4050 {
lab=#net107}
N -2440 -4100 -2440 -4090 {
lab=GND}
N -2440 -4210 -2440 -4200 {
lab=vdd_syn2}
N -2380 -4020 -2370 -4020 {
lab=GND}
N -2380 -3990 -2380 -3980 {
lab=p2}
N -2510 -4160 -2500 -4160 {
lab=vpres3}
N -2380 -4160 -2370 -4160 {
lab=w_px}
N -2430 -4020 -2420 -4020 {
lab=ctrl_pos}
N -2380 -4140 -2380 -4120 {
lab=#net108}
N -2380 -4060 -2380 -4050 {
lab=#net109}
N -2120 -4100 -2120 -4090 {
lab=GND}
N -2120 -4210 -2120 -4200 {
lab=vdd_syn3}
N -2060 -4020 -2050 -4020 {
lab=GND}
N -2060 -3990 -2060 -3980 {
lab=p3}
N -2190 -4160 -2180 -4160 {
lab=vpres3}
N -2060 -4160 -2050 -4160 {
lab=w_px}
N -2110 -4020 -2100 -4020 {
lab=ctrl_pos}
N -2060 -4140 -2060 -4120 {
lab=#net110}
N -2060 -4060 -2060 -4050 {
lab=#net111}
N -1800 -4100 -1800 -4090 {
lab=GND}
N -1800 -4210 -1800 -4200 {
lab=vdd_syn4}
N -1740 -4020 -1730 -4020 {
lab=GND}
N -1740 -3990 -1740 -3980 {
lab=p4}
N -1870 -4160 -1860 -4160 {
lab=vpres3}
N -1740 -4160 -1730 -4160 {
lab=b_px}
N -1790 -4020 -1780 -4020 {
lab=ctrl_pos}
N -1740 -4140 -1740 -4120 {
lab=#net112}
N -1740 -4060 -1740 -4050 {
lab=#net113}
N -1480 -4100 -1480 -4090 {
lab=GND}
N -1480 -4210 -1480 -4200 {
lab=vdd_syn5}
N -1420 -4020 -1410 -4020 {
lab=GND}
N -1420 -3990 -1420 -3980 {
lab=p5}
N -1550 -4160 -1540 -4160 {
lab=vpres3}
N -1420 -4160 -1410 -4160 {
lab=b_px}
N -1470 -4020 -1460 -4020 {
lab=ctrl_pos}
N -1420 -4140 -1420 -4120 {
lab=#net114}
N -1420 -4060 -1420 -4050 {
lab=#net115}
N -1160 -4100 -1160 -4090 {
lab=GND}
N -1160 -4210 -1160 -4200 {
lab=vdd_syn6}
N -1100 -4020 -1090 -4020 {
lab=GND}
N -1100 -3990 -1100 -3980 {
lab=p6}
N -1230 -4160 -1220 -4160 {
lab=vpres3}
N -1100 -4160 -1090 -4160 {
lab=b_px}
N -1150 -4020 -1140 -4020 {
lab=ctrl_pos}
N -1100 -4140 -1100 -4120 {
lab=#net116}
N -1100 -4060 -1100 -4050 {
lab=#net117}
N -840 -4100 -840 -4090 {
lab=GND}
N -840 -4210 -840 -4200 {
lab=vdd_syn7}
N -780 -4020 -770 -4020 {
lab=GND}
N -780 -3990 -780 -3980 {
lab=p7}
N -910 -4160 -900 -4160 {
lab=vpres3}
N -780 -4160 -770 -4160 {
lab=b_px}
N -830 -4020 -820 -4020 {
lab=ctrl_pos}
N -780 -4140 -780 -4120 {
lab=#net118}
N -780 -4060 -780 -4050 {
lab=#net119}
N -520 -4100 -520 -4090 {
lab=GND}
N -520 -4210 -520 -4200 {
lab=vdd_syn8}
N -460 -4020 -450 -4020 {
lab=GND}
N -460 -3990 -460 -3980 {
lab=p8}
N -590 -4160 -580 -4160 {
lab=vpres3}
N -460 -4160 -450 -4160 {
lab=w_px}
N -510 -4020 -500 -4020 {
lab=ctrl_pos}
N -460 -4140 -460 -4120 {
lab=#net120}
N -460 -4060 -460 -4050 {
lab=#net121}
N -200 -4100 -200 -4090 {
lab=GND}
N -200 -4210 -200 -4200 {
lab=vdd_syn9}
N -140 -4020 -130 -4020 {
lab=GND}
N -140 -3990 -140 -3980 {
lab=p9}
N -270 -4160 -260 -4160 {
lab=vpres3}
N -140 -4160 -130 -4160 {
lab=w_px}
N -190 -4020 -180 -4020 {
lab=ctrl_pos}
N -140 -4140 -140 -4120 {
lab=#net122}
N -140 -4060 -140 -4050 {
lab=#net123}
N -2760 -3800 -2760 -3790 {
lab=GND}
N -2760 -3910 -2760 -3900 {
lab=vdd_syn1}
N -2700 -3720 -2690 -3720 {
lab=GND}
N -2700 -3690 -2700 -3680 {
lab=p1}
N -2830 -3860 -2820 -3860 {
lab=vpres4}
N -2700 -3860 -2690 -3860 {
lab=b_px}
N -2750 -3720 -2740 -3720 {
lab=ctrl_pos}
N -2700 -3840 -2700 -3820 {
lab=#net124}
N -2700 -3760 -2700 -3750 {
lab=#net125}
N -2440 -3800 -2440 -3790 {
lab=GND}
N -2440 -3910 -2440 -3900 {
lab=vdd_syn2}
N -2380 -3720 -2370 -3720 {
lab=GND}
N -2380 -3690 -2380 -3680 {
lab=p2}
N -2510 -3860 -2500 -3860 {
lab=vpres4}
N -2380 -3860 -2370 -3860 {
lab=w_px}
N -2430 -3720 -2420 -3720 {
lab=ctrl_pos}
N -2380 -3840 -2380 -3820 {
lab=#net126}
N -2380 -3760 -2380 -3750 {
lab=#net127}
N -2120 -3800 -2120 -3790 {
lab=GND}
N -2120 -3910 -2120 -3900 {
lab=vdd_syn3}
N -2060 -3720 -2050 -3720 {
lab=GND}
N -2060 -3690 -2060 -3680 {
lab=p3}
N -2190 -3860 -2180 -3860 {
lab=vpres4}
N -2060 -3860 -2050 -3860 {
lab=w_px}
N -2110 -3720 -2100 -3720 {
lab=ctrl_pos}
N -2060 -3840 -2060 -3820 {
lab=#net128}
N -2060 -3760 -2060 -3750 {
lab=#net129}
N -1800 -3800 -1800 -3790 {
lab=GND}
N -1800 -3910 -1800 -3900 {
lab=vdd_syn4}
N -1740 -3720 -1730 -3720 {
lab=GND}
N -1740 -3690 -1740 -3680 {
lab=p4}
N -1870 -3860 -1860 -3860 {
lab=vpres4}
N -1740 -3860 -1730 -3860 {
lab=b_px}
N -1790 -3720 -1780 -3720 {
lab=ctrl_pos}
N -1740 -3840 -1740 -3820 {
lab=#net130}
N -1740 -3760 -1740 -3750 {
lab=#net131}
N -1480 -3800 -1480 -3790 {
lab=GND}
N -1480 -3910 -1480 -3900 {
lab=vdd_syn5}
N -1420 -3720 -1410 -3720 {
lab=GND}
N -1420 -3690 -1420 -3680 {
lab=p5}
N -1550 -3860 -1540 -3860 {
lab=vpres4}
N -1420 -3860 -1410 -3860 {
lab=b_px}
N -1470 -3720 -1460 -3720 {
lab=ctrl_pos}
N -1420 -3840 -1420 -3820 {
lab=#net132}
N -1420 -3760 -1420 -3750 {
lab=#net133}
N -1160 -3800 -1160 -3790 {
lab=GND}
N -1160 -3910 -1160 -3900 {
lab=vdd_syn6}
N -1100 -3720 -1090 -3720 {
lab=GND}
N -1100 -3690 -1100 -3680 {
lab=p6}
N -1230 -3860 -1220 -3860 {
lab=vpres4}
N -1100 -3860 -1090 -3860 {
lab=b_px}
N -1150 -3720 -1140 -3720 {
lab=ctrl_pos}
N -1100 -3840 -1100 -3820 {
lab=#net134}
N -1100 -3760 -1100 -3750 {
lab=#net135}
N -840 -3800 -840 -3790 {
lab=GND}
N -840 -3910 -840 -3900 {
lab=vdd_syn7}
N -780 -3720 -770 -3720 {
lab=GND}
N -780 -3690 -780 -3680 {
lab=p7}
N -910 -3860 -900 -3860 {
lab=vpres4}
N -780 -3860 -770 -3860 {
lab=w_px}
N -830 -3720 -820 -3720 {
lab=ctrl_pos}
N -780 -3840 -780 -3820 {
lab=#net136}
N -780 -3760 -780 -3750 {
lab=#net137}
N -520 -3800 -520 -3790 {
lab=GND}
N -520 -3910 -520 -3900 {
lab=vdd_syn8}
N -460 -3720 -450 -3720 {
lab=GND}
N -460 -3690 -460 -3680 {
lab=p8}
N -590 -3860 -580 -3860 {
lab=vpres4}
N -460 -3860 -450 -3860 {
lab=b_px}
N -510 -3720 -500 -3720 {
lab=ctrl_pos}
N -460 -3840 -460 -3820 {
lab=#net138}
N -460 -3760 -460 -3750 {
lab=#net139}
N -200 -3800 -200 -3790 {
lab=GND}
N -200 -3910 -200 -3900 {
lab=vdd_syn9}
N -140 -3720 -130 -3720 {
lab=GND}
N -140 -3690 -140 -3680 {
lab=p9}
N -270 -3860 -260 -3860 {
lab=vpres4}
N -140 -3860 -130 -3860 {
lab=b_px}
N -190 -3720 -180 -3720 {
lab=ctrl_pos}
N -140 -3840 -140 -3820 {
lab=#net140}
N -140 -3760 -140 -3750 {
lab=#net141}
N -2760 -3500 -2760 -3490 {
lab=GND}
N -2760 -3610 -2760 -3600 {
lab=vdd_syn1}
N -2700 -3420 -2690 -3420 {
lab=GND}
N -2700 -3390 -2700 -3380 {
lab=p1}
N -2830 -3560 -2820 -3560 {
lab=vpres5}
N -2700 -3560 -2690 -3560 {
lab=b_px}
N -2750 -3420 -2740 -3420 {
lab=ctrl_pos}
N -2700 -3540 -2700 -3520 {
lab=#net142}
N -2700 -3460 -2700 -3450 {
lab=#net143}
N -2440 -3500 -2440 -3490 {
lab=GND}
N -2440 -3610 -2440 -3600 {
lab=vdd_syn2}
N -2380 -3420 -2370 -3420 {
lab=GND}
N -2380 -3390 -2380 -3380 {
lab=p2}
N -2510 -3560 -2500 -3560 {
lab=vpres5}
N -2380 -3560 -2370 -3560 {
lab=w_px}
N -2430 -3420 -2420 -3420 {
lab=ctrl_pos}
N -2380 -3540 -2380 -3520 {
lab=#net144}
N -2380 -3460 -2380 -3450 {
lab=#net145}
N -2120 -3500 -2120 -3490 {
lab=GND}
N -2120 -3610 -2120 -3600 {
lab=vdd_syn3}
N -2060 -3420 -2050 -3420 {
lab=GND}
N -2060 -3390 -2060 -3380 {
lab=p3}
N -2190 -3560 -2180 -3560 {
lab=vpres5}
N -2060 -3560 -2050 -3560 {
lab=w_px}
N -2110 -3420 -2100 -3420 {
lab=ctrl_pos}
N -2060 -3540 -2060 -3520 {
lab=#net146}
N -2060 -3460 -2060 -3450 {
lab=#net147}
N -1800 -3500 -1800 -3490 {
lab=GND}
N -1800 -3610 -1800 -3600 {
lab=vdd_syn4}
N -1740 -3420 -1730 -3420 {
lab=GND}
N -1740 -3390 -1740 -3380 {
lab=p4}
N -1870 -3560 -1860 -3560 {
lab=vpres5}
N -1740 -3560 -1730 -3560 {
lab=w_px}
N -1790 -3420 -1780 -3420 {
lab=ctrl_pos}
N -1740 -3540 -1740 -3520 {
lab=#net148}
N -1740 -3460 -1740 -3450 {
lab=#net149}
N -1480 -3500 -1480 -3490 {
lab=GND}
N -1480 -3610 -1480 -3600 {
lab=vdd_syn5}
N -1420 -3420 -1410 -3420 {
lab=GND}
N -1420 -3390 -1420 -3380 {
lab=p5}
N -1550 -3560 -1540 -3560 {
lab=vpres5}
N -1420 -3560 -1410 -3560 {
lab=w_px}
N -1470 -3420 -1460 -3420 {
lab=ctrl_pos}
N -1420 -3540 -1420 -3520 {
lab=#net150}
N -1420 -3460 -1420 -3450 {
lab=#net151}
N -1160 -3500 -1160 -3490 {
lab=GND}
N -1160 -3610 -1160 -3600 {
lab=vdd_syn6}
N -1100 -3420 -1090 -3420 {
lab=GND}
N -1100 -3390 -1100 -3380 {
lab=p6}
N -1230 -3560 -1220 -3560 {
lab=vpres5}
N -1100 -3560 -1090 -3560 {
lab=w_px}
N -1150 -3420 -1140 -3420 {
lab=ctrl_pos}
N -1100 -3540 -1100 -3520 {
lab=#net152}
N -1100 -3460 -1100 -3450 {
lab=#net153}
N -840 -3500 -840 -3490 {
lab=GND}
N -840 -3610 -840 -3600 {
lab=vdd_syn7}
N -780 -3420 -770 -3420 {
lab=GND}
N -780 -3390 -780 -3380 {
lab=p7}
N -910 -3560 -900 -3560 {
lab=vpres5}
N -780 -3560 -770 -3560 {
lab=w_px}
N -830 -3420 -820 -3420 {
lab=ctrl_pos}
N -780 -3540 -780 -3520 {
lab=#net154}
N -780 -3460 -780 -3450 {
lab=#net155}
N -520 -3500 -520 -3490 {
lab=GND}
N -520 -3610 -520 -3600 {
lab=vdd_syn8}
N -460 -3420 -450 -3420 {
lab=GND}
N -460 -3390 -460 -3380 {
lab=p8}
N -590 -3560 -580 -3560 {
lab=vpres5}
N -460 -3560 -450 -3560 {
lab=w_px}
N -510 -3420 -500 -3420 {
lab=ctrl_pos}
N -460 -3540 -460 -3520 {
lab=#net156}
N -460 -3460 -460 -3450 {
lab=#net157}
N -200 -3500 -200 -3490 {
lab=GND}
N -200 -3610 -200 -3600 {
lab=vdd_syn9}
N -140 -3420 -130 -3420 {
lab=GND}
N -140 -3390 -140 -3380 {
lab=p9}
N -270 -3560 -260 -3560 {
lab=vpres5}
N -140 -3560 -130 -3560 {
lab=w_px}
N -190 -3420 -180 -3420 {
lab=ctrl_pos}
N -140 -3540 -140 -3520 {
lab=#net158}
N -140 -3460 -140 -3450 {
lab=#net159}
N -2760 -3200 -2760 -3190 {
lab=GND}
N -2760 -3310 -2760 -3300 {
lab=vdd_syn1}
N -2700 -3120 -2690 -3120 {
lab=GND}
N -2700 -3090 -2700 -3080 {
lab=p1}
N -2830 -3260 -2820 -3260 {
lab=vpres6}
N -2700 -3260 -2690 -3260 {
lab=w_px}
N -2750 -3120 -2740 -3120 {
lab=ctrl_pos}
N -2700 -3240 -2700 -3220 {
lab=#net160}
N -2700 -3160 -2700 -3150 {
lab=#net161}
N -2440 -3200 -2440 -3190 {
lab=GND}
N -2440 -3310 -2440 -3300 {
lab=vdd_syn2}
N -2380 -3120 -2370 -3120 {
lab=GND}
N -2380 -3090 -2380 -3080 {
lab=p2}
N -2510 -3260 -2500 -3260 {
lab=vpres6}
N -2380 -3260 -2370 -3260 {
lab=b_px}
N -2430 -3120 -2420 -3120 {
lab=ctrl_pos}
N -2380 -3240 -2380 -3220 {
lab=#net162}
N -2380 -3160 -2380 -3150 {
lab=#net163}
N -2120 -3200 -2120 -3190 {
lab=GND}
N -2120 -3310 -2120 -3300 {
lab=vdd_syn3}
N -2060 -3120 -2050 -3120 {
lab=GND}
N -2060 -3090 -2060 -3080 {
lab=p3}
N -2190 -3260 -2180 -3260 {
lab=vpres6}
N -2060 -3260 -2050 -3260 {
lab=b_px}
N -2110 -3120 -2100 -3120 {
lab=ctrl_pos}
N -2060 -3240 -2060 -3220 {
lab=#net164}
N -2060 -3160 -2060 -3150 {
lab=#net165}
N -1800 -3200 -1800 -3190 {
lab=GND}
N -1800 -3310 -1800 -3300 {
lab=vdd_syn4}
N -1740 -3120 -1730 -3120 {
lab=GND}
N -1740 -3090 -1740 -3080 {
lab=p4}
N -1870 -3260 -1860 -3260 {
lab=vpres6}
N -1740 -3260 -1730 -3260 {
lab=b_px}
N -1790 -3120 -1780 -3120 {
lab=ctrl_pos}
N -1740 -3240 -1740 -3220 {
lab=#net166}
N -1740 -3160 -1740 -3150 {
lab=#net167}
N -1480 -3200 -1480 -3190 {
lab=GND}
N -1480 -3310 -1480 -3300 {
lab=vdd_syn5}
N -1420 -3120 -1410 -3120 {
lab=GND}
N -1420 -3090 -1420 -3080 {
lab=p5}
N -1550 -3260 -1540 -3260 {
lab=vpres6}
N -1420 -3260 -1410 -3260 {
lab=w_px}
N -1470 -3120 -1460 -3120 {
lab=ctrl_pos}
N -1420 -3240 -1420 -3220 {
lab=#net168}
N -1420 -3160 -1420 -3150 {
lab=#net169}
N -1160 -3200 -1160 -3190 {
lab=GND}
N -1160 -3310 -1160 -3300 {
lab=vdd_syn6}
N -1100 -3120 -1090 -3120 {
lab=GND}
N -1100 -3090 -1100 -3080 {
lab=p6}
N -1230 -3260 -1220 -3260 {
lab=vpres6}
N -1100 -3260 -1090 -3260 {
lab=w_px}
N -1150 -3120 -1140 -3120 {
lab=ctrl_pos}
N -1100 -3240 -1100 -3220 {
lab=#net170}
N -1100 -3160 -1100 -3150 {
lab=#net171}
N -840 -3200 -840 -3190 {
lab=GND}
N -840 -3310 -840 -3300 {
lab=vdd_syn7}
N -780 -3120 -770 -3120 {
lab=GND}
N -780 -3090 -780 -3080 {
lab=p7}
N -910 -3260 -900 -3260 {
lab=vpres6}
N -780 -3260 -770 -3260 {
lab=b_px}
N -830 -3120 -820 -3120 {
lab=ctrl_pos}
N -780 -3240 -780 -3220 {
lab=#net172}
N -780 -3160 -780 -3150 {
lab=#net173}
N -520 -3200 -520 -3190 {
lab=GND}
N -520 -3310 -520 -3300 {
lab=vdd_syn8}
N -460 -3120 -450 -3120 {
lab=GND}
N -460 -3090 -460 -3080 {
lab=p8}
N -590 -3260 -580 -3260 {
lab=vpres6}
N -460 -3260 -450 -3260 {
lab=b_px}
N -510 -3120 -500 -3120 {
lab=ctrl_pos}
N -460 -3240 -460 -3220 {
lab=#net174}
N -460 -3160 -460 -3150 {
lab=#net175}
N -200 -3200 -200 -3190 {
lab=GND}
N -200 -3310 -200 -3300 {
lab=vdd_syn9}
N -140 -3120 -130 -3120 {
lab=GND}
N -140 -3090 -140 -3080 {
lab=p9}
N -270 -3260 -260 -3260 {
lab=vpres6}
N -140 -3260 -130 -3260 {
lab=b_px}
N -190 -3120 -180 -3120 {
lab=ctrl_pos}
N -140 -3240 -140 -3220 {
lab=#net176}
N -140 -3160 -140 -3150 {
lab=#net177}
N -2760 -2900 -2760 -2890 {
lab=GND}
N -2760 -3010 -2760 -3000 {
lab=vdd_syn1}
N -2700 -2820 -2690 -2820 {
lab=GND}
N -2700 -2790 -2700 -2780 {
lab=p1}
N -2830 -2960 -2820 -2960 {
lab=vpres7}
N -2700 -2960 -2690 -2960 {
lab=w_px}
N -2750 -2820 -2740 -2820 {
lab=ctrl_pos}
N -2700 -2940 -2700 -2920 {
lab=#net178}
N -2700 -2860 -2700 -2850 {
lab=#net179}
N -2440 -2900 -2440 -2890 {
lab=GND}
N -2440 -3010 -2440 -3000 {
lab=vdd_syn2}
N -2380 -2820 -2370 -2820 {
lab=GND}
N -2380 -2790 -2380 -2780 {
lab=p2}
N -2510 -2960 -2500 -2960 {
lab=vpres7}
N -2380 -2960 -2370 -2960 {
lab=w_px}
N -2430 -2820 -2420 -2820 {
lab=ctrl_pos}
N -2380 -2940 -2380 -2920 {
lab=#net180}
N -2380 -2860 -2380 -2850 {
lab=#net181}
N -2120 -2900 -2120 -2890 {
lab=GND}
N -2120 -3010 -2120 -3000 {
lab=vdd_syn3}
N -2060 -2820 -2050 -2820 {
lab=GND}
N -2060 -2790 -2060 -2780 {
lab=p3}
N -2190 -2960 -2180 -2960 {
lab=vpres7}
N -2060 -2960 -2050 -2960 {
lab=w_px}
N -2110 -2820 -2100 -2820 {
lab=ctrl_pos}
N -2060 -2940 -2060 -2920 {
lab=#net182}
N -2060 -2860 -2060 -2850 {
lab=#net183}
N -1800 -2900 -1800 -2890 {
lab=GND}
N -1800 -3010 -1800 -3000 {
lab=vdd_syn4}
N -1740 -2820 -1730 -2820 {
lab=GND}
N -1740 -2790 -1740 -2780 {
lab=p4}
N -1870 -2960 -1860 -2960 {
lab=vpres7}
N -1740 -2960 -1730 -2960 {
lab=w_px}
N -1790 -2820 -1780 -2820 {
lab=ctrl_pos}
N -1740 -2940 -1740 -2920 {
lab=#net184}
N -1740 -2860 -1740 -2850 {
lab=#net185}
N -1480 -2900 -1480 -2890 {
lab=GND}
N -1480 -3010 -1480 -3000 {
lab=vdd_syn5}
N -1420 -2820 -1410 -2820 {
lab=GND}
N -1420 -2790 -1420 -2780 {
lab=p5}
N -1550 -2960 -1540 -2960 {
lab=vpres7}
N -1420 -2960 -1410 -2960 {
lab=w_px}
N -1470 -2820 -1460 -2820 {
lab=ctrl_pos}
N -1420 -2940 -1420 -2920 {
lab=#net186}
N -1420 -2860 -1420 -2850 {
lab=#net187}
N -1160 -2900 -1160 -2890 {
lab=GND}
N -1160 -3010 -1160 -3000 {
lab=vdd_syn6}
N -1100 -2820 -1090 -2820 {
lab=GND}
N -1100 -2790 -1100 -2780 {
lab=p6}
N -1230 -2960 -1220 -2960 {
lab=vpres7}
N -1100 -2960 -1090 -2960 {
lab=b_px}
N -1150 -2820 -1140 -2820 {
lab=ctrl_pos}
N -1100 -2940 -1100 -2920 {
lab=#net188}
N -1100 -2860 -1100 -2850 {
lab=#net189}
N -840 -2900 -840 -2890 {
lab=GND}
N -840 -3010 -840 -3000 {
lab=vdd_syn7}
N -780 -2820 -770 -2820 {
lab=GND}
N -780 -2790 -780 -2780 {
lab=p7}
N -910 -2960 -900 -2960 {
lab=vpres7}
N -780 -2960 -770 -2960 {
lab=w_px}
N -830 -2820 -820 -2820 {
lab=ctrl_pos}
N -780 -2940 -780 -2920 {
lab=#net190}
N -780 -2860 -780 -2850 {
lab=#net191}
N -520 -2900 -520 -2890 {
lab=GND}
N -520 -3010 -520 -3000 {
lab=vdd_syn8}
N -460 -2820 -450 -2820 {
lab=GND}
N -460 -2790 -460 -2780 {
lab=p8}
N -590 -2960 -580 -2960 {
lab=vpres7}
N -460 -2960 -450 -2960 {
lab=w_px}
N -510 -2820 -500 -2820 {
lab=ctrl_pos}
N -460 -2940 -460 -2920 {
lab=#net192}
N -460 -2860 -460 -2850 {
lab=#net193}
N -200 -2900 -200 -2890 {
lab=GND}
N -200 -3010 -200 -3000 {
lab=vdd_syn9}
N -140 -2820 -130 -2820 {
lab=GND}
N -140 -2790 -140 -2780 {
lab=p9}
N -270 -2960 -260 -2960 {
lab=vpres7}
N -140 -2960 -130 -2960 {
lab=w_px}
N -190 -2820 -180 -2820 {
lab=ctrl_pos}
N -140 -2940 -140 -2920 {
lab=#net194}
N -140 -2860 -140 -2850 {
lab=#net195}
N -2760 -2600 -2760 -2590 {
lab=GND}
N -2760 -2710 -2760 -2700 {
lab=vdd_syn1}
N -2700 -2520 -2690 -2520 {
lab=GND}
N -2700 -2490 -2700 -2480 {
lab=p1}
N -2830 -2660 -2820 -2660 {
lab=vpres8}
N -2700 -2660 -2690 -2660 {
lab=b_px}
N -2750 -2520 -2740 -2520 {
lab=ctrl_pos}
N -2700 -2640 -2700 -2620 {
lab=#net196}
N -2700 -2560 -2700 -2550 {
lab=#net197}
N -2440 -2600 -2440 -2590 {
lab=GND}
N -2440 -2710 -2440 -2700 {
lab=vdd_syn2}
N -2380 -2520 -2370 -2520 {
lab=GND}
N -2380 -2490 -2380 -2480 {
lab=p2}
N -2510 -2660 -2500 -2660 {
lab=vpres8}
N -2380 -2660 -2370 -2660 {
lab=b_px}
N -2430 -2520 -2420 -2520 {
lab=ctrl_pos}
N -2380 -2640 -2380 -2620 {
lab=#net198}
N -2380 -2560 -2380 -2550 {
lab=#net199}
N -2120 -2600 -2120 -2590 {
lab=GND}
N -2120 -2710 -2120 -2700 {
lab=vdd_syn3}
N -2060 -2520 -2050 -2520 {
lab=GND}
N -2060 -2490 -2060 -2480 {
lab=p3}
N -2190 -2660 -2180 -2660 {
lab=vpres8}
N -2060 -2660 -2050 -2660 {
lab=b_px}
N -2110 -2520 -2100 -2520 {
lab=ctrl_pos}
N -2060 -2640 -2060 -2620 {
lab=#net200}
N -2060 -2560 -2060 -2550 {
lab=#net201}
N -1800 -2600 -1800 -2590 {
lab=GND}
N -1800 -2710 -1800 -2700 {
lab=vdd_syn4}
N -1740 -2520 -1730 -2520 {
lab=GND}
N -1740 -2490 -1740 -2480 {
lab=p4}
N -1870 -2660 -1860 -2660 {
lab=vpres8}
N -1740 -2660 -1730 -2660 {
lab=b_px}
N -1790 -2520 -1780 -2520 {
lab=ctrl_pos}
N -1740 -2640 -1740 -2620 {
lab=#net202}
N -1740 -2560 -1740 -2550 {
lab=#net203}
N -1480 -2600 -1480 -2590 {
lab=GND}
N -1480 -2710 -1480 -2700 {
lab=vdd_syn5}
N -1420 -2520 -1410 -2520 {
lab=GND}
N -1420 -2490 -1420 -2480 {
lab=p5}
N -1550 -2660 -1540 -2660 {
lab=vpres8}
N -1420 -2660 -1410 -2660 {
lab=b_px}
N -1470 -2520 -1460 -2520 {
lab=ctrl_pos}
N -1420 -2640 -1420 -2620 {
lab=#net204}
N -1420 -2560 -1420 -2550 {
lab=#net205}
N -1160 -2600 -1160 -2590 {
lab=GND}
N -1160 -2710 -1160 -2700 {
lab=vdd_syn6}
N -1100 -2520 -1090 -2520 {
lab=GND}
N -1100 -2490 -1100 -2480 {
lab=p6}
N -1230 -2660 -1220 -2660 {
lab=vpres8}
N -1100 -2660 -1090 -2660 {
lab=b_px}
N -1150 -2520 -1140 -2520 {
lab=ctrl_pos}
N -1100 -2640 -1100 -2620 {
lab=#net206}
N -1100 -2560 -1100 -2550 {
lab=#net207}
N -840 -2600 -840 -2590 {
lab=GND}
N -840 -2710 -840 -2700 {
lab=vdd_syn7}
N -780 -2520 -770 -2520 {
lab=GND}
N -780 -2490 -780 -2480 {
lab=p7}
N -910 -2660 -900 -2660 {
lab=vpres8}
N -780 -2660 -770 -2660 {
lab=w_px}
N -830 -2520 -820 -2520 {
lab=ctrl_pos}
N -780 -2640 -780 -2620 {
lab=#net208}
N -780 -2560 -780 -2550 {
lab=#net209}
N -520 -2600 -520 -2590 {
lab=GND}
N -520 -2710 -520 -2700 {
lab=vdd_syn8}
N -460 -2520 -450 -2520 {
lab=GND}
N -460 -2490 -460 -2480 {
lab=p8}
N -590 -2660 -580 -2660 {
lab=vpres8}
N -460 -2660 -450 -2660 {
lab=b_px}
N -510 -2520 -500 -2520 {
lab=ctrl_pos}
N -460 -2640 -460 -2620 {
lab=#net210}
N -460 -2560 -460 -2550 {
lab=#net211}
N -200 -2600 -200 -2590 {
lab=GND}
N -200 -2710 -200 -2700 {
lab=vdd_syn9}
N -140 -2520 -130 -2520 {
lab=GND}
N -140 -2490 -140 -2480 {
lab=p9}
N -270 -2660 -260 -2660 {
lab=vpres8}
N -140 -2660 -130 -2660 {
lab=b_px}
N -190 -2520 -180 -2520 {
lab=ctrl_pos}
N -140 -2640 -140 -2620 {
lab=#net212}
N -140 -2560 -140 -2550 {
lab=#net213}
N -2760 -2300 -2760 -2290 {
lab=GND}
N -2760 -2410 -2760 -2400 {
lab=vdd_syn1}
N -2700 -2220 -2690 -2220 {
lab=GND}
N -2700 -2190 -2700 -2180 {
lab=p1}
N -2830 -2360 -2820 -2360 {
lab=vpres9}
N -2700 -2360 -2690 -2360 {
lab=w_px}
N -2750 -2220 -2740 -2220 {
lab=ctrl_pos}
N -2700 -2340 -2700 -2320 {
lab=#net214}
N -2700 -2260 -2700 -2250 {
lab=#net215}
N -2440 -2300 -2440 -2290 {
lab=GND}
N -2440 -2410 -2440 -2400 {
lab=vdd_syn2}
N -2380 -2220 -2370 -2220 {
lab=GND}
N -2380 -2190 -2380 -2180 {
lab=p2}
N -2510 -2360 -2500 -2360 {
lab=vpres9}
N -2380 -2360 -2370 -2360 {
lab=w_px}
N -2430 -2220 -2420 -2220 {
lab=ctrl_pos}
N -2380 -2340 -2380 -2320 {
lab=#net216}
N -2380 -2260 -2380 -2250 {
lab=#net217}
N -2120 -2300 -2120 -2290 {
lab=GND}
N -2120 -2410 -2120 -2400 {
lab=vdd_syn3}
N -2060 -2220 -2050 -2220 {
lab=GND}
N -2060 -2190 -2060 -2180 {
lab=p3}
N -2190 -2360 -2180 -2360 {
lab=vpres9}
N -2060 -2360 -2050 -2360 {
lab=w_px}
N -2110 -2220 -2100 -2220 {
lab=ctrl_pos}
N -2060 -2340 -2060 -2320 {
lab=#net218}
N -2060 -2260 -2060 -2250 {
lab=#net219}
N -1800 -2300 -1800 -2290 {
lab=GND}
N -1800 -2410 -1800 -2400 {
lab=vdd_syn4}
N -1740 -2220 -1730 -2220 {
lab=GND}
N -1740 -2190 -1740 -2180 {
lab=p4}
N -1870 -2360 -1860 -2360 {
lab=vpres9}
N -1740 -2360 -1730 -2360 {
lab=b_px}
N -1790 -2220 -1780 -2220 {
lab=ctrl_pos}
N -1740 -2340 -1740 -2320 {
lab=#net220}
N -1740 -2260 -1740 -2250 {
lab=#net221}
N -1480 -2300 -1480 -2290 {
lab=GND}
N -1480 -2410 -1480 -2400 {
lab=vdd_syn5}
N -1420 -2220 -1410 -2220 {
lab=GND}
N -1420 -2190 -1420 -2180 {
lab=p5}
N -1550 -2360 -1540 -2360 {
lab=vpres9}
N -1420 -2360 -1410 -2360 {
lab=w_px}
N -1470 -2220 -1460 -2220 {
lab=ctrl_pos}
N -1420 -2340 -1420 -2320 {
lab=#net222}
N -1420 -2260 -1420 -2250 {
lab=#net223}
N -1160 -2300 -1160 -2290 {
lab=GND}
N -1160 -2410 -1160 -2400 {
lab=vdd_syn6}
N -1100 -2220 -1090 -2220 {
lab=GND}
N -1100 -2190 -1100 -2180 {
lab=p6}
N -1230 -2360 -1220 -2360 {
lab=vpres9}
N -1100 -2360 -1090 -2360 {
lab=w_px}
N -1150 -2220 -1140 -2220 {
lab=ctrl_pos}
N -1100 -2340 -1100 -2320 {
lab=#net224}
N -1100 -2260 -1100 -2250 {
lab=#net225}
N -840 -2300 -840 -2290 {
lab=GND}
N -840 -2410 -840 -2400 {
lab=vdd_syn7}
N -780 -2220 -770 -2220 {
lab=GND}
N -780 -2190 -780 -2180 {
lab=p7}
N -910 -2360 -900 -2360 {
lab=vpres9}
N -780 -2360 -770 -2360 {
lab=b_px}
N -830 -2220 -820 -2220 {
lab=ctrl_pos}
N -780 -2340 -780 -2320 {
lab=#net226}
N -780 -2260 -780 -2250 {
lab=#net227}
N -520 -2300 -520 -2290 {
lab=GND}
N -520 -2410 -520 -2400 {
lab=vdd_syn8}
N -460 -2220 -450 -2220 {
lab=GND}
N -460 -2190 -460 -2180 {
lab=p8}
N -590 -2360 -580 -2360 {
lab=vpres9}
N -460 -2360 -450 -2360 {
lab=w_px}
N -510 -2220 -500 -2220 {
lab=ctrl_pos}
N -460 -2340 -460 -2320 {
lab=#net228}
N -460 -2260 -460 -2250 {
lab=#net229}
N -200 -2300 -200 -2290 {
lab=GND}
N -200 -2410 -200 -2400 {
lab=vdd_syn9}
N -140 -2220 -130 -2220 {
lab=GND}
N -140 -2190 -140 -2180 {
lab=p9}
N -270 -2360 -260 -2360 {
lab=vpres9}
N -140 -2360 -130 -2360 {
lab=b_px}
N -190 -2220 -180 -2220 {
lab=ctrl_pos}
N -140 -2340 -140 -2320 {
lab=#net230}
N -140 -2260 -140 -2250 {
lab=#net231}
N -2760 -2000 -2760 -1990 {
lab=GND}
N -2760 -2110 -2760 -2100 {
lab=vdd_syn1}
N -2700 -1920 -2690 -1920 {
lab=GND}
N -2700 -1890 -2700 -1880 {
lab=p1}
N -2830 -2060 -2820 -2060 {
lab=vpres10}
N -2700 -2060 -2690 -2060 {
lab=w_px}
N -2750 -1920 -2740 -1920 {
lab=ctrl_pos}
N -2700 -2040 -2700 -2020 {
lab=#net232}
N -2700 -1960 -2700 -1950 {
lab=#net233}
N -2440 -2000 -2440 -1990 {
lab=GND}
N -2440 -2110 -2440 -2100 {
lab=vdd_syn2}
N -2380 -1920 -2370 -1920 {
lab=GND}
N -2380 -1890 -2380 -1880 {
lab=p2}
N -2510 -2060 -2500 -2060 {
lab=vpres10}
N -2380 -2060 -2370 -2060 {
lab=b_px}
N -2430 -1920 -2420 -1920 {
lab=ctrl_pos}
N -2380 -2040 -2380 -2020 {
lab=#net234}
N -2380 -1960 -2380 -1950 {
lab=#net235}
N -2120 -2000 -2120 -1990 {
lab=GND}
N -2120 -2110 -2120 -2100 {
lab=vdd_syn3}
N -2060 -1920 -2050 -1920 {
lab=GND}
N -2060 -1890 -2060 -1880 {
lab=p3}
N -2190 -2060 -2180 -2060 {
lab=vpres10}
N -2060 -2060 -2050 -2060 {
lab=w_px}
N -2110 -1920 -2100 -1920 {
lab=ctrl_pos}
N -2060 -2040 -2060 -2020 {
lab=#net236}
N -2060 -1960 -2060 -1950 {
lab=#net237}
N -1800 -2000 -1800 -1990 {
lab=GND}
N -1800 -2110 -1800 -2100 {
lab=vdd_syn4}
N -1740 -1920 -1730 -1920 {
lab=GND}
N -1740 -1890 -1740 -1880 {
lab=p4}
N -1870 -2060 -1860 -2060 {
lab=vpres10}
N -1740 -2060 -1730 -2060 {
lab=w_px}
N -1790 -1920 -1780 -1920 {
lab=ctrl_pos}
N -1740 -2040 -1740 -2020 {
lab=#net238}
N -1740 -1960 -1740 -1950 {
lab=#net239}
N -1480 -2000 -1480 -1990 {
lab=GND}
N -1480 -2110 -1480 -2100 {
lab=vdd_syn5}
N -1420 -1920 -1410 -1920 {
lab=GND}
N -1420 -1890 -1420 -1880 {
lab=p5}
N -1550 -2060 -1540 -2060 {
lab=vpres10}
N -1420 -2060 -1410 -2060 {
lab=w_px}
N -1470 -1920 -1460 -1920 {
lab=ctrl_pos}
N -1420 -2040 -1420 -2020 {
lab=#net240}
N -1420 -1960 -1420 -1950 {
lab=#net241}
N -1160 -2000 -1160 -1990 {
lab=GND}
N -1160 -2110 -1160 -2100 {
lab=vdd_syn6}
N -1100 -1920 -1090 -1920 {
lab=GND}
N -1100 -1890 -1100 -1880 {
lab=p6}
N -1230 -2060 -1220 -2060 {
lab=vpres10}
N -1100 -2060 -1090 -2060 {
lab=b_px}
N -1150 -1920 -1140 -1920 {
lab=ctrl_pos}
N -1100 -2040 -1100 -2020 {
lab=#net242}
N -1100 -1960 -1100 -1950 {
lab=#net243}
N -840 -2000 -840 -1990 {
lab=GND}
N -840 -2110 -840 -2100 {
lab=vdd_syn7}
N -780 -1920 -770 -1920 {
lab=GND}
N -780 -1890 -780 -1880 {
lab=p7}
N -910 -2060 -900 -2060 {
lab=vpres10}
N -780 -2060 -770 -2060 {
lab=w_px}
N -830 -1920 -820 -1920 {
lab=ctrl_pos}
N -780 -2040 -780 -2020 {
lab=#net244}
N -780 -1960 -780 -1950 {
lab=#net245}
N -520 -2000 -520 -1990 {
lab=GND}
N -520 -2110 -520 -2100 {
lab=vdd_syn8}
N -460 -1920 -450 -1920 {
lab=GND}
N -460 -1890 -460 -1880 {
lab=p8}
N -590 -2060 -580 -2060 {
lab=vpres10}
N -460 -2060 -450 -2060 {
lab=b_px}
N -510 -1920 -500 -1920 {
lab=ctrl_pos}
N -460 -2040 -460 -2020 {
lab=#net246}
N -460 -1960 -460 -1950 {
lab=#net247}
N -200 -2000 -200 -1990 {
lab=GND}
N -200 -2110 -200 -2100 {
lab=vdd_syn9}
N -140 -1920 -130 -1920 {
lab=GND}
N -140 -1890 -140 -1880 {
lab=p9}
N -270 -2060 -260 -2060 {
lab=vpres10}
N -140 -2060 -130 -2060 {
lab=w_px}
N -190 -1920 -180 -1920 {
lab=ctrl_pos}
N -140 -2040 -140 -2020 {
lab=#net248}
N -140 -1960 -140 -1950 {
lab=#net249}
N -2760 -1700 -2760 -1690 {
lab=GND}
N -2760 -1810 -2760 -1800 {
lab=vdd_syn1}
N -2700 -1620 -2690 -1620 {
lab=GND}
N -2700 -1590 -2700 -1580 {
lab=p1}
N -2830 -1760 -2820 -1760 {
lab=vpres11}
N -2700 -1760 -2690 -1760 {
lab=b_px}
N -2750 -1620 -2740 -1620 {
lab=ctrl_pos}
N -2700 -1740 -2700 -1720 {
lab=#net250}
N -2700 -1660 -2700 -1650 {
lab=#net251}
N -2440 -1700 -2440 -1690 {
lab=GND}
N -2440 -1810 -2440 -1800 {
lab=vdd_syn2}
N -2380 -1620 -2370 -1620 {
lab=GND}
N -2380 -1590 -2380 -1580 {
lab=p2}
N -2510 -1760 -2500 -1760 {
lab=vpres11}
N -2380 -1760 -2370 -1760 {
lab=w_px}
N -2430 -1620 -2420 -1620 {
lab=ctrl_pos}
N -2380 -1740 -2380 -1720 {
lab=#net252}
N -2380 -1660 -2380 -1650 {
lab=#net253}
N -2120 -1700 -2120 -1690 {
lab=GND}
N -2120 -1810 -2120 -1800 {
lab=vdd_syn3}
N -2060 -1620 -2050 -1620 {
lab=GND}
N -2060 -1590 -2060 -1580 {
lab=p3}
N -2190 -1760 -2180 -1760 {
lab=vpres11}
N -2060 -1760 -2050 -1760 {
lab=w_px}
N -2110 -1620 -2100 -1620 {
lab=ctrl_pos}
N -2060 -1740 -2060 -1720 {
lab=#net254}
N -2060 -1660 -2060 -1650 {
lab=#net255}
N -1800 -1700 -1800 -1690 {
lab=GND}
N -1800 -1810 -1800 -1800 {
lab=vdd_syn4}
N -1740 -1620 -1730 -1620 {
lab=GND}
N -1740 -1590 -1740 -1580 {
lab=p4}
N -1870 -1760 -1860 -1760 {
lab=vpres11}
N -1740 -1760 -1730 -1760 {
lab=w_px}
N -1790 -1620 -1780 -1620 {
lab=ctrl_pos}
N -1740 -1740 -1740 -1720 {
lab=#net256}
N -1740 -1660 -1740 -1650 {
lab=#net257}
N -1480 -1700 -1480 -1690 {
lab=GND}
N -1480 -1810 -1480 -1800 {
lab=vdd_syn5}
N -1420 -1620 -1410 -1620 {
lab=GND}
N -1420 -1590 -1420 -1580 {
lab=p5}
N -1550 -1760 -1540 -1760 {
lab=vpres11}
N -1420 -1760 -1410 -1760 {
lab=w_px}
N -1470 -1620 -1460 -1620 {
lab=ctrl_pos}
N -1420 -1740 -1420 -1720 {
lab=#net258}
N -1420 -1660 -1420 -1650 {
lab=#net259}
N -1160 -1700 -1160 -1690 {
lab=GND}
N -1160 -1810 -1160 -1800 {
lab=vdd_syn6}
N -1100 -1620 -1090 -1620 {
lab=GND}
N -1100 -1590 -1100 -1580 {
lab=p6}
N -1230 -1760 -1220 -1760 {
lab=vpres11}
N -1100 -1760 -1090 -1760 {
lab=w_px}
N -1150 -1620 -1140 -1620 {
lab=ctrl_pos}
N -1100 -1740 -1100 -1720 {
lab=#net260}
N -1100 -1660 -1100 -1650 {
lab=#net261}
N -840 -1700 -840 -1690 {
lab=GND}
N -840 -1810 -840 -1800 {
lab=vdd_syn7}
N -780 -1620 -770 -1620 {
lab=GND}
N -780 -1590 -780 -1580 {
lab=p7}
N -910 -1760 -900 -1760 {
lab=vpres11}
N -780 -1760 -770 -1760 {
lab=b_px}
N -830 -1620 -820 -1620 {
lab=ctrl_pos}
N -780 -1740 -780 -1720 {
lab=#net262}
N -780 -1660 -780 -1650 {
lab=#net263}
N -520 -1700 -520 -1690 {
lab=GND}
N -520 -1810 -520 -1800 {
lab=vdd_syn8}
N -460 -1620 -450 -1620 {
lab=GND}
N -460 -1590 -460 -1580 {
lab=p8}
N -590 -1760 -580 -1760 {
lab=vpres11}
N -460 -1760 -450 -1760 {
lab=w_px}
N -510 -1620 -500 -1620 {
lab=ctrl_pos}
N -460 -1740 -460 -1720 {
lab=#net264}
N -460 -1660 -460 -1650 {
lab=#net265}
N -200 -1700 -200 -1690 {
lab=GND}
N -200 -1810 -200 -1800 {
lab=vdd_syn9}
N -140 -1620 -130 -1620 {
lab=GND}
N -140 -1590 -140 -1580 {
lab=p9}
N -270 -1760 -260 -1760 {
lab=vpres11}
N -140 -1760 -130 -1760 {
lab=w_px}
N -190 -1620 -180 -1620 {
lab=ctrl_pos}
N -140 -1740 -140 -1720 {
lab=#net266}
N -140 -1660 -140 -1650 {
lab=#net267}
N -2760 -1400 -2760 -1390 {
lab=GND}
N -2760 -1510 -2760 -1500 {
lab=vdd_syn1}
N -2700 -1320 -2690 -1320 {
lab=GND}
N -2700 -1290 -2700 -1280 {
lab=p1}
N -2830 -1460 -2820 -1460 {
lab=vpres12}
N -2700 -1460 -2690 -1460 {
lab=w_px}
N -2750 -1320 -2740 -1320 {
lab=ctrl_pos}
N -2700 -1440 -2700 -1420 {
lab=#net268}
N -2700 -1360 -2700 -1350 {
lab=#net269}
N -2440 -1400 -2440 -1390 {
lab=GND}
N -2440 -1510 -2440 -1500 {
lab=vdd_syn2}
N -2380 -1320 -2370 -1320 {
lab=GND}
N -2380 -1290 -2380 -1280 {
lab=p2}
N -2510 -1460 -2500 -1460 {
lab=vpres12}
N -2380 -1460 -2370 -1460 {
lab=w_px}
N -2430 -1320 -2420 -1320 {
lab=ctrl_pos}
N -2380 -1440 -2380 -1420 {
lab=#net270}
N -2380 -1360 -2380 -1350 {
lab=#net271}
N -2120 -1400 -2120 -1390 {
lab=GND}
N -2120 -1510 -2120 -1500 {
lab=vdd_syn3}
N -2060 -1320 -2050 -1320 {
lab=GND}
N -2060 -1290 -2060 -1280 {
lab=p3}
N -2190 -1460 -2180 -1460 {
lab=vpres12}
N -2060 -1460 -2050 -1460 {
lab=b_px}
N -2110 -1320 -2100 -1320 {
lab=ctrl_pos}
N -2060 -1440 -2060 -1420 {
lab=#net272}
N -2060 -1360 -2060 -1350 {
lab=#net273}
N -1800 -1400 -1800 -1390 {
lab=GND}
N -1800 -1510 -1800 -1500 {
lab=vdd_syn4}
N -1740 -1320 -1730 -1320 {
lab=GND}
N -1740 -1290 -1740 -1280 {
lab=p4}
N -1870 -1460 -1860 -1460 {
lab=vpres12}
N -1740 -1460 -1730 -1460 {
lab=b_px}
N -1790 -1320 -1780 -1320 {
lab=ctrl_pos}
N -1740 -1440 -1740 -1420 {
lab=#net274}
N -1740 -1360 -1740 -1350 {
lab=#net275}
N -1480 -1400 -1480 -1390 {
lab=GND}
N -1480 -1510 -1480 -1500 {
lab=vdd_syn5}
N -1420 -1320 -1410 -1320 {
lab=GND}
N -1420 -1290 -1420 -1280 {
lab=p5}
N -1550 -1460 -1540 -1460 {
lab=vpres12}
N -1420 -1460 -1410 -1460 {
lab=b_px}
N -1470 -1320 -1460 -1320 {
lab=ctrl_pos}
N -1420 -1440 -1420 -1420 {
lab=#net276}
N -1420 -1360 -1420 -1350 {
lab=#net277}
N -1160 -1400 -1160 -1390 {
lab=GND}
N -1160 -1510 -1160 -1500 {
lab=vdd_syn6}
N -1100 -1320 -1090 -1320 {
lab=GND}
N -1100 -1290 -1100 -1280 {
lab=p6}
N -1230 -1460 -1220 -1460 {
lab=vpres12}
N -1100 -1460 -1090 -1460 {
lab=b_px}
N -1150 -1320 -1140 -1320 {
lab=ctrl_pos}
N -1100 -1440 -1100 -1420 {
lab=#net278}
N -1100 -1360 -1100 -1350 {
lab=#net279}
N -840 -1400 -840 -1390 {
lab=GND}
N -840 -1510 -840 -1500 {
lab=vdd_syn7}
N -780 -1320 -770 -1320 {
lab=GND}
N -780 -1290 -780 -1280 {
lab=p7}
N -910 -1460 -900 -1460 {
lab=vpres12}
N -780 -1460 -770 -1460 {
lab=w_px}
N -830 -1320 -820 -1320 {
lab=ctrl_pos}
N -780 -1440 -780 -1420 {
lab=#net280}
N -780 -1360 -780 -1350 {
lab=#net281}
N -520 -1400 -520 -1390 {
lab=GND}
N -520 -1510 -520 -1500 {
lab=vdd_syn8}
N -460 -1320 -450 -1320 {
lab=GND}
N -460 -1290 -460 -1280 {
lab=p8}
N -590 -1460 -580 -1460 {
lab=vpres12}
N -460 -1460 -450 -1460 {
lab=b_px}
N -510 -1320 -500 -1320 {
lab=ctrl_pos}
N -460 -1440 -460 -1420 {
lab=#net282}
N -460 -1360 -460 -1350 {
lab=#net283}
N -200 -1400 -200 -1390 {
lab=GND}
N -200 -1510 -200 -1500 {
lab=vdd_syn9}
N -140 -1320 -130 -1320 {
lab=GND}
N -140 -1290 -140 -1280 {
lab=p9}
N -270 -1460 -260 -1460 {
lab=vpres12}
N -140 -1460 -130 -1460 {
lab=b_px}
N -190 -1320 -180 -1320 {
lab=ctrl_pos}
N -140 -1440 -140 -1420 {
lab=#net284}
N -140 -1360 -140 -1350 {
lab=#net285}
N -2760 -1100 -2760 -1090 {
lab=GND}
N -2760 -1210 -2760 -1200 {
lab=vdd_syn1}
N -2700 -1020 -2690 -1020 {
lab=GND}
N -2700 -990 -2700 -980 {
lab=p1}
N -2830 -1160 -2820 -1160 {
lab=vpres13}
N -2700 -1160 -2690 -1160 {
lab=b_px}
N -2750 -1020 -2740 -1020 {
lab=ctrl_pos}
N -2700 -1140 -2700 -1120 {
lab=#net286}
N -2700 -1060 -2700 -1050 {
lab=#net287}
N -2440 -1100 -2440 -1090 {
lab=GND}
N -2440 -1210 -2440 -1200 {
lab=vdd_syn2}
N -2380 -1020 -2370 -1020 {
lab=GND}
N -2380 -990 -2380 -980 {
lab=p2}
N -2510 -1160 -2500 -1160 {
lab=vpres13}
N -2380 -1160 -2370 -1160 {
lab=b_px}
N -2430 -1020 -2420 -1020 {
lab=ctrl_pos}
N -2380 -1140 -2380 -1120 {
lab=#net288}
N -2380 -1060 -2380 -1050 {
lab=#net289}
N -2120 -1100 -2120 -1090 {
lab=GND}
N -2120 -1210 -2120 -1200 {
lab=vdd_syn3}
N -2060 -1020 -2050 -1020 {
lab=GND}
N -2060 -990 -2060 -980 {
lab=p3}
N -2190 -1160 -2180 -1160 {
lab=vpres13}
N -2060 -1160 -2050 -1160 {
lab=b_px}
N -2110 -1020 -2100 -1020 {
lab=ctrl_pos}
N -2060 -1140 -2060 -1120 {
lab=#net290}
N -2060 -1060 -2060 -1050 {
lab=#net291}
N -1800 -1100 -1800 -1090 {
lab=GND}
N -1800 -1210 -1800 -1200 {
lab=vdd_syn4}
N -1740 -1020 -1730 -1020 {
lab=GND}
N -1740 -990 -1740 -980 {
lab=p4}
N -1870 -1160 -1860 -1160 {
lab=vpres13}
N -1740 -1160 -1730 -1160 {
lab=w_px}
N -1790 -1020 -1780 -1020 {
lab=ctrl_pos}
N -1740 -1140 -1740 -1120 {
lab=#net292}
N -1740 -1060 -1740 -1050 {
lab=#net293}
N -1480 -1100 -1480 -1090 {
lab=GND}
N -1480 -1210 -1480 -1200 {
lab=vdd_syn5}
N -1420 -1020 -1410 -1020 {
lab=GND}
N -1420 -990 -1420 -980 {
lab=p5}
N -1550 -1160 -1540 -1160 {
lab=vpres13}
N -1420 -1160 -1410 -1160 {
lab=b_px}
N -1470 -1020 -1460 -1020 {
lab=ctrl_pos}
N -1420 -1140 -1420 -1120 {
lab=#net294}
N -1420 -1060 -1420 -1050 {
lab=#net295}
N -1160 -1100 -1160 -1090 {
lab=GND}
N -1160 -1210 -1160 -1200 {
lab=vdd_syn6}
N -1100 -1020 -1090 -1020 {
lab=GND}
N -1100 -990 -1100 -980 {
lab=p6}
N -1230 -1160 -1220 -1160 {
lab=vpres13}
N -1100 -1160 -1090 -1160 {
lab=w_px}
N -1150 -1020 -1140 -1020 {
lab=ctrl_pos}
N -1100 -1140 -1100 -1120 {
lab=#net296}
N -1100 -1060 -1100 -1050 {
lab=#net297}
N -840 -1100 -840 -1090 {
lab=GND}
N -840 -1210 -840 -1200 {
lab=vdd_syn7}
N -780 -1020 -770 -1020 {
lab=GND}
N -780 -990 -780 -980 {
lab=p7}
N -910 -1160 -900 -1160 {
lab=vpres13}
N -780 -1160 -770 -1160 {
lab=b_px}
N -830 -1020 -820 -1020 {
lab=ctrl_pos}
N -780 -1140 -780 -1120 {
lab=#net298}
N -780 -1060 -780 -1050 {
lab=#net299}
N -520 -1100 -520 -1090 {
lab=GND}
N -520 -1210 -520 -1200 {
lab=vdd_syn8}
N -460 -1020 -450 -1020 {
lab=GND}
N -460 -990 -460 -980 {
lab=p8}
N -590 -1160 -580 -1160 {
lab=vpres13}
N -460 -1160 -450 -1160 {
lab=w_px}
N -510 -1020 -500 -1020 {
lab=ctrl_pos}
N -460 -1140 -460 -1120 {
lab=#net300}
N -460 -1060 -460 -1050 {
lab=#net301}
N -200 -1100 -200 -1090 {
lab=GND}
N -200 -1210 -200 -1200 {
lab=vdd_syn9}
N -140 -1020 -130 -1020 {
lab=GND}
N -140 -990 -140 -980 {
lab=p9}
N -270 -1160 -260 -1160 {
lab=vpres13}
N -140 -1160 -130 -1160 {
lab=w_px}
N -190 -1020 -180 -1020 {
lab=ctrl_pos}
N -140 -1140 -140 -1120 {
lab=#net302}
N -140 -1060 -140 -1050 {
lab=#net303}
N -2760 -800 -2760 -790 {
lab=GND}
N -2760 -910 -2760 -900 {
lab=vdd_syn1}
N -2700 -720 -2690 -720 {
lab=GND}
N -2700 -690 -2700 -680 {
lab=p1}
N -2830 -860 -2820 -860 {
lab=vpres14}
N -2700 -860 -2690 -860 {
lab=b_px}
N -2750 -720 -2740 -720 {
lab=ctrl_pos}
N -2700 -840 -2700 -820 {
lab=#net304}
N -2700 -760 -2700 -750 {
lab=#net305}
N -2440 -800 -2440 -790 {
lab=GND}
N -2440 -910 -2440 -900 {
lab=vdd_syn2}
N -2380 -720 -2370 -720 {
lab=GND}
N -2380 -690 -2380 -680 {
lab=p2}
N -2510 -860 -2500 -860 {
lab=vpres14}
N -2380 -860 -2370 -860 {
lab=b_px}
N -2430 -720 -2420 -720 {
lab=ctrl_pos}
N -2380 -840 -2380 -820 {
lab=#net306}
N -2380 -760 -2380 -750 {
lab=#net307}
N -2120 -800 -2120 -790 {
lab=GND}
N -2120 -910 -2120 -900 {
lab=vdd_syn3}
N -2060 -720 -2050 -720 {
lab=GND}
N -2060 -690 -2060 -680 {
lab=p3}
N -2190 -860 -2180 -860 {
lab=vpres14}
N -2060 -860 -2050 -860 {
lab=b_px}
N -2110 -720 -2100 -720 {
lab=ctrl_pos}
N -2060 -840 -2060 -820 {
lab=#net308}
N -2060 -760 -2060 -750 {
lab=#net309}
N -1800 -800 -1800 -790 {
lab=GND}
N -1800 -910 -1800 -900 {
lab=vdd_syn4}
N -1740 -720 -1730 -720 {
lab=GND}
N -1740 -690 -1740 -680 {
lab=p4}
N -1870 -860 -1860 -860 {
lab=vpres14}
N -1740 -860 -1730 -860 {
lab=w_px}
N -1790 -720 -1780 -720 {
lab=ctrl_pos}
N -1740 -840 -1740 -820 {
lab=#net310}
N -1740 -760 -1740 -750 {
lab=#net311}
N -1480 -800 -1480 -790 {
lab=GND}
N -1480 -910 -1480 -900 {
lab=vdd_syn5}
N -1420 -720 -1410 -720 {
lab=GND}
N -1420 -690 -1420 -680 {
lab=p5}
N -1550 -860 -1540 -860 {
lab=vpres14}
N -1420 -860 -1410 -860 {
lab=b_px}
N -1470 -720 -1460 -720 {
lab=ctrl_pos}
N -1420 -840 -1420 -820 {
lab=#net312}
N -1420 -760 -1420 -750 {
lab=#net313}
N -1160 -800 -1160 -790 {
lab=GND}
N -1160 -910 -1160 -900 {
lab=vdd_syn6}
N -1100 -720 -1090 -720 {
lab=GND}
N -1100 -690 -1100 -680 {
lab=p6}
N -1230 -860 -1220 -860 {
lab=vpres14}
N -1100 -860 -1090 -860 {
lab=b_px}
N -1150 -720 -1140 -720 {
lab=ctrl_pos}
N -1100 -840 -1100 -820 {
lab=#net314}
N -1100 -760 -1100 -750 {
lab=#net315}
N -840 -800 -840 -790 {
lab=GND}
N -840 -910 -840 -900 {
lab=vdd_syn7}
N -780 -720 -770 -720 {
lab=GND}
N -780 -690 -780 -680 {
lab=p7}
N -910 -860 -900 -860 {
lab=vpres14}
N -780 -860 -770 -860 {
lab=w_px}
N -830 -720 -820 -720 {
lab=ctrl_pos}
N -780 -840 -780 -820 {
lab=#net316}
N -780 -760 -780 -750 {
lab=#net317}
N -520 -800 -520 -790 {
lab=GND}
N -520 -910 -520 -900 {
lab=vdd_syn8}
N -460 -720 -450 -720 {
lab=GND}
N -460 -690 -460 -680 {
lab=p8}
N -590 -860 -580 -860 {
lab=vpres14}
N -460 -860 -450 -860 {
lab=b_px}
N -510 -720 -500 -720 {
lab=ctrl_pos}
N -460 -840 -460 -820 {
lab=#net318}
N -460 -760 -460 -750 {
lab=#net319}
N -200 -800 -200 -790 {
lab=GND}
N -200 -910 -200 -900 {
lab=vdd_syn9}
N -140 -720 -130 -720 {
lab=GND}
N -140 -690 -140 -680 {
lab=p9}
N -270 -860 -260 -860 {
lab=vpres14}
N -140 -860 -130 -860 {
lab=w_px}
N -190 -720 -180 -720 {
lab=ctrl_pos}
N -140 -840 -140 -820 {
lab=#net320}
N -140 -760 -140 -750 {
lab=#net321}
N -2760 -500 -2760 -490 {
lab=GND}
N -2760 -610 -2760 -600 {
lab=vdd_syn1}
N -2700 -420 -2690 -420 {
lab=GND}
N -2700 -390 -2700 -380 {
lab=p1}
N -2830 -560 -2820 -560 {
lab=vpres15}
N -2700 -560 -2690 -560 {
lab=b_px}
N -2750 -420 -2740 -420 {
lab=ctrl_pos}
N -2700 -540 -2700 -520 {
lab=#net322}
N -2700 -460 -2700 -450 {
lab=#net323}
N -2440 -500 -2440 -490 {
lab=GND}
N -2440 -610 -2440 -600 {
lab=vdd_syn2}
N -2380 -420 -2370 -420 {
lab=GND}
N -2380 -390 -2380 -380 {
lab=p2}
N -2510 -560 -2500 -560 {
lab=vpres15}
N -2380 -560 -2370 -560 {
lab=b_px}
N -2430 -420 -2420 -420 {
lab=ctrl_pos}
N -2380 -540 -2380 -520 {
lab=#net324}
N -2380 -460 -2380 -450 {
lab=#net325}
N -2120 -500 -2120 -490 {
lab=GND}
N -2120 -610 -2120 -600 {
lab=vdd_syn3}
N -2060 -420 -2050 -420 {
lab=GND}
N -2060 -390 -2060 -380 {
lab=p3}
N -2190 -560 -2180 -560 {
lab=vpres15}
N -2060 -560 -2050 -560 {
lab=w_px}
N -2110 -420 -2100 -420 {
lab=ctrl_pos}
N -2060 -540 -2060 -520 {
lab=#net326}
N -2060 -460 -2060 -450 {
lab=#net327}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn4}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p4}
N -1870 -560 -1860 -560 {
lab=vpres15}
N -1740 -560 -1730 -560 {
lab=b_px}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net328}
N -1740 -460 -1740 -450 {
lab=#net329}
N -1480 -500 -1480 -490 {
lab=GND}
N -1480 -610 -1480 -600 {
lab=vdd_syn5}
N -1420 -420 -1410 -420 {
lab=GND}
N -1420 -390 -1420 -380 {
lab=p5}
N -1550 -560 -1540 -560 {
lab=vpres15}
N -1420 -560 -1410 -560 {
lab=w_px}
N -1470 -420 -1460 -420 {
lab=ctrl_pos}
N -1420 -540 -1420 -520 {
lab=#net330}
N -1420 -460 -1420 -450 {
lab=#net331}
N -1160 -500 -1160 -490 {
lab=GND}
N -1160 -610 -1160 -600 {
lab=vdd_syn6}
N -1100 -420 -1090 -420 {
lab=GND}
N -1100 -390 -1100 -380 {
lab=p6}
N -1230 -560 -1220 -560 {
lab=vpres15}
N -1100 -560 -1090 -560 {
lab=w_px}
N -1150 -420 -1140 -420 {
lab=ctrl_pos}
N -1100 -540 -1100 -520 {
lab=#net332}
N -1100 -460 -1100 -450 {
lab=#net333}
N -840 -500 -840 -490 {
lab=GND}
N -840 -610 -840 -600 {
lab=vdd_syn7}
N -780 -420 -770 -420 {
lab=GND}
N -780 -390 -780 -380 {
lab=p7}
N -910 -560 -900 -560 {
lab=vpres15}
N -780 -560 -770 -560 {
lab=w_px}
N -830 -420 -820 -420 {
lab=ctrl_pos}
N -780 -540 -780 -520 {
lab=#net334}
N -780 -460 -780 -450 {
lab=#net335}
N -520 -500 -520 -490 {
lab=GND}
N -520 -610 -520 -600 {
lab=vdd_syn8}
N -460 -420 -450 -420 {
lab=GND}
N -460 -390 -460 -380 {
lab=p8}
N -590 -560 -580 -560 {
lab=vpres15}
N -460 -560 -450 -560 {
lab=w_px}
N -510 -420 -500 -420 {
lab=ctrl_pos}
N -460 -540 -460 -520 {
lab=#net336}
N -460 -460 -460 -450 {
lab=#net337}
N -200 -500 -200 -490 {
lab=GND}
N -200 -610 -200 -600 {
lab=vdd_syn9}
N -140 -420 -130 -420 {
lab=GND}
N -140 -390 -140 -380 {
lab=p9}
N -270 -560 -260 -560 {
lab=vpres15}
N -140 -560 -130 -560 {
lab=b_px}
N -190 -420 -180 -420 {
lab=ctrl_pos}
N -140 -540 -140 -520 {
lab=#net338}
N -140 -460 -140 -450 {
lab=#net339}
N 30 -4370 40 -4370 {
lab=1}
N 30 -4390 40 -4390 {
lab=2}
N 30 -4410 40 -4410 {
lab=3}
N 30 -4430 40 -4430 {
lab=4}
N 30 -4450 40 -4450 {
lab=5}
N 30 -4470 40 -4470 {
lab=6}
N 30 -4490 40 -4490 {
lab=7}
N 30 -4510 40 -4510 {
lab=8}
N 30 -4530 40 -4530 {
lab=9}
N 120 -2760 120 -2740 {
lab=GND}
N 120 -2840 120 -2820 {
lab=vdd_syn1}
N 220 -2760 220 -2740 {
lab=GND}
N 220 -2840 220 -2820 {
lab=vdd_syn2}
N 320 -2760 320 -2740 {
lab=GND}
N 320 -2840 320 -2820 {
lab=vdd_syn3}
N 420 -2760 420 -2740 {
lab=GND}
N 420 -2840 420 -2820 {
lab=vdd_syn4}
N 520 -2760 520 -2740 {
lab=GND}
N 520 -2840 520 -2820 {
lab=vdd_syn5}
N 620 -2760 620 -2740 {
lab=GND}
N 620 -2840 620 -2820 {
lab=vdd_syn6}
N 720 -2760 720 -2740 {
lab=GND}
N 720 -2840 720 -2820 {
lab=vdd_syn7}
N 820 -2760 820 -2740 {
lab=GND}
N 820 -2840 820 -2820 {
lab=vdd_syn8}
N 920 -2760 920 -2740 {
lab=GND}
N 920 -2840 920 -2820 {
lab=vdd_syn9}
N 700 -2620 700 -2600 {
lab=GND}
N 700 -2700 700 -2680 {
lab=b_px}
N 620 -2620 620 -2600 {
lab=GND}
N 620 -2700 620 -2680 {
lab=w_px}
N -3020 -270 -3020 -260 {
lab=#net340}
N -3020 -340 -3020 -330 {
lab=p0}
N -3020 -20 -3020 -10 {
lab=N0}
N -3090 -160 -3090 -140 {
lab=GND}
N -2950 -160 -2950 -140 {
lab=vdd_pos}
N -3090 -260 -3090 -250 {
lab=inh0}
N -3060 -260 -3060 -250 {
lab=vb_pos}
N -2980 -260 -2980 -250 {
lab=vlky}
N 150 -4180 160 -4180 {
lab=inh0}
N 120 -4190 120 -4180 {
lab=GND}
N 120 -4140 120 -4130 {
lab=inh_d}
N 80 -4180 90 -4180 {
lab=ctrl_vinh}
C {devices/vsource.sym} 20 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} 20 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 100 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} 100 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 100 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -3760 -4370 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -3860 -4420 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -4410 0 0 {name=I2 value="PWL(0 0 99.9u 0 100u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u)"}
C {devices/gnd.sym} -4140 -4360 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4510 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4510 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} 110 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -10 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} 600 -2530 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param L_pre=0.15
.param W_pre=1
.param L_pos=0.15
.param W_pos=5
.param L_mem_in=0.15
.param W_mem_in=10
.param L_mem_out=0.45
.param W_mem_out=0.45
.param Wp_or=1
.param Lp_or=0.15
.param Wn_or=1
.param Ln_or=0.15
.param Wp_or_inv=1
.param Lp_or_inv=0.15
.param Wn_or_inv=1
.param Ln_or_inv=0.15
.control
	save all
	tran 10n 150u 0
	write SNN_15x1_InfStage_0to9tb.raw
	*wrdata SNN_15x1_lt_tb.ssv v(8)
.endc
" }
C {devices/launcher.sym} 80 -1895 0 0 {name=h1
descr="load training 1"
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_InfStage_tb.raw tran"
}
C {devices/lab_pin.sym} -3940 -4460 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/gnd.sym} -3080 -4690 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -3150 -4760 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -3020 -4690 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4620 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4620 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -3020 -4580 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/vsource.sym} 20 -2230 0 0 {name=V13 value="PWL(0 1.8 54.9u 1.8 55u 0)"}
C {devices/gnd.sym} 20 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} 20 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} 200 -2230 0 0 {name=V14 value="PWL(0 0 59.9u 0 60u 1.8 94.9u 1.8 95u 0)"}
C {devices/gnd.sym} 200 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 200 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} 460 -2230 0 0 {name=V15 value="PWL(0 0 99.9u 0 100u 1.8)"}
C {devices/gnd.sym} 460 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 460 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -4110 -4460 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} 20 -2370 0 0 {name=V11 value="PWL(0 1.8 54.9u 1.8 55u 0)"}
C {devices/gnd.sym} 20 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 20 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 180 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} 180 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 180 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 190 -2650 0 0 {name=V3 value="PWL(0 0 99.9u 0 100u 1.8)"}
C {devices/gnd.sym} 190 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 190 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} 280 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 280 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 280 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_wu}
C {devices/vsource.sym} 360 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} 360 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 360 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tr}
C {devices/vsource.sym} 20 -2510 0 0 {name=V7 value=0.8
*0.55}
C {devices/gnd.sym} 20 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 20 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} 100 -2510 0 0 {name=V8 value=0.6}
C {devices/gnd.sym} 100 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 100 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -3760 -4550 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} 20 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -4000 -4540 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -4670 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -3860 -4720 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -4710 0 0 {name=I1 value="PWL(0 0 109.9u 0 110u 5u 129.9u 5u 130u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -4140 -4660 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4810 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4810 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4760 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -3080 -4390 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -3150 -4460 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/ammeter.sym} -3020 -4390 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4320 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4320 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -3020 -4280 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3330 -4610 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3610 -4760 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -4110 -4760 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -3390 -4560 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -3330 -4760 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -3450 -4760 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -3450 -4790 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4710 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -3760 -4850 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -3390 -4670 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4820 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -4000 -4840 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3070 -4320 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -3070 -4620 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} 100 -2370 0 0 {name=V16 value="PWL(0 0 99.9u 0 100u 1.8)"}
C {devices/gnd.sym} 100 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 100 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} 520 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} 520 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 520 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} 120 -4290 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 120 -4590 2 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/vsource.sym} 260 -2370 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} 260 -2320 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} 260 -2420 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 310 -4440 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 160 -4040 2 0 {name=p94 sig_type=std_logic lab=inh1}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4020 3 0 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -4050 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 120 -3990 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -4040 0 0 {name=p85 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} 260 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} 260 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 260 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -4800 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -4500 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} 20 -2790 0 0 {name=V10 value=1.8
*"PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 20 -2740 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 20 -2840 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -3080 -4090 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -3020 -4090 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -4020 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -4020 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -3020 -3980 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -4020 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3790 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -3150 -3860 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -3020 -3790 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3720 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3720 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -3020 -3680 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3720 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3490 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -3150 -3560 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -3020 -3490 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3420 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3420 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -3020 -3380 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3420 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -3190 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -3020 -3190 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -3120 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -3120 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -3020 -3080 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -3120 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2890 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -3020 -2890 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2820 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2820 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -3020 -2780 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2820 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2590 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -3020 -2590 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2520 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2520 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -3020 -2480 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2520 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -2290 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -3150 -2360 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -3020 -2290 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -2220 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -2220 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -3020 -2180 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -2220 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -3770 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -3860 -3820 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -3810 0 0 {name=I4 value="PWL(0 0 99.9u 0 100u 5u 109.9u 5u 110u 0 119.9u 0 120u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -4140 -3760 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3910 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3910 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3860 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -4110 -3860 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3950 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3940 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -4070 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -3860 -4120 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -4110 0 0 {name=I3 value="PWL(0 0 119.9u 0 120u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -4140 -4060 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -4210 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -4210 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -4160 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -4110 -4160 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -3760 -4250 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -4240 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -4200 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -3900 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -3170 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -3860 -3220 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -3210 0 0 {name=I6 value="PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 109.9u 0 110u 5u 124.9u 5u 125u 0 134.9u 0 135u 5u)"}
C {devices/gnd.sym} -4140 -3160 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3310 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3310 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3260 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -4110 -3260 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3350 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3340 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -3470 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -3860 -3520 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -3510 0 0 {name=I5 value="PWL(0 0 104.9u 0 105u 5u 109.9u 5u 110u 0)"}
C {devices/gnd.sym} -4140 -3460 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3610 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3610 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -3560 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -4110 -3560 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3650 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3640 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -3600 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -3300 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -2570 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -3860 -2620 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2610 0 0 {name=I8 value="PWL(0 0 104.9u 0 105u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -4140 -2560 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2710 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2710 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2660 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -4110 -2660 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -3760 -2750 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2740 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -2870 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -3860 -2920 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2910 0 0 {name=I7 value="PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 129.9u 0 130u 5u 134.9u 5u 135u 0)"}
C {devices/gnd.sym} -4140 -2860 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -3010 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -3010 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2960 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -4110 -2960 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -3760 -3050 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -3040 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -3000 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -2700 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -2270 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -3860 -2320 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2310 0 0 {name=I9 value="PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 119.9u 0 120u 5u 124.9u 5u 125u 0 134.9u 0 135u 5u 139.9u 5u 140u 0 144.9u 0 145u 5u)"}
C {devices/gnd.sym} -4140 -2260 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2410 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2410 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2360 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -4110 -2360 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -3760 -2450 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2440 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -2400 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3610 -4460 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3610 -4160 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3150 -4160 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3610 -2360 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3150 -2660 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3610 -2660 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3150 -2960 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3610 -2960 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3150 -3260 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3610 -3260 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3610 -3560 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3610 -3860 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/launcher.sym} 90 -1975 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2360 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2660 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2960 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3260 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3560 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -3860 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4160 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4460 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -4760 0 0 {name=x2010}
C {devices/gnd.sym} -3080 -1990 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -3020 -1990 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1920 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1920 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -3020 -1880 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1920 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1690 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -3020 -1690 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1620 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1620 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -3020 -1580 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1620 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1390 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -3020 -1390 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1320 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1320 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -3020 -1280 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1320 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -1090 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -3020 -1090 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -1020 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -1020 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -3020 -980 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -1020 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -790 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -3020 -790 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -720 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -720 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -3020 -680 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -720 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3080 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -3020 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -3040 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -3010 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -3020 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3070 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3760 -1970 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -3860 -2020 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -2010 0 0 {name=I10 value="PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 109.9u 0 110u 5u 114.9u 5u 115u 0 129.9u 0 130u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u 144.9u 5u 145u 0)"}
C {devices/gnd.sym} -4140 -1960 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -2110 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -2110 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -2060 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -4110 -2060 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -3760 -2150 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -2140 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -2100 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -1370 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -3860 -1420 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -1410 0 0 {name=I12 value="PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 114.9u 0 115u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -4140 -1360 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1510 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1510 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1460 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -4110 -1460 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -3760 -1550 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1540 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -1670 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -3860 -1720 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -1710 0 0 {name=I11 value="PWL(0 0 104.9u 0 105u 5u 109.9u 5u 110u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -4140 -1660 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1810 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1810 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1760 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -4110 -1760 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -3760 -1850 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1840 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -1800 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -1500 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -770 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -3860 -820 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -810 0 0 {name=I14 value="PWL(0 0 99.9u 0 100u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u 144.9u 5u 145u 0)"}
C {devices/gnd.sym} -4140 -760 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -910 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -910 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -860 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -4110 -860 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -3760 -950 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -940 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -3760 -1070 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -3860 -1120 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -1110 0 0 {name=I13 value="PWL(0 0 104.9u 0 105u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u 129.9u 5u 130u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -4140 -1060 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -1210 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -1210 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -1160 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -4110 -1160 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -3760 -1250 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -1240 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -1200 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3860 -900 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -3760 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -3860 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -4140 -510 0 0 {name=I15 value="PWL(0 0 104.9u 0 105u 5u 114.9u 5u 115u 0 119.9u 0 120u 5u 124.9u 5u 125u 0 144.9u 0 145u 5u)"}
C {devices/gnd.sym} -4140 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -3960 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -4040 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -3940 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -4110 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -3760 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -4000 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -3860 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -3610 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3610 -860 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3610 -1160 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3610 -1760 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3610 -2060 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -860 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1160 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1460 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -1760 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -3760 -2060 0 0 {name=x2100}
C {devices/lab_pin.sym} -3150 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4580 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -4280 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3980 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3680 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3380 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -3080 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2780 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2480 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -2180 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1880 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1580 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -1280 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -980 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -680 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -3020 -380 0 0 {name=x150}
C {devices/lab_pin.sym} -3150 -860 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3150 -1160 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3150 -2060 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3150 -1760 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3610 -1460 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3150 -1460 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3080 -4810 0 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -4510 0 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3310 0 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2110 0 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4760 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4610 0 0 {name=x2013}
C {devices/lab_pin.sym} -3450 -4640 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 180 -2370 0 0 {name=V20 value="PWL(0 0 99.9u 0 100u 1.8)"}
C {devices/gnd.sym} 180 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 180 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -3390 -4260 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -3450 -4490 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4410 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -3390 -4370 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4520 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4460 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4310 0 0 {name=x2023}
C {devices/lab_pin.sym} -3450 -4340 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3960 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -3450 -4190 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -4110 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -3390 -4070 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -4220 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -4160 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -4010 0 0 {name=x2033}
C {devices/lab_pin.sym} -3450 -4040 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3660 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -3450 -3890 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3810 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -3390 -3770 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3920 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3860 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3710 0 0 {name=x2043}
C {devices/lab_pin.sym} -3450 -3740 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3360 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -3450 -3590 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3510 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -3390 -3470 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3620 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3560 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3410 0 0 {name=x2053}
C {devices/lab_pin.sym} -3450 -3440 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -3060 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -3450 -3290 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -3210 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -3390 -3170 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3320 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -3260 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -3110 0 0 {name=x2063}
C {devices/lab_pin.sym} -3450 -3140 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2760 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -3450 -2990 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2910 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -3390 -2870 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -3020 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2960 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2810 0 0 {name=x2073}
C {devices/lab_pin.sym} -3450 -2840 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2460 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -3450 -2690 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2610 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -3390 -2570 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2720 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2660 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2510 0 0 {name=x2083}
C {devices/lab_pin.sym} -3450 -2540 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -2160 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -3450 -2390 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2310 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -3390 -2270 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2420 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2360 0 0 {name=x2092}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -2210 0 0 {name=x2093}
C {devices/lab_pin.sym} -3450 -2240 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1860 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -3450 -2090 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -2010 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -3390 -1970 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -2120 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -2060 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1910 0 0 {name=x2103}
C {devices/lab_pin.sym} -3450 -1940 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1560 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -3450 -1790 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1710 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -3390 -1670 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1820 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1760 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1610 0 0 {name=x2113}
C {devices/lab_pin.sym} -3450 -1640 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -1260 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -3450 -1490 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1410 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -3390 -1370 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1520 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1460 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1310 0 0 {name=x2123}
C {devices/lab_pin.sym} -3450 -1340 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -960 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -3450 -1190 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -1110 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -3390 -1070 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -1220 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -1160 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -1010 0 0 {name=x2133}
C {devices/lab_pin.sym} -3450 -1040 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -660 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -3450 -890 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -810 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -3390 -770 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -920 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -860 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -710 0 0 {name=x2143}
C {devices/lab_pin.sym} -3450 -740 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -3390 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -3450 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -3390 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -3390 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -3390 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -3450 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -3390 -560 0 0 {name=x2152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -3390 -410 0 0 {name=x2153}
C {devices/lab_pin.sym} -3450 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -3330 -4460 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3330 -4310 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -3450 -4460 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -3450 -4160 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -3330 -4160 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3330 -4010 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -3450 -3860 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -3330 -3860 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -3710 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -3330 -3560 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3330 -3410 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -3450 -3560 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -3450 -3260 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -3330 -3260 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3330 -3110 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -3450 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -3330 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3330 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -3450 -860 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -3330 -860 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3330 -710 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -3450 -1160 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -3330 -1160 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3330 -1010 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -3450 -1460 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -3330 -1460 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -1310 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -3330 -1760 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3330 -1610 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -3450 -1760 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -3450 -2060 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -3330 -2060 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3330 -1910 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -3450 -2360 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -3330 -2360 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3330 -2210 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -3450 -2660 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -3330 -2660 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3330 -2510 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -3450 -2960 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -3330 -2960 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3330 -2810 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -3450 -680 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -980 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1280 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1580 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -1880 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2180 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2480 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -2780 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3080 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3380 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3680 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -3980 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4280 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -3450 -4580 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 440 -2650 0 0 {name=V22 value=1.8}
C {devices/gnd.sym} 440 -2600 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 440 -2700 2 0 {name=p285 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2740 -260 1 0 {name=p286 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2770 -140 0 0 {name=l90 lab=GND}
C {devices/ammeter.sym} -2700 -300 0 0 {name=Vmeas1 savecurrent=true}
C {devices/lab_pin.sym} -2700 -340 2 0 {name=p287 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2700 -10 2 0 {name=p288 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} -2630 -140 3 0 {name=p289 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2770 -260 1 0 {name=p290 sig_type=std_logic lab=inh1}
C {devices/lab_pin.sym} -2660 -260 1 0 {name=p291 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2700 -160 1 0 {name=x1}
C {devices/lab_pin.sym} -2420 -260 1 0 {name=p292 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2450 -140 0 0 {name=l91 lab=GND}
C {devices/ammeter.sym} -2380 -300 0 0 {name=Vmeas2 savecurrent=true}
C {devices/lab_pin.sym} -2380 -340 2 0 {name=p294 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2380 -10 2 0 {name=p295 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} -2310 -140 3 0 {name=p296 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2450 -260 1 0 {name=p297 sig_type=std_logic lab=inh2}
C {devices/lab_pin.sym} -2340 -260 1 0 {name=p298 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2380 -160 1 0 {name=x2}
C {devices/lab_pin.sym} -2100 -260 1 0 {name=p299 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -2130 -140 0 0 {name=l92 lab=GND}
C {devices/ammeter.sym} -2060 -300 0 0 {name=Vmeas3 savecurrent=true}
C {devices/lab_pin.sym} -2060 -340 2 0 {name=p300 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2060 -10 2 0 {name=p301 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} -1990 -140 3 0 {name=p302 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -2130 -260 1 0 {name=p303 sig_type=std_logic lab=inh3}
C {devices/lab_pin.sym} -2020 -260 1 0 {name=p305 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -2060 -160 1 0 {name=x3}
C {devices/lab_pin.sym} -1780 -260 1 0 {name=p306 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -140 0 0 {name=l93 lab=GND}
C {devices/ammeter.sym} -1740 -300 0 0 {name=Vmeas4 savecurrent=true}
C {devices/lab_pin.sym} -1740 -340 2 0 {name=p307 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1740 -10 2 0 {name=p308 sig_type=std_logic lab=4}
C {devices/lab_pin.sym} -1670 -140 3 0 {name=p309 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1810 -260 1 0 {name=p310 sig_type=std_logic lab=inh4}
C {devices/lab_pin.sym} -1700 -260 1 0 {name=p311 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -160 1 0 {name=x4}
C {devices/lab_pin.sym} -1460 -260 1 0 {name=p314 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1490 -140 0 0 {name=l94 lab=GND}
C {devices/ammeter.sym} -1420 -300 0 0 {name=Vmeas5 savecurrent=true}
C {devices/lab_pin.sym} -1420 -340 2 0 {name=p316 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1420 -10 2 0 {name=p318 sig_type=std_logic lab=5}
C {devices/lab_pin.sym} -1350 -140 3 0 {name=p320 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1490 -260 1 0 {name=p322 sig_type=std_logic lab=inh5}
C {devices/lab_pin.sym} -1380 -260 1 0 {name=p323 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1420 -160 1 0 {name=x5}
C {devices/lab_pin.sym} -1140 -260 1 0 {name=p355 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1170 -140 0 0 {name=l95 lab=GND}
C {devices/ammeter.sym} -1100 -300 0 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -1100 -340 2 0 {name=p356 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1100 -10 2 0 {name=p357 sig_type=std_logic lab=6}
C {devices/lab_pin.sym} -1030 -140 3 0 {name=p358 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1170 -260 1 0 {name=p360 sig_type=std_logic lab=inh6}
C {devices/lab_pin.sym} -1060 -260 1 0 {name=p364 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1100 -160 1 0 {name=x6}
C {devices/lab_pin.sym} -820 -260 1 0 {name=p366 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -850 -140 0 0 {name=l96 lab=GND}
C {devices/ammeter.sym} -780 -300 0 0 {name=Vmeas7 savecurrent=true}
C {devices/lab_pin.sym} -780 -340 2 0 {name=p368 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -780 -10 2 0 {name=p370 sig_type=std_logic lab=7}
C {devices/lab_pin.sym} -710 -140 3 0 {name=p371 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -850 -260 1 0 {name=p372 sig_type=std_logic lab=inh7}
C {devices/lab_pin.sym} -740 -260 1 0 {name=p374 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -780 -160 1 0 {name=x7}
C {devices/lab_pin.sym} -500 -260 1 0 {name=p375 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -530 -140 0 0 {name=l97 lab=GND}
C {devices/ammeter.sym} -460 -300 0 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -460 -340 2 0 {name=p377 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -460 -10 2 0 {name=p379 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} -390 -140 3 0 {name=p381 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -530 -260 1 0 {name=p383 sig_type=std_logic lab=inh8}
C {devices/lab_pin.sym} -420 -260 1 0 {name=p384 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -460 -160 1 0 {name=x8}
C {devices/lab_pin.sym} -180 -260 1 0 {name=p390 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -210 -140 0 0 {name=l98 lab=GND}
C {devices/ammeter.sym} -140 -300 0 0 {name=Vmeas9 savecurrent=true}
C {devices/lab_pin.sym} -140 -340 2 0 {name=p391 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -140 -10 2 0 {name=p393 sig_type=std_logic lab=9}
C {devices/lab_pin.sym} -70 -140 3 0 {name=p395 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -210 -260 1 0 {name=p397 sig_type=std_logic lab=inh9}
C {devices/lab_pin.sym} -100 -260 1 0 {name=p398 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -140 -160 1 0 {name=x9}
C {devices/gnd.sym} -2760 -4690 0 0 {name=l99 lab=GND}
C {devices/lab_pin.sym} -2830 -4760 0 0 {name=p399 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2700 -4690 0 0 {name=Vmeas11 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4620 0 0 {name=M11
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4620 3 0 {name=l100 lab=GND}
C {devices/lab_pin.sym} -2700 -4580 2 0 {name=p402 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4620 0 0 {name=p403 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4580 0 0 {name=x11}
C {devices/lab_pin.sym} -2760 -4810 0 0 {name=p404 sig_type=std_logic lab=vdd_syn1}
C {devices/lab_pin.sym} -3080 -4210 0 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3910 0 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3610 0 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -3010 0 0 {name=p406 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2710 0 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -2410 0 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1810 0 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1510 0 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -1210 0 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -910 0 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -3080 -610 0 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} 160 -3900 2 0 {name=p319 sig_type=std_logic lab=inh2}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3880 3 0 {name=M2
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3910 2 0 {name=l101 lab=GND}
C {devices/lab_pin.sym} 120 -3850 2 0 {name=p407 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3900 0 0 {name=p408 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3760 2 0 {name=p409 sig_type=std_logic lab=inh3}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3740 3 0 {name=M3
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3770 2 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} 120 -3710 2 0 {name=p410 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3760 0 0 {name=p412 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3620 2 0 {name=p414 sig_type=std_logic lab=inh4}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3600 3 0 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3630 2 0 {name=l103 lab=GND}
C {devices/lab_pin.sym} 120 -3570 2 0 {name=p416 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3620 0 0 {name=p417 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3480 2 0 {name=p418 sig_type=std_logic lab=inh5}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3460 3 0 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3490 2 0 {name=l104 lab=GND}
C {devices/lab_pin.sym} 120 -3430 2 0 {name=p419 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3480 0 0 {name=p420 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3340 2 0 {name=p421 sig_type=std_logic lab=inh6}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3320 3 0 {name=M6
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3350 2 0 {name=l107 lab=GND}
C {devices/lab_pin.sym} 120 -3290 2 0 {name=p422 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3340 0 0 {name=p423 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3200 2 0 {name=p424 sig_type=std_logic lab=inh7}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3180 3 0 {name=M7
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3210 2 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} 120 -3150 2 0 {name=p425 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3200 0 0 {name=p426 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3060 2 0 {name=p427 sig_type=std_logic lab=inh8}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3040 3 0 {name=M8
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3070 2 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 120 -3010 2 0 {name=p428 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3060 0 0 {name=p429 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -2920 2 0 {name=p430 sig_type=std_logic lab=inh9}
C {sky130_fd_pr/nfet_01v8.sym} 120 -2900 3 0 {name=M9
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -2930 2 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} 120 -2870 2 0 {name=p431 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -2920 0 0 {name=p432 sig_type=std_logic lab=ctrl_vinh}
C {devices/gnd.sym} -2440 -4690 0 0 {name=l128 lab=GND}
C {devices/lab_pin.sym} -2510 -4760 0 0 {name=p436 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2380 -4690 0 0 {name=Vmeas12 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4620 0 0 {name=M12
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4620 3 0 {name=l129 lab=GND}
C {devices/lab_pin.sym} -2380 -4580 2 0 {name=p438 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4620 0 0 {name=p439 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4580 0 0 {name=x12}
C {devices/lab_pin.sym} -2440 -4810 0 0 {name=p440 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4690 0 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -2190 -4760 0 0 {name=p441 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -2060 -4690 0 0 {name=Vmeas13 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4620 0 0 {name=M13
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4620 3 0 {name=l131 lab=GND}
C {devices/lab_pin.sym} -2060 -4580 2 0 {name=p443 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4620 0 0 {name=p444 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4580 0 0 {name=x13}
C {devices/lab_pin.sym} -2120 -4810 0 0 {name=p445 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4690 0 0 {name=l132 lab=GND}
C {devices/lab_pin.sym} -1870 -4760 0 0 {name=p446 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1740 -4690 0 0 {name=Vmeas14 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4620 0 0 {name=M14
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4620 3 0 {name=l133 lab=GND}
C {devices/lab_pin.sym} -1740 -4580 2 0 {name=p448 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4620 0 0 {name=p449 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4580 0 0 {name=x14}
C {devices/lab_pin.sym} -1800 -4810 0 0 {name=p450 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4690 0 0 {name=l134 lab=GND}
C {devices/lab_pin.sym} -1550 -4760 0 0 {name=p451 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1420 -4690 0 0 {name=Vmeas15 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4620 0 0 {name=M15
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4620 3 0 {name=l135 lab=GND}
C {devices/lab_pin.sym} -1420 -4580 2 0 {name=p453 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4620 0 0 {name=p454 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4580 0 0 {name=x15}
C {devices/lab_pin.sym} -1480 -4810 0 0 {name=p455 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4690 0 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} -1230 -4760 0 0 {name=p456 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1100 -4690 0 0 {name=Vmeas16 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4620 0 0 {name=M16
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4620 3 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -1100 -4580 2 0 {name=p458 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4620 0 0 {name=p459 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4580 0 0 {name=x16}
C {devices/lab_pin.sym} -1160 -4810 0 0 {name=p460 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4690 0 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -910 -4760 0 0 {name=p461 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -780 -4690 0 0 {name=Vmeas17 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4620 0 0 {name=M17
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4620 3 0 {name=l139 lab=GND}
C {devices/lab_pin.sym} -780 -4580 2 0 {name=p464 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4620 0 0 {name=p466 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4580 0 0 {name=x17}
C {devices/lab_pin.sym} -840 -4810 0 0 {name=p467 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4690 0 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -590 -4760 0 0 {name=p468 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -460 -4690 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4620 0 0 {name=M18
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4620 3 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -460 -4580 2 0 {name=p470 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4620 0 0 {name=p471 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4580 0 0 {name=x18}
C {devices/lab_pin.sym} -520 -4810 0 0 {name=p472 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4690 0 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} -270 -4760 0 0 {name=p473 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -140 -4690 0 0 {name=Vmeas19 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4620 0 0 {name=M19
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4620 3 0 {name=l143 lab=GND}
C {devices/lab_pin.sym} -140 -4580 2 0 {name=p475 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4620 0 0 {name=p476 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4580 0 0 {name=x19}
C {devices/lab_pin.sym} -200 -4810 0 0 {name=p477 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4390 0 0 {name=l144 lab=GND}
C {devices/ammeter.sym} -2700 -4390 0 0 {name=Vmeas21 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4320 0 0 {name=M21
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4320 3 0 {name=l147 lab=GND}
C {devices/lab_pin.sym} -2700 -4280 2 0 {name=p480 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4320 0 0 {name=p481 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -4280 0 0 {name=x21}
C {devices/lab_pin.sym} -2760 -4510 0 0 {name=p482 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4390 0 0 {name=l148 lab=GND}
C {devices/ammeter.sym} -2380 -4390 0 0 {name=Vmeas22 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4320 0 0 {name=M22
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4320 3 0 {name=l149 lab=GND}
C {devices/lab_pin.sym} -2380 -4280 2 0 {name=p485 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4320 0 0 {name=p486 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -4280 0 0 {name=x22}
C {devices/lab_pin.sym} -2440 -4510 0 0 {name=p487 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4390 0 0 {name=l150 lab=GND}
C {devices/ammeter.sym} -2060 -4390 0 0 {name=Vmeas23 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4320 0 0 {name=M23
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4320 3 0 {name=l151 lab=GND}
C {devices/lab_pin.sym} -2060 -4280 2 0 {name=p490 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4320 0 0 {name=p491 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -4280 0 0 {name=x23}
C {devices/lab_pin.sym} -2120 -4510 0 0 {name=p492 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4390 0 0 {name=l152 lab=GND}
C {devices/ammeter.sym} -1740 -4390 0 0 {name=Vmeas24 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4320 0 0 {name=M24
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4320 3 0 {name=l153 lab=GND}
C {devices/lab_pin.sym} -1740 -4280 2 0 {name=p495 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4320 0 0 {name=p496 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4280 0 0 {name=x24}
C {devices/lab_pin.sym} -1800 -4510 0 0 {name=p497 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4390 0 0 {name=l154 lab=GND}
C {devices/ammeter.sym} -1420 -4390 0 0 {name=Vmeas25 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4320 0 0 {name=M25
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4320 3 0 {name=l155 lab=GND}
C {devices/lab_pin.sym} -1420 -4280 2 0 {name=p500 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4320 0 0 {name=p501 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -4280 0 0 {name=x25}
C {devices/lab_pin.sym} -1480 -4510 0 0 {name=p502 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4390 0 0 {name=l156 lab=GND}
C {devices/ammeter.sym} -1100 -4390 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4320 0 0 {name=M26
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4320 3 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -1100 -4280 2 0 {name=p505 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4320 0 0 {name=p506 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -4280 0 0 {name=x26}
C {devices/lab_pin.sym} -1160 -4510 0 0 {name=p507 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4390 0 0 {name=l158 lab=GND}
C {devices/ammeter.sym} -780 -4390 0 0 {name=Vmeas27 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4320 0 0 {name=M27
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4320 3 0 {name=l159 lab=GND}
C {devices/lab_pin.sym} -780 -4280 2 0 {name=p510 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4320 0 0 {name=p511 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -4280 0 0 {name=x27}
C {devices/lab_pin.sym} -840 -4510 0 0 {name=p512 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4390 0 0 {name=l160 lab=GND}
C {devices/ammeter.sym} -460 -4390 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4320 0 0 {name=M28
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4320 3 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -460 -4280 2 0 {name=p517 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4320 0 0 {name=p518 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4280 0 0 {name=x28}
C {devices/lab_pin.sym} -520 -4510 0 0 {name=p519 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4390 0 0 {name=l162 lab=GND}
C {devices/ammeter.sym} -140 -4390 0 0 {name=Vmeas29 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4320 0 0 {name=M29
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4320 3 0 {name=l163 lab=GND}
C {devices/lab_pin.sym} -140 -4280 2 0 {name=p522 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4320 0 0 {name=p523 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -4280 0 0 {name=x29}
C {devices/lab_pin.sym} -200 -4510 0 0 {name=p524 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -4090 0 0 {name=l164 lab=GND}
C {devices/ammeter.sym} -2700 -4090 0 0 {name=Vmeas31 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -4020 0 0 {name=M31
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -4020 3 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} -2700 -3980 2 0 {name=p527 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -4020 0 0 {name=p528 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3980 0 0 {name=x31}
C {devices/lab_pin.sym} -2760 -4210 0 0 {name=p529 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -4090 0 0 {name=l168 lab=GND}
C {devices/ammeter.sym} -2380 -4090 0 0 {name=Vmeas32 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -4020 0 0 {name=M32
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -4020 3 0 {name=l169 lab=GND}
C {devices/lab_pin.sym} -2380 -3980 2 0 {name=p532 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -4020 0 0 {name=p533 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3980 0 0 {name=x32}
C {devices/lab_pin.sym} -2440 -4210 0 0 {name=p534 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -4090 0 0 {name=l170 lab=GND}
C {devices/ammeter.sym} -2060 -4090 0 0 {name=Vmeas33 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -4020 0 0 {name=M33
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -4020 3 0 {name=l171 lab=GND}
C {devices/lab_pin.sym} -2060 -3980 2 0 {name=p537 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -4020 0 0 {name=p538 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3980 0 0 {name=x33}
C {devices/lab_pin.sym} -2120 -4210 0 0 {name=p539 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -4090 0 0 {name=l172 lab=GND}
C {devices/ammeter.sym} -1740 -4090 0 0 {name=Vmeas34 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4020 0 0 {name=M34
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4020 3 0 {name=l173 lab=GND}
C {devices/lab_pin.sym} -1740 -3980 2 0 {name=p542 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -4020 0 0 {name=p543 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3980 0 0 {name=x34}
C {devices/lab_pin.sym} -1800 -4210 0 0 {name=p544 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -4090 0 0 {name=l174 lab=GND}
C {devices/ammeter.sym} -1420 -4090 0 0 {name=Vmeas35 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -4020 0 0 {name=M35
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -4020 3 0 {name=l175 lab=GND}
C {devices/lab_pin.sym} -1420 -3980 2 0 {name=p547 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -4020 0 0 {name=p548 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3980 0 0 {name=x35}
C {devices/lab_pin.sym} -1480 -4210 0 0 {name=p549 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -4090 0 0 {name=l176 lab=GND}
C {devices/ammeter.sym} -1100 -4090 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -4020 0 0 {name=M36
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -4020 3 0 {name=l177 lab=GND}
C {devices/lab_pin.sym} -1100 -3980 2 0 {name=p552 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -4020 0 0 {name=p553 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3980 0 0 {name=x36}
C {devices/lab_pin.sym} -1160 -4210 0 0 {name=p554 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -4090 0 0 {name=l178 lab=GND}
C {devices/ammeter.sym} -780 -4090 0 0 {name=Vmeas37 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -4020 0 0 {name=M37
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -4020 3 0 {name=l179 lab=GND}
C {devices/lab_pin.sym} -780 -3980 2 0 {name=p557 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -4020 0 0 {name=p558 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3980 0 0 {name=x37}
C {devices/lab_pin.sym} -840 -4210 0 0 {name=p559 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -4090 0 0 {name=l180 lab=GND}
C {devices/ammeter.sym} -460 -4090 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4020 0 0 {name=M38
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4020 3 0 {name=l181 lab=GND}
C {devices/lab_pin.sym} -460 -3980 2 0 {name=p562 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4020 0 0 {name=p564 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3980 0 0 {name=x38}
C {devices/lab_pin.sym} -520 -4210 0 0 {name=p566 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -4090 0 0 {name=l182 lab=GND}
C {devices/ammeter.sym} -140 -4090 0 0 {name=Vmeas39 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -4020 0 0 {name=M39
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -4020 3 0 {name=l183 lab=GND}
C {devices/lab_pin.sym} -140 -3980 2 0 {name=p569 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -4020 0 0 {name=p570 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3980 0 0 {name=x39}
C {devices/lab_pin.sym} -200 -4210 0 0 {name=p571 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3790 0 0 {name=l184 lab=GND}
C {devices/ammeter.sym} -2700 -3790 0 0 {name=Vmeas41 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3720 0 0 {name=M41
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3720 3 0 {name=l187 lab=GND}
C {devices/lab_pin.sym} -2700 -3680 2 0 {name=p574 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3720 0 0 {name=p575 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3680 0 0 {name=x41}
C {devices/lab_pin.sym} -2760 -3910 0 0 {name=p576 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3790 0 0 {name=l188 lab=GND}
C {devices/ammeter.sym} -2380 -3790 0 0 {name=Vmeas42 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3720 0 0 {name=M42
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3720 3 0 {name=l189 lab=GND}
C {devices/lab_pin.sym} -2380 -3680 2 0 {name=p579 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3720 0 0 {name=p580 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3680 0 0 {name=x42}
C {devices/lab_pin.sym} -2440 -3910 0 0 {name=p581 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3790 0 0 {name=l190 lab=GND}
C {devices/ammeter.sym} -2060 -3790 0 0 {name=Vmeas43 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3720 0 0 {name=M43
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3720 3 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} -2060 -3680 2 0 {name=p584 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3720 0 0 {name=p585 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3680 0 0 {name=x43}
C {devices/lab_pin.sym} -2120 -3910 0 0 {name=p586 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3790 0 0 {name=l192 lab=GND}
C {devices/ammeter.sym} -1740 -3790 0 0 {name=Vmeas44 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3720 0 0 {name=M44
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3720 3 0 {name=l193 lab=GND}
C {devices/lab_pin.sym} -1740 -3680 2 0 {name=p589 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3720 0 0 {name=p590 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3680 0 0 {name=x44}
C {devices/lab_pin.sym} -1800 -3910 0 0 {name=p591 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3790 0 0 {name=l194 lab=GND}
C {devices/ammeter.sym} -1420 -3790 0 0 {name=Vmeas45 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3720 0 0 {name=M45
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3720 3 0 {name=l195 lab=GND}
C {devices/lab_pin.sym} -1420 -3680 2 0 {name=p594 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3720 0 0 {name=p595 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3680 0 0 {name=x45}
C {devices/lab_pin.sym} -1480 -3910 0 0 {name=p596 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3790 0 0 {name=l196 lab=GND}
C {devices/ammeter.sym} -1100 -3790 0 0 {name=Vmeas46 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3720 0 0 {name=M46
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3720 3 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -1100 -3680 2 0 {name=p599 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3720 0 0 {name=p600 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3680 0 0 {name=x46}
C {devices/lab_pin.sym} -1160 -3910 0 0 {name=p601 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3790 0 0 {name=l198 lab=GND}
C {devices/ammeter.sym} -780 -3790 0 0 {name=Vmeas47 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3720 0 0 {name=M47
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3720 3 0 {name=l199 lab=GND}
C {devices/lab_pin.sym} -780 -3680 2 0 {name=p604 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3720 0 0 {name=p605 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3680 0 0 {name=x47}
C {devices/lab_pin.sym} -840 -3910 0 0 {name=p606 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3790 0 0 {name=l200 lab=GND}
C {devices/ammeter.sym} -460 -3790 0 0 {name=Vmeas48 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3720 0 0 {name=M48
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3720 3 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -460 -3680 2 0 {name=p609 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3720 0 0 {name=p610 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3680 0 0 {name=x48}
C {devices/lab_pin.sym} -520 -3910 0 0 {name=p614 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3790 0 0 {name=l202 lab=GND}
C {devices/ammeter.sym} -140 -3790 0 0 {name=Vmeas49 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3720 0 0 {name=M49
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3720 3 0 {name=l203 lab=GND}
C {devices/lab_pin.sym} -140 -3680 2 0 {name=p618 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3720 0 0 {name=p619 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3680 0 0 {name=x49}
C {devices/lab_pin.sym} -200 -3910 0 0 {name=p620 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3490 0 0 {name=l204 lab=GND}
C {devices/lab_pin.sym} -2830 -3560 0 0 {name=p621 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -2700 -3490 0 0 {name=Vmeas51 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3420 0 0 {name=M51
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3420 3 0 {name=l207 lab=GND}
C {devices/lab_pin.sym} -2700 -3380 2 0 {name=p623 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3420 0 0 {name=p624 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3380 0 0 {name=x51}
C {devices/lab_pin.sym} -2760 -3610 0 0 {name=p625 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3490 0 0 {name=l208 lab=GND}
C {devices/ammeter.sym} -2380 -3490 0 0 {name=Vmeas52 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3420 0 0 {name=M52
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3420 3 0 {name=l209 lab=GND}
C {devices/lab_pin.sym} -2380 -3380 2 0 {name=p628 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3420 0 0 {name=p629 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3380 0 0 {name=x52}
C {devices/lab_pin.sym} -2440 -3610 0 0 {name=p630 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3490 0 0 {name=l210 lab=GND}
C {devices/ammeter.sym} -2060 -3490 0 0 {name=Vmeas53 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3420 0 0 {name=M53
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3420 3 0 {name=l211 lab=GND}
C {devices/lab_pin.sym} -2060 -3380 2 0 {name=p633 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3420 0 0 {name=p634 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3380 0 0 {name=x53}
C {devices/lab_pin.sym} -2120 -3610 0 0 {name=p635 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3490 0 0 {name=l212 lab=GND}
C {devices/ammeter.sym} -1740 -3490 0 0 {name=Vmeas54 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3420 0 0 {name=M54
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3420 3 0 {name=l213 lab=GND}
C {devices/lab_pin.sym} -1740 -3380 2 0 {name=p638 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3420 0 0 {name=p639 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3380 0 0 {name=x54}
C {devices/lab_pin.sym} -1800 -3610 0 0 {name=p640 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3490 0 0 {name=l214 lab=GND}
C {devices/ammeter.sym} -1420 -3490 0 0 {name=Vmeas55 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3420 0 0 {name=M55
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3420 3 0 {name=l215 lab=GND}
C {devices/lab_pin.sym} -1420 -3380 2 0 {name=p643 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3420 0 0 {name=p644 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3380 0 0 {name=x55}
C {devices/lab_pin.sym} -1480 -3610 0 0 {name=p645 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3490 0 0 {name=l216 lab=GND}
C {devices/ammeter.sym} -1100 -3490 0 0 {name=Vmeas56 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3420 0 0 {name=M56
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3420 3 0 {name=l217 lab=GND}
C {devices/lab_pin.sym} -1100 -3380 2 0 {name=p648 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3420 0 0 {name=p649 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3380 0 0 {name=x56}
C {devices/lab_pin.sym} -1160 -3610 0 0 {name=p650 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3490 0 0 {name=l218 lab=GND}
C {devices/ammeter.sym} -780 -3490 0 0 {name=Vmeas57 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3420 0 0 {name=M57
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3420 3 0 {name=l219 lab=GND}
C {devices/lab_pin.sym} -780 -3380 2 0 {name=p653 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3420 0 0 {name=p654 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3380 0 0 {name=x57}
C {devices/lab_pin.sym} -840 -3610 0 0 {name=p655 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3490 0 0 {name=l220 lab=GND}
C {devices/ammeter.sym} -460 -3490 0 0 {name=Vmeas58 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3420 0 0 {name=M58
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3420 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} -460 -3380 2 0 {name=p658 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3420 0 0 {name=p659 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3380 0 0 {name=x58}
C {devices/lab_pin.sym} -520 -3610 0 0 {name=p660 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3490 0 0 {name=l222 lab=GND}
C {devices/ammeter.sym} -140 -3490 0 0 {name=Vmeas59 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3420 0 0 {name=M59
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3420 3 0 {name=l223 lab=GND}
C {devices/lab_pin.sym} -140 -3380 2 0 {name=p675 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3420 0 0 {name=p680 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3380 0 0 {name=x59}
C {devices/lab_pin.sym} -200 -3610 0 0 {name=p687 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -3190 0 0 {name=l224 lab=GND}
C {devices/lab_pin.sym} -2830 -3260 0 0 {name=p692 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2700 -3190 0 0 {name=Vmeas61 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -3120 0 0 {name=M61
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -3120 3 0 {name=l227 lab=GND}
C {devices/lab_pin.sym} -2700 -3080 2 0 {name=p703 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -3120 0 0 {name=p704 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -3080 0 0 {name=x61}
C {devices/lab_pin.sym} -2760 -3310 0 0 {name=p705 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -3190 0 0 {name=l228 lab=GND}
C {devices/lab_pin.sym} -2510 -3260 0 0 {name=p706 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2380 -3190 0 0 {name=Vmeas62 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -3120 0 0 {name=M62
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -3120 3 0 {name=l229 lab=GND}
C {devices/lab_pin.sym} -2380 -3080 2 0 {name=p708 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -3120 0 0 {name=p709 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -3080 0 0 {name=x62}
C {devices/lab_pin.sym} -2440 -3310 0 0 {name=p710 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -3190 0 0 {name=l230 lab=GND}
C {devices/lab_pin.sym} -2190 -3260 0 0 {name=p711 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -2060 -3190 0 0 {name=Vmeas63 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -3120 0 0 {name=M63
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -3120 3 0 {name=l231 lab=GND}
C {devices/lab_pin.sym} -2060 -3080 2 0 {name=p713 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -3120 0 0 {name=p714 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -3080 0 0 {name=x63}
C {devices/lab_pin.sym} -2120 -3310 0 0 {name=p715 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -3190 0 0 {name=l232 lab=GND}
C {devices/lab_pin.sym} -1870 -3260 0 0 {name=p716 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1740 -3190 0 0 {name=Vmeas64 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3120 0 0 {name=M64
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3120 3 0 {name=l233 lab=GND}
C {devices/lab_pin.sym} -1740 -3080 2 0 {name=p718 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -3120 0 0 {name=p719 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3080 0 0 {name=x64}
C {devices/lab_pin.sym} -1800 -3310 0 0 {name=p720 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -3190 0 0 {name=l234 lab=GND}
C {devices/lab_pin.sym} -1550 -3260 0 0 {name=p721 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1420 -3190 0 0 {name=Vmeas65 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -3120 0 0 {name=M65
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -3120 3 0 {name=l235 lab=GND}
C {devices/lab_pin.sym} -1420 -3080 2 0 {name=p723 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -3120 0 0 {name=p724 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -3080 0 0 {name=x65}
C {devices/lab_pin.sym} -1480 -3310 0 0 {name=p725 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -3190 0 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} -1230 -3260 0 0 {name=p726 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -1100 -3190 0 0 {name=Vmeas66 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -3120 0 0 {name=M66
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -3120 3 0 {name=l237 lab=GND}
C {devices/lab_pin.sym} -1100 -3080 2 0 {name=p728 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -3120 0 0 {name=p729 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -3080 0 0 {name=x66}
C {devices/lab_pin.sym} -1160 -3310 0 0 {name=p730 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -3190 0 0 {name=l238 lab=GND}
C {devices/lab_pin.sym} -910 -3260 0 0 {name=p731 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -780 -3190 0 0 {name=Vmeas67 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -3120 0 0 {name=M67
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -3120 3 0 {name=l239 lab=GND}
C {devices/lab_pin.sym} -780 -3080 2 0 {name=p733 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -3120 0 0 {name=p734 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -3080 0 0 {name=x67}
C {devices/lab_pin.sym} -840 -3310 0 0 {name=p735 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -3190 0 0 {name=l240 lab=GND}
C {devices/lab_pin.sym} -590 -3260 0 0 {name=p736 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -460 -3190 0 0 {name=Vmeas68 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3120 0 0 {name=M68
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3120 3 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} -460 -3080 2 0 {name=p738 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3120 0 0 {name=p739 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3080 0 0 {name=x68}
C {devices/lab_pin.sym} -520 -3310 0 0 {name=p740 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -3190 0 0 {name=l242 lab=GND}
C {devices/lab_pin.sym} -270 -3260 0 0 {name=p741 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -140 -3190 0 0 {name=Vmeas69 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -3120 0 0 {name=M69
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -3120 3 0 {name=l243 lab=GND}
C {devices/lab_pin.sym} -140 -3080 2 0 {name=p743 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -3120 0 0 {name=p744 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -3080 0 0 {name=x69}
C {devices/lab_pin.sym} -200 -3310 0 0 {name=p745 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2890 0 0 {name=l244 lab=GND}
C {devices/lab_pin.sym} -2830 -2960 0 0 {name=p746 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2700 -2890 0 0 {name=Vmeas71 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2820 0 0 {name=M71
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2820 3 0 {name=l259 lab=GND}
C {devices/lab_pin.sym} -2700 -2780 2 0 {name=p748 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2820 0 0 {name=p749 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2780 0 0 {name=x71}
C {devices/lab_pin.sym} -2760 -3010 0 0 {name=p750 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2890 0 0 {name=l260 lab=GND}
C {devices/lab_pin.sym} -2510 -2960 0 0 {name=p751 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2380 -2890 0 0 {name=Vmeas72 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2820 0 0 {name=M72
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2820 3 0 {name=l261 lab=GND}
C {devices/lab_pin.sym} -2380 -2780 2 0 {name=p753 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2820 0 0 {name=p754 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2780 0 0 {name=x72}
C {devices/lab_pin.sym} -2440 -3010 0 0 {name=p755 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2890 0 0 {name=l262 lab=GND}
C {devices/lab_pin.sym} -2190 -2960 0 0 {name=p756 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -2060 -2890 0 0 {name=Vmeas73 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2820 0 0 {name=M73
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2820 3 0 {name=l263 lab=GND}
C {devices/lab_pin.sym} -2060 -2780 2 0 {name=p758 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2820 0 0 {name=p759 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2780 0 0 {name=x73}
C {devices/lab_pin.sym} -2120 -3010 0 0 {name=p760 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2890 0 0 {name=l264 lab=GND}
C {devices/lab_pin.sym} -1870 -2960 0 0 {name=p761 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1740 -2890 0 0 {name=Vmeas74 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2820 0 0 {name=M74
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2820 3 0 {name=l265 lab=GND}
C {devices/lab_pin.sym} -1740 -2780 2 0 {name=p763 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2820 0 0 {name=p764 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2780 0 0 {name=x74}
C {devices/lab_pin.sym} -1800 -3010 0 0 {name=p765 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2890 0 0 {name=l266 lab=GND}
C {devices/lab_pin.sym} -1550 -2960 0 0 {name=p766 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1420 -2890 0 0 {name=Vmeas75 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2820 0 0 {name=M75
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2820 3 0 {name=l267 lab=GND}
C {devices/lab_pin.sym} -1420 -2780 2 0 {name=p768 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2820 0 0 {name=p769 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2780 0 0 {name=x75}
C {devices/lab_pin.sym} -1480 -3010 0 0 {name=p770 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2890 0 0 {name=l268 lab=GND}
C {devices/lab_pin.sym} -1230 -2960 0 0 {name=p771 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -1100 -2890 0 0 {name=Vmeas76 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2820 0 0 {name=M76
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2820 3 0 {name=l269 lab=GND}
C {devices/lab_pin.sym} -1100 -2780 2 0 {name=p773 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2820 0 0 {name=p774 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2780 0 0 {name=x76}
C {devices/lab_pin.sym} -1160 -3010 0 0 {name=p775 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2890 0 0 {name=l270 lab=GND}
C {devices/lab_pin.sym} -910 -2960 0 0 {name=p776 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -780 -2890 0 0 {name=Vmeas77 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2820 0 0 {name=M77
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2820 3 0 {name=l271 lab=GND}
C {devices/lab_pin.sym} -780 -2780 2 0 {name=p778 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2820 0 0 {name=p779 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2780 0 0 {name=x77}
C {devices/lab_pin.sym} -840 -3010 0 0 {name=p780 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2890 0 0 {name=l272 lab=GND}
C {devices/lab_pin.sym} -590 -2960 0 0 {name=p781 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -460 -2890 0 0 {name=Vmeas78 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2820 0 0 {name=M78
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2820 3 0 {name=l273 lab=GND}
C {devices/lab_pin.sym} -460 -2780 2 0 {name=p783 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2820 0 0 {name=p784 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2780 0 0 {name=x78}
C {devices/lab_pin.sym} -520 -3010 0 0 {name=p785 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2890 0 0 {name=l274 lab=GND}
C {devices/lab_pin.sym} -270 -2960 0 0 {name=p786 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -140 -2890 0 0 {name=Vmeas79 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2820 0 0 {name=M79
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2820 3 0 {name=l275 lab=GND}
C {devices/lab_pin.sym} -140 -2780 2 0 {name=p788 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2820 0 0 {name=p789 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2780 0 0 {name=x79}
C {devices/lab_pin.sym} -200 -3010 0 0 {name=p790 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2590 0 0 {name=l276 lab=GND}
C {devices/lab_pin.sym} -2830 -2660 0 0 {name=p791 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2700 -2590 0 0 {name=Vmeas81 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2520 0 0 {name=M81
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2520 3 0 {name=l277 lab=GND}
C {devices/lab_pin.sym} -2700 -2480 2 0 {name=p793 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2520 0 0 {name=p794 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2480 0 0 {name=x81}
C {devices/lab_pin.sym} -2760 -2710 0 0 {name=p795 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2590 0 0 {name=l278 lab=GND}
C {devices/lab_pin.sym} -2510 -2660 0 0 {name=p796 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2380 -2590 0 0 {name=Vmeas82 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2520 0 0 {name=M82
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2520 3 0 {name=l279 lab=GND}
C {devices/lab_pin.sym} -2380 -2480 2 0 {name=p798 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2520 0 0 {name=p799 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2480 0 0 {name=x82}
C {devices/lab_pin.sym} -2440 -2710 0 0 {name=p800 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2590 0 0 {name=l280 lab=GND}
C {devices/lab_pin.sym} -2190 -2660 0 0 {name=p801 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -2060 -2590 0 0 {name=Vmeas83 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2520 0 0 {name=M83
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2520 3 0 {name=l281 lab=GND}
C {devices/lab_pin.sym} -2060 -2480 2 0 {name=p803 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2520 0 0 {name=p804 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2480 0 0 {name=x83}
C {devices/lab_pin.sym} -2120 -2710 0 0 {name=p805 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2590 0 0 {name=l282 lab=GND}
C {devices/lab_pin.sym} -1870 -2660 0 0 {name=p806 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1740 -2590 0 0 {name=Vmeas84 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2520 0 0 {name=M84
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2520 3 0 {name=l283 lab=GND}
C {devices/lab_pin.sym} -1740 -2480 2 0 {name=p808 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2520 0 0 {name=p809 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2480 0 0 {name=x84}
C {devices/lab_pin.sym} -1800 -2710 0 0 {name=p810 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2590 0 0 {name=l284 lab=GND}
C {devices/lab_pin.sym} -1550 -2660 0 0 {name=p811 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1420 -2590 0 0 {name=Vmeas85 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2520 0 0 {name=M85
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2520 3 0 {name=l285 lab=GND}
C {devices/lab_pin.sym} -1420 -2480 2 0 {name=p813 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2520 0 0 {name=p814 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2480 0 0 {name=x85}
C {devices/lab_pin.sym} -1480 -2710 0 0 {name=p815 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2590 0 0 {name=l286 lab=GND}
C {devices/lab_pin.sym} -1230 -2660 0 0 {name=p816 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -1100 -2590 0 0 {name=Vmeas86 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2520 0 0 {name=M86
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2520 3 0 {name=l287 lab=GND}
C {devices/lab_pin.sym} -1100 -2480 2 0 {name=p818 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2520 0 0 {name=p819 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2480 0 0 {name=x86}
C {devices/lab_pin.sym} -1160 -2710 0 0 {name=p820 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2590 0 0 {name=l288 lab=GND}
C {devices/lab_pin.sym} -910 -2660 0 0 {name=p821 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -780 -2590 0 0 {name=Vmeas87 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2520 0 0 {name=M87
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2520 3 0 {name=l289 lab=GND}
C {devices/lab_pin.sym} -780 -2480 2 0 {name=p823 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2520 0 0 {name=p824 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2480 0 0 {name=x87}
C {devices/lab_pin.sym} -840 -2710 0 0 {name=p825 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2590 0 0 {name=l290 lab=GND}
C {devices/lab_pin.sym} -590 -2660 0 0 {name=p826 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -460 -2590 0 0 {name=Vmeas88 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2520 0 0 {name=M88
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2520 3 0 {name=l291 lab=GND}
C {devices/lab_pin.sym} -460 -2480 2 0 {name=p828 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2520 0 0 {name=p829 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2480 0 0 {name=x88}
C {devices/lab_pin.sym} -520 -2710 0 0 {name=p830 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2590 0 0 {name=l292 lab=GND}
C {devices/lab_pin.sym} -270 -2660 0 0 {name=p831 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -140 -2590 0 0 {name=Vmeas89 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2520 0 0 {name=M89
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2520 3 0 {name=l293 lab=GND}
C {devices/lab_pin.sym} -140 -2480 2 0 {name=p833 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2520 0 0 {name=p834 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2480 0 0 {name=x89}
C {devices/lab_pin.sym} -200 -2710 0 0 {name=p835 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -2290 0 0 {name=l294 lab=GND}
C {devices/lab_pin.sym} -2830 -2360 0 0 {name=p836 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2700 -2290 0 0 {name=Vmeas91 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -2220 0 0 {name=M91
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -2220 3 0 {name=l295 lab=GND}
C {devices/lab_pin.sym} -2700 -2180 2 0 {name=p838 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -2220 0 0 {name=p839 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -2180 0 0 {name=x91}
C {devices/lab_pin.sym} -2760 -2410 0 0 {name=p840 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -2290 0 0 {name=l296 lab=GND}
C {devices/lab_pin.sym} -2510 -2360 0 0 {name=p841 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2380 -2290 0 0 {name=Vmeas92 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -2220 0 0 {name=M92
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -2220 3 0 {name=l297 lab=GND}
C {devices/lab_pin.sym} -2380 -2180 2 0 {name=p843 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -2220 0 0 {name=p844 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -2180 0 0 {name=x92}
C {devices/lab_pin.sym} -2440 -2410 0 0 {name=p845 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -2290 0 0 {name=l298 lab=GND}
C {devices/lab_pin.sym} -2190 -2360 0 0 {name=p846 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -2060 -2290 0 0 {name=Vmeas93 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -2220 0 0 {name=M93
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -2220 3 0 {name=l299 lab=GND}
C {devices/lab_pin.sym} -2060 -2180 2 0 {name=p848 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -2220 0 0 {name=p849 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -2180 0 0 {name=x93}
C {devices/lab_pin.sym} -2120 -2410 0 0 {name=p850 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -2290 0 0 {name=l300 lab=GND}
C {devices/lab_pin.sym} -1870 -2360 0 0 {name=p851 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1740 -2290 0 0 {name=Vmeas94 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2220 0 0 {name=M94
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2220 3 0 {name=l301 lab=GND}
C {devices/lab_pin.sym} -1740 -2180 2 0 {name=p853 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -2220 0 0 {name=p854 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2180 0 0 {name=x94}
C {devices/lab_pin.sym} -1800 -2410 0 0 {name=p855 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -2290 0 0 {name=l302 lab=GND}
C {devices/lab_pin.sym} -1550 -2360 0 0 {name=p856 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1420 -2290 0 0 {name=Vmeas95 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -2220 0 0 {name=M95
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -2220 3 0 {name=l303 lab=GND}
C {devices/lab_pin.sym} -1420 -2180 2 0 {name=p858 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -2220 0 0 {name=p859 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -2180 0 0 {name=x95}
C {devices/lab_pin.sym} -1480 -2410 0 0 {name=p860 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -2290 0 0 {name=l304 lab=GND}
C {devices/lab_pin.sym} -1230 -2360 0 0 {name=p861 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1100 -2290 0 0 {name=Vmeas96 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -2220 0 0 {name=M96
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -2220 3 0 {name=l305 lab=GND}
C {devices/lab_pin.sym} -1100 -2180 2 0 {name=p863 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -2220 0 0 {name=p864 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -2180 0 0 {name=x96}
C {devices/lab_pin.sym} -1160 -2410 0 0 {name=p865 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -2290 0 0 {name=l306 lab=GND}
C {devices/lab_pin.sym} -910 -2360 0 0 {name=p866 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -780 -2290 0 0 {name=Vmeas97 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -2220 0 0 {name=M97
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -2220 3 0 {name=l307 lab=GND}
C {devices/lab_pin.sym} -780 -2180 2 0 {name=p868 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -2220 0 0 {name=p869 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -2180 0 0 {name=x97}
C {devices/lab_pin.sym} -840 -2410 0 0 {name=p870 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -2290 0 0 {name=l308 lab=GND}
C {devices/lab_pin.sym} -590 -2360 0 0 {name=p871 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -460 -2290 0 0 {name=Vmeas98 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2220 0 0 {name=M98
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2220 3 0 {name=l309 lab=GND}
C {devices/lab_pin.sym} -460 -2180 2 0 {name=p873 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2220 0 0 {name=p874 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2180 0 0 {name=x98}
C {devices/lab_pin.sym} -520 -2410 0 0 {name=p875 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -2290 0 0 {name=l310 lab=GND}
C {devices/lab_pin.sym} -270 -2360 0 0 {name=p876 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -140 -2290 0 0 {name=Vmeas99 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -2220 0 0 {name=M99
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -2220 3 0 {name=l311 lab=GND}
C {devices/lab_pin.sym} -140 -2180 2 0 {name=p878 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -2220 0 0 {name=p879 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -2180 0 0 {name=x99}
C {devices/lab_pin.sym} -200 -2410 0 0 {name=p880 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1990 0 0 {name=l312 lab=GND}
C {devices/lab_pin.sym} -2830 -2060 0 0 {name=p881 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2700 -1990 0 0 {name=Vmeas101 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1920 0 0 {name=M101
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1920 3 0 {name=l313 lab=GND}
C {devices/lab_pin.sym} -2700 -1880 2 0 {name=p883 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1920 0 0 {name=p884 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1880 0 0 {name=x101}
C {devices/lab_pin.sym} -2760 -2110 0 0 {name=p885 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1990 0 0 {name=l314 lab=GND}
C {devices/lab_pin.sym} -2510 -2060 0 0 {name=p886 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2380 -1990 0 0 {name=Vmeas102 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1920 0 0 {name=M102
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1920 3 0 {name=l315 lab=GND}
C {devices/lab_pin.sym} -2380 -1880 2 0 {name=p888 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1920 0 0 {name=p889 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1880 0 0 {name=x102}
C {devices/lab_pin.sym} -2440 -2110 0 0 {name=p890 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1990 0 0 {name=l316 lab=GND}
C {devices/lab_pin.sym} -2190 -2060 0 0 {name=p891 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -2060 -1990 0 0 {name=Vmeas103 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1920 0 0 {name=M103
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1920 3 0 {name=l317 lab=GND}
C {devices/lab_pin.sym} -2060 -1880 2 0 {name=p893 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1920 0 0 {name=p894 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1880 0 0 {name=x103}
C {devices/lab_pin.sym} -2120 -2110 0 0 {name=p895 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1990 0 0 {name=l318 lab=GND}
C {devices/lab_pin.sym} -1870 -2060 0 0 {name=p896 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1740 -1990 0 0 {name=Vmeas104 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1920 0 0 {name=M104
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1920 3 0 {name=l319 lab=GND}
C {devices/lab_pin.sym} -1740 -1880 2 0 {name=p898 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1920 0 0 {name=p899 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1880 0 0 {name=x104}
C {devices/lab_pin.sym} -1800 -2110 0 0 {name=p900 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1990 0 0 {name=l320 lab=GND}
C {devices/lab_pin.sym} -1550 -2060 0 0 {name=p901 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1420 -1990 0 0 {name=Vmeas105 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1920 0 0 {name=M105
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1920 3 0 {name=l321 lab=GND}
C {devices/lab_pin.sym} -1420 -1880 2 0 {name=p903 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1920 0 0 {name=p904 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1880 0 0 {name=x105}
C {devices/lab_pin.sym} -1480 -2110 0 0 {name=p905 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1990 0 0 {name=l322 lab=GND}
C {devices/lab_pin.sym} -1230 -2060 0 0 {name=p906 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -1100 -1990 0 0 {name=Vmeas106 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1920 0 0 {name=M106
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1920 3 0 {name=l323 lab=GND}
C {devices/lab_pin.sym} -1100 -1880 2 0 {name=p908 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1920 0 0 {name=p909 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1880 0 0 {name=x106}
C {devices/lab_pin.sym} -1160 -2110 0 0 {name=p910 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1990 0 0 {name=l324 lab=GND}
C {devices/lab_pin.sym} -910 -2060 0 0 {name=p911 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -780 -1990 0 0 {name=Vmeas107 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1920 0 0 {name=M107
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1920 3 0 {name=l325 lab=GND}
C {devices/lab_pin.sym} -780 -1880 2 0 {name=p913 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1920 0 0 {name=p914 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1880 0 0 {name=x107}
C {devices/lab_pin.sym} -840 -2110 0 0 {name=p915 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1990 0 0 {name=l326 lab=GND}
C {devices/lab_pin.sym} -590 -2060 0 0 {name=p916 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -460 -1990 0 0 {name=Vmeas108 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1920 0 0 {name=M108
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1920 3 0 {name=l327 lab=GND}
C {devices/lab_pin.sym} -460 -1880 2 0 {name=p918 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1920 0 0 {name=p919 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1880 0 0 {name=x108}
C {devices/lab_pin.sym} -520 -2110 0 0 {name=p920 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1990 0 0 {name=l328 lab=GND}
C {devices/lab_pin.sym} -270 -2060 0 0 {name=p921 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -140 -1990 0 0 {name=Vmeas109 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1920 0 0 {name=M109
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1920 3 0 {name=l329 lab=GND}
C {devices/lab_pin.sym} -140 -1880 2 0 {name=p923 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1920 0 0 {name=p924 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1880 0 0 {name=x109}
C {devices/lab_pin.sym} -200 -2110 0 0 {name=p925 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1690 0 0 {name=l330 lab=GND}
C {devices/lab_pin.sym} -2830 -1760 0 0 {name=p926 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2700 -1690 0 0 {name=Vmeas111 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1620 0 0 {name=M111
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1620 3 0 {name=l331 lab=GND}
C {devices/lab_pin.sym} -2700 -1580 2 0 {name=p928 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1620 0 0 {name=p929 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1580 0 0 {name=x111}
C {devices/lab_pin.sym} -2760 -1810 0 0 {name=p930 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1690 0 0 {name=l332 lab=GND}
C {devices/lab_pin.sym} -2510 -1760 0 0 {name=p931 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2380 -1690 0 0 {name=Vmeas112 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1620 0 0 {name=M112
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1620 3 0 {name=l333 lab=GND}
C {devices/lab_pin.sym} -2380 -1580 2 0 {name=p933 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1620 0 0 {name=p934 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1580 0 0 {name=x112}
C {devices/lab_pin.sym} -2440 -1810 0 0 {name=p935 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1690 0 0 {name=l334 lab=GND}
C {devices/lab_pin.sym} -2190 -1760 0 0 {name=p936 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -2060 -1690 0 0 {name=Vmeas113 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1620 0 0 {name=M113
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1620 3 0 {name=l335 lab=GND}
C {devices/lab_pin.sym} -2060 -1580 2 0 {name=p938 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1620 0 0 {name=p939 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1580 0 0 {name=x113}
C {devices/lab_pin.sym} -2120 -1810 0 0 {name=p940 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1690 0 0 {name=l336 lab=GND}
C {devices/lab_pin.sym} -1870 -1760 0 0 {name=p941 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1740 -1690 0 0 {name=Vmeas114 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1620 0 0 {name=M114
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1620 3 0 {name=l337 lab=GND}
C {devices/lab_pin.sym} -1740 -1580 2 0 {name=p943 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1620 0 0 {name=p944 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1580 0 0 {name=x114}
C {devices/lab_pin.sym} -1800 -1810 0 0 {name=p945 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1690 0 0 {name=l338 lab=GND}
C {devices/lab_pin.sym} -1550 -1760 0 0 {name=p946 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1420 -1690 0 0 {name=Vmeas115 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1620 0 0 {name=M115
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1620 3 0 {name=l339 lab=GND}
C {devices/lab_pin.sym} -1420 -1580 2 0 {name=p948 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1620 0 0 {name=p949 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1580 0 0 {name=x115}
C {devices/lab_pin.sym} -1480 -1810 0 0 {name=p950 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1690 0 0 {name=l340 lab=GND}
C {devices/lab_pin.sym} -1230 -1760 0 0 {name=p951 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -1100 -1690 0 0 {name=Vmeas116 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1620 0 0 {name=M116
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1620 3 0 {name=l341 lab=GND}
C {devices/lab_pin.sym} -1100 -1580 2 0 {name=p953 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1620 0 0 {name=p954 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1580 0 0 {name=x116}
C {devices/lab_pin.sym} -1160 -1810 0 0 {name=p955 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1690 0 0 {name=l342 lab=GND}
C {devices/lab_pin.sym} -910 -1760 0 0 {name=p956 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -780 -1690 0 0 {name=Vmeas117 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1620 0 0 {name=M117
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1620 3 0 {name=l343 lab=GND}
C {devices/lab_pin.sym} -780 -1580 2 0 {name=p958 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1620 0 0 {name=p959 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1580 0 0 {name=x117}
C {devices/lab_pin.sym} -840 -1810 0 0 {name=p960 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1690 0 0 {name=l344 lab=GND}
C {devices/lab_pin.sym} -590 -1760 0 0 {name=p961 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -460 -1690 0 0 {name=Vmeas118 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1620 0 0 {name=M118
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1620 3 0 {name=l345 lab=GND}
C {devices/lab_pin.sym} -460 -1580 2 0 {name=p963 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1620 0 0 {name=p964 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1580 0 0 {name=x118}
C {devices/lab_pin.sym} -520 -1810 0 0 {name=p965 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1690 0 0 {name=l346 lab=GND}
C {devices/lab_pin.sym} -270 -1760 0 0 {name=p966 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -140 -1690 0 0 {name=Vmeas119 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1620 0 0 {name=M119
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1620 3 0 {name=l347 lab=GND}
C {devices/lab_pin.sym} -140 -1580 2 0 {name=p968 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1620 0 0 {name=p969 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1580 0 0 {name=x119}
C {devices/lab_pin.sym} -200 -1810 0 0 {name=p970 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1390 0 0 {name=l348 lab=GND}
C {devices/lab_pin.sym} -2830 -1460 0 0 {name=p971 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2700 -1390 0 0 {name=Vmeas121 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1320 0 0 {name=M121
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1320 3 0 {name=l349 lab=GND}
C {devices/lab_pin.sym} -2700 -1280 2 0 {name=p973 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1320 0 0 {name=p974 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -1280 0 0 {name=x121}
C {devices/lab_pin.sym} -2760 -1510 0 0 {name=p975 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1390 0 0 {name=l350 lab=GND}
C {devices/lab_pin.sym} -2510 -1460 0 0 {name=p976 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2380 -1390 0 0 {name=Vmeas122 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1320 0 0 {name=M122
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1320 3 0 {name=l351 lab=GND}
C {devices/lab_pin.sym} -2380 -1280 2 0 {name=p978 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1320 0 0 {name=p979 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -1280 0 0 {name=x122}
C {devices/lab_pin.sym} -2440 -1510 0 0 {name=p980 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1390 0 0 {name=l352 lab=GND}
C {devices/lab_pin.sym} -2190 -1460 0 0 {name=p981 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -2060 -1390 0 0 {name=Vmeas123 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1320 0 0 {name=M123
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1320 3 0 {name=l353 lab=GND}
C {devices/lab_pin.sym} -2060 -1280 2 0 {name=p983 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1320 0 0 {name=p984 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -1280 0 0 {name=x123}
C {devices/lab_pin.sym} -2120 -1510 0 0 {name=p985 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1390 0 0 {name=l354 lab=GND}
C {devices/lab_pin.sym} -1870 -1460 0 0 {name=p986 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1740 -1390 0 0 {name=Vmeas124 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1320 0 0 {name=M124
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1320 3 0 {name=l355 lab=GND}
C {devices/lab_pin.sym} -1740 -1280 2 0 {name=p988 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1320 0 0 {name=p989 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1280 0 0 {name=x124}
C {devices/lab_pin.sym} -1800 -1510 0 0 {name=p990 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1390 0 0 {name=l356 lab=GND}
C {devices/lab_pin.sym} -1550 -1460 0 0 {name=p991 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1420 -1390 0 0 {name=Vmeas125 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1320 0 0 {name=M125
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1320 3 0 {name=l357 lab=GND}
C {devices/lab_pin.sym} -1420 -1280 2 0 {name=p993 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1320 0 0 {name=p994 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -1280 0 0 {name=x125}
C {devices/lab_pin.sym} -1480 -1510 0 0 {name=p995 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1390 0 0 {name=l358 lab=GND}
C {devices/lab_pin.sym} -1230 -1460 0 0 {name=p996 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -1100 -1390 0 0 {name=Vmeas126 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1320 0 0 {name=M126
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1320 3 0 {name=l359 lab=GND}
C {devices/lab_pin.sym} -1100 -1280 2 0 {name=p998 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1320 0 0 {name=p999 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -1280 0 0 {name=x126}
C {devices/lab_pin.sym} -1160 -1510 0 0 {name=p1000 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1390 0 0 {name=l360 lab=GND}
C {devices/lab_pin.sym} -910 -1460 0 0 {name=p1001 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -780 -1390 0 0 {name=Vmeas127 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1320 0 0 {name=M127
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1320 3 0 {name=l361 lab=GND}
C {devices/lab_pin.sym} -780 -1280 2 0 {name=p1003 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1320 0 0 {name=p1004 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -1280 0 0 {name=x127}
C {devices/lab_pin.sym} -840 -1510 0 0 {name=p1005 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1390 0 0 {name=l362 lab=GND}
C {devices/lab_pin.sym} -590 -1460 0 0 {name=p1006 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -460 -1390 0 0 {name=Vmeas128 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1320 0 0 {name=M128
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1320 3 0 {name=l363 lab=GND}
C {devices/lab_pin.sym} -460 -1280 2 0 {name=p1008 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1320 0 0 {name=p1009 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1280 0 0 {name=x128}
C {devices/lab_pin.sym} -520 -1510 0 0 {name=p1010 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1390 0 0 {name=l364 lab=GND}
C {devices/lab_pin.sym} -270 -1460 0 0 {name=p1011 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -140 -1390 0 0 {name=Vmeas129 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1320 0 0 {name=M129
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1320 3 0 {name=l365 lab=GND}
C {devices/lab_pin.sym} -140 -1280 2 0 {name=p1013 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1320 0 0 {name=p1014 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -1280 0 0 {name=x129}
C {devices/lab_pin.sym} -200 -1510 0 0 {name=p1015 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -1090 0 0 {name=l366 lab=GND}
C {devices/lab_pin.sym} -2830 -1160 0 0 {name=p1016 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2700 -1090 0 0 {name=Vmeas131 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -1020 0 0 {name=M131
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -1020 3 0 {name=l367 lab=GND}
C {devices/lab_pin.sym} -2700 -980 2 0 {name=p1018 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -1020 0 0 {name=p1019 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -980 0 0 {name=x131}
C {devices/lab_pin.sym} -2760 -1210 0 0 {name=p1020 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -1090 0 0 {name=l368 lab=GND}
C {devices/lab_pin.sym} -2510 -1160 0 0 {name=p1021 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2380 -1090 0 0 {name=Vmeas132 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -1020 0 0 {name=M132
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -1020 3 0 {name=l369 lab=GND}
C {devices/lab_pin.sym} -2380 -980 2 0 {name=p1023 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -1020 0 0 {name=p1024 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -980 0 0 {name=x132}
C {devices/lab_pin.sym} -2440 -1210 0 0 {name=p1025 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -1090 0 0 {name=l370 lab=GND}
C {devices/lab_pin.sym} -2190 -1160 0 0 {name=p1026 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -2060 -1090 0 0 {name=Vmeas133 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -1020 0 0 {name=M133
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -1020 3 0 {name=l371 lab=GND}
C {devices/lab_pin.sym} -2060 -980 2 0 {name=p1028 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -1020 0 0 {name=p1029 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -980 0 0 {name=x133}
C {devices/lab_pin.sym} -2120 -1210 0 0 {name=p1030 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -1090 0 0 {name=l372 lab=GND}
C {devices/lab_pin.sym} -1870 -1160 0 0 {name=p1031 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1740 -1090 0 0 {name=Vmeas134 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1020 0 0 {name=M134
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1020 3 0 {name=l373 lab=GND}
C {devices/lab_pin.sym} -1740 -980 2 0 {name=p1033 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -1020 0 0 {name=p1034 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -980 0 0 {name=x134}
C {devices/lab_pin.sym} -1800 -1210 0 0 {name=p1035 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -1090 0 0 {name=l374 lab=GND}
C {devices/lab_pin.sym} -1550 -1160 0 0 {name=p1036 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1420 -1090 0 0 {name=Vmeas135 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -1020 0 0 {name=M135
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -1020 3 0 {name=l375 lab=GND}
C {devices/lab_pin.sym} -1420 -980 2 0 {name=p1038 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -1020 0 0 {name=p1039 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -980 0 0 {name=x135}
C {devices/lab_pin.sym} -1480 -1210 0 0 {name=p1040 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -1090 0 0 {name=l376 lab=GND}
C {devices/lab_pin.sym} -1230 -1160 0 0 {name=p1041 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -1100 -1090 0 0 {name=Vmeas136 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -1020 0 0 {name=M136
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -1020 3 0 {name=l377 lab=GND}
C {devices/lab_pin.sym} -1100 -980 2 0 {name=p1043 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -1020 0 0 {name=p1044 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -980 0 0 {name=x136}
C {devices/lab_pin.sym} -1160 -1210 0 0 {name=p1045 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -1090 0 0 {name=l378 lab=GND}
C {devices/lab_pin.sym} -910 -1160 0 0 {name=p1046 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -780 -1090 0 0 {name=Vmeas137 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -1020 0 0 {name=M137
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -1020 3 0 {name=l379 lab=GND}
C {devices/lab_pin.sym} -780 -980 2 0 {name=p1048 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -1020 0 0 {name=p1049 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -980 0 0 {name=x137}
C {devices/lab_pin.sym} -840 -1210 0 0 {name=p1050 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -1090 0 0 {name=l380 lab=GND}
C {devices/lab_pin.sym} -590 -1160 0 0 {name=p1051 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -460 -1090 0 0 {name=Vmeas138 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1020 0 0 {name=M138
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1020 3 0 {name=l381 lab=GND}
C {devices/lab_pin.sym} -460 -980 2 0 {name=p1053 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1020 0 0 {name=p1054 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -980 0 0 {name=x138}
C {devices/lab_pin.sym} -520 -1210 0 0 {name=p1055 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -1090 0 0 {name=l382 lab=GND}
C {devices/lab_pin.sym} -270 -1160 0 0 {name=p1056 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -140 -1090 0 0 {name=Vmeas139 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -1020 0 0 {name=M139
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -1020 3 0 {name=l383 lab=GND}
C {devices/lab_pin.sym} -140 -980 2 0 {name=p1058 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -1020 0 0 {name=p1059 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -980 0 0 {name=x139}
C {devices/lab_pin.sym} -200 -1210 0 0 {name=p1060 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -790 0 0 {name=l384 lab=GND}
C {devices/lab_pin.sym} -2830 -860 0 0 {name=p1061 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2700 -790 0 0 {name=Vmeas141 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -720 0 0 {name=M141
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -720 3 0 {name=l385 lab=GND}
C {devices/lab_pin.sym} -2700 -680 2 0 {name=p1063 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -720 0 0 {name=p1064 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -680 0 0 {name=x141}
C {devices/lab_pin.sym} -2760 -910 0 0 {name=p1065 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -790 0 0 {name=l386 lab=GND}
C {devices/lab_pin.sym} -2510 -860 0 0 {name=p1066 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2380 -790 0 0 {name=Vmeas142 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -720 0 0 {name=M142
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -720 3 0 {name=l387 lab=GND}
C {devices/lab_pin.sym} -2380 -680 2 0 {name=p1068 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -720 0 0 {name=p1069 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -680 0 0 {name=x142}
C {devices/lab_pin.sym} -2440 -910 0 0 {name=p1070 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -790 0 0 {name=l388 lab=GND}
C {devices/lab_pin.sym} -2190 -860 0 0 {name=p1071 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -2060 -790 0 0 {name=Vmeas143 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -720 0 0 {name=M143
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -720 3 0 {name=l389 lab=GND}
C {devices/lab_pin.sym} -2060 -680 2 0 {name=p1073 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -720 0 0 {name=p1074 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -680 0 0 {name=x143}
C {devices/lab_pin.sym} -2120 -910 0 0 {name=p1075 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -790 0 0 {name=l390 lab=GND}
C {devices/lab_pin.sym} -1870 -860 0 0 {name=p1076 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1740 -790 0 0 {name=Vmeas144 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -720 0 0 {name=M144
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -720 3 0 {name=l391 lab=GND}
C {devices/lab_pin.sym} -1740 -680 2 0 {name=p1078 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -720 0 0 {name=p1079 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -680 0 0 {name=x144}
C {devices/lab_pin.sym} -1800 -910 0 0 {name=p1080 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -790 0 0 {name=l392 lab=GND}
C {devices/lab_pin.sym} -1550 -860 0 0 {name=p1081 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1420 -790 0 0 {name=Vmeas145 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -720 0 0 {name=M145
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -720 3 0 {name=l393 lab=GND}
C {devices/lab_pin.sym} -1420 -680 2 0 {name=p1083 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -720 0 0 {name=p1084 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -680 0 0 {name=x145}
C {devices/lab_pin.sym} -1480 -910 0 0 {name=p1085 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -790 0 0 {name=l394 lab=GND}
C {devices/lab_pin.sym} -1230 -860 0 0 {name=p1086 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -1100 -790 0 0 {name=Vmeas146 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -720 0 0 {name=M146
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -720 3 0 {name=l395 lab=GND}
C {devices/lab_pin.sym} -1100 -680 2 0 {name=p1088 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -720 0 0 {name=p1089 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -680 0 0 {name=x146}
C {devices/lab_pin.sym} -1160 -910 0 0 {name=p1090 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -790 0 0 {name=l396 lab=GND}
C {devices/lab_pin.sym} -910 -860 0 0 {name=p1091 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -780 -790 0 0 {name=Vmeas147 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -720 0 0 {name=M147
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -720 3 0 {name=l397 lab=GND}
C {devices/lab_pin.sym} -780 -680 2 0 {name=p1093 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -720 0 0 {name=p1094 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -680 0 0 {name=x147}
C {devices/lab_pin.sym} -840 -910 0 0 {name=p1095 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -790 0 0 {name=l398 lab=GND}
C {devices/lab_pin.sym} -590 -860 0 0 {name=p1096 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -460 -790 0 0 {name=Vmeas148 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -720 0 0 {name=M148
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -720 3 0 {name=l399 lab=GND}
C {devices/lab_pin.sym} -460 -680 2 0 {name=p1098 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -720 0 0 {name=p1099 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -680 0 0 {name=x148}
C {devices/lab_pin.sym} -520 -910 0 0 {name=p1100 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -790 0 0 {name=l400 lab=GND}
C {devices/lab_pin.sym} -270 -860 0 0 {name=p1101 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -140 -790 0 0 {name=Vmeas149 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -720 0 0 {name=M149
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -720 3 0 {name=l401 lab=GND}
C {devices/lab_pin.sym} -140 -680 2 0 {name=p1103 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -720 0 0 {name=p1104 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -680 0 0 {name=x149}
C {devices/lab_pin.sym} -200 -910 0 0 {name=p1105 sig_type=std_logic lab=vdd_syn9}
C {devices/gnd.sym} -2760 -490 0 0 {name=l402 lab=GND}
C {devices/lab_pin.sym} -2830 -560 0 0 {name=p1106 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2700 -490 0 0 {name=Vmeas151 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -420 0 0 {name=M151
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2690 -420 3 0 {name=l403 lab=GND}
C {devices/lab_pin.sym} -2700 -380 2 0 {name=p1108 sig_type=std_logic lab=p1}
C {devices/lab_pin.sym} -2750 -420 0 0 {name=p1109 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2700 -380 0 0 {name=x151}
C {devices/lab_pin.sym} -2760 -610 0 0 {name=p1110 sig_type=std_logic lab=vdd_syn1}
C {devices/gnd.sym} -2440 -490 0 0 {name=l404 lab=GND}
C {devices/lab_pin.sym} -2510 -560 0 0 {name=p1111 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2380 -490 0 0 {name=Vmeas152 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2400 -420 0 0 {name=M152
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2370 -420 3 0 {name=l405 lab=GND}
C {devices/lab_pin.sym} -2380 -380 2 0 {name=p1113 sig_type=std_logic lab=p2}
C {devices/lab_pin.sym} -2430 -420 0 0 {name=p1114 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2380 -380 0 0 {name=x152}
C {devices/lab_pin.sym} -2440 -610 0 0 {name=p1115 sig_type=std_logic lab=vdd_syn2}
C {devices/gnd.sym} -2120 -490 0 0 {name=l406 lab=GND}
C {devices/lab_pin.sym} -2190 -560 0 0 {name=p1116 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -2060 -490 0 0 {name=Vmeas153 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -2080 -420 0 0 {name=M153
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -2050 -420 3 0 {name=l407 lab=GND}
C {devices/lab_pin.sym} -2060 -380 2 0 {name=p1118 sig_type=std_logic lab=p3}
C {devices/lab_pin.sym} -2110 -420 0 0 {name=p1119 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -2060 -380 0 0 {name=x153}
C {devices/lab_pin.sym} -2120 -610 0 0 {name=p1120 sig_type=std_logic lab=vdd_syn3}
C {devices/gnd.sym} -1800 -490 0 0 {name=l408 lab=GND}
C {devices/lab_pin.sym} -1870 -560 0 0 {name=p1121 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas154 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M154
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l409 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p1123 sig_type=std_logic lab=p4}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p1124 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x154}
C {devices/lab_pin.sym} -1800 -610 0 0 {name=p1125 sig_type=std_logic lab=vdd_syn4}
C {devices/gnd.sym} -1480 -490 0 0 {name=l410 lab=GND}
C {devices/lab_pin.sym} -1550 -560 0 0 {name=p1126 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1420 -490 0 0 {name=Vmeas155 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1440 -420 0 0 {name=M155
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1410 -420 3 0 {name=l411 lab=GND}
C {devices/lab_pin.sym} -1420 -380 2 0 {name=p1128 sig_type=std_logic lab=p5}
C {devices/lab_pin.sym} -1470 -420 0 0 {name=p1129 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1420 -380 0 0 {name=x155}
C {devices/lab_pin.sym} -1480 -610 0 0 {name=p1130 sig_type=std_logic lab=vdd_syn5}
C {devices/gnd.sym} -1160 -490 0 0 {name=l412 lab=GND}
C {devices/lab_pin.sym} -1230 -560 0 0 {name=p1131 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -1100 -490 0 0 {name=Vmeas156 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1120 -420 0 0 {name=M156
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1090 -420 3 0 {name=l413 lab=GND}
C {devices/lab_pin.sym} -1100 -380 2 0 {name=p1133 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -1150 -420 0 0 {name=p1134 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1100 -380 0 0 {name=x156}
C {devices/lab_pin.sym} -1160 -610 0 0 {name=p1135 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -840 -490 0 0 {name=l414 lab=GND}
C {devices/lab_pin.sym} -910 -560 0 0 {name=p1136 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -780 -490 0 0 {name=Vmeas157 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -800 -420 0 0 {name=M157
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -770 -420 3 0 {name=l415 lab=GND}
C {devices/lab_pin.sym} -780 -380 2 0 {name=p1138 sig_type=std_logic lab=p7}
C {devices/lab_pin.sym} -830 -420 0 0 {name=p1139 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -780 -380 0 0 {name=x157}
C {devices/lab_pin.sym} -840 -610 0 0 {name=p1140 sig_type=std_logic lab=vdd_syn7}
C {devices/gnd.sym} -520 -490 0 0 {name=l416 lab=GND}
C {devices/lab_pin.sym} -590 -560 0 0 {name=p1141 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -460 -490 0 0 {name=Vmeas158 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -420 0 0 {name=M158
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -420 3 0 {name=l417 lab=GND}
C {devices/lab_pin.sym} -460 -380 2 0 {name=p1143 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -420 0 0 {name=p1144 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -380 0 0 {name=x158}
C {devices/lab_pin.sym} -520 -610 0 0 {name=p1145 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -200 -490 0 0 {name=l418 lab=GND}
C {devices/lab_pin.sym} -270 -560 0 0 {name=p1146 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -140 -490 0 0 {name=Vmeas159 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -160 -420 0 0 {name=M159
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -130 -420 3 0 {name=l419 lab=GND}
C {devices/lab_pin.sym} -140 -380 2 0 {name=p1148 sig_type=std_logic lab=p9}
C {devices/lab_pin.sym} -190 -420 0 0 {name=p1149 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -140 -380 0 0 {name=x159}
C {devices/lab_pin.sym} -200 -610 0 0 {name=p1150 sig_type=std_logic lab=vdd_syn9}
C {devices/lab_pin.sym} -2510 -3560 0 0 {name=p626 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2190 -3560 0 0 {name=p627 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1870 -3560 0 0 {name=p631 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1550 -3560 0 0 {name=p632 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1230 -3560 0 0 {name=p636 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -910 -3560 0 0 {name=p637 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -590 -3560 0 0 {name=p641 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -270 -3560 0 0 {name=p642 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2830 -3860 0 0 {name=p478 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2510 -3860 0 0 {name=p479 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2190 -3860 0 0 {name=p483 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1870 -3860 0 0 {name=p484 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1550 -3860 0 0 {name=p488 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1230 -3860 0 0 {name=p489 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -910 -3860 0 0 {name=p493 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -590 -3860 0 0 {name=p494 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -270 -3860 0 0 {name=p498 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2830 -4160 0 0 {name=p525 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2510 -4160 0 0 {name=p526 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2190 -4160 0 0 {name=p530 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1870 -4160 0 0 {name=p531 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1550 -4160 0 0 {name=p535 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1230 -4160 0 0 {name=p536 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -910 -4160 0 0 {name=p540 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -590 -4160 0 0 {name=p541 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -270 -4160 0 0 {name=p545 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2830 -4460 0 0 {name=p572 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2510 -4460 0 0 {name=p573 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2190 -4460 0 0 {name=p577 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1870 -4460 0 0 {name=p578 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1550 -4460 0 0 {name=p582 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1230 -4460 0 0 {name=p583 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -910 -4460 0 0 {name=p587 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -590 -4460 0 0 {name=p588 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -270 -4460 0 0 {name=p592 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} 30 -4370 0 0 {name=p1151 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} 30 -4390 0 0 {name=p1152 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} 30 -4410 0 0 {name=p1153 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} 30 -4430 0 0 {name=p1154 sig_type=std_logic lab=4}
C {devices/lab_pin.sym} 30 -4450 0 0 {name=p1155 sig_type=std_logic lab=5}
C {devices/lab_pin.sym} 30 -4470 0 0 {name=p1156 sig_type=std_logic lab=6}
C {devices/lab_pin.sym} 30 -4490 0 0 {name=p1157 sig_type=std_logic lab=7}
C {devices/lab_pin.sym} 30 -4510 0 0 {name=p1158 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} 30 -4530 0 0 {name=p1159 sig_type=std_logic lab=9}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/WTA_circuit.sym} 160 -4440 0 0 {name=x160}
C {devices/vsource.sym} 120 -2790 0 0 {name=V23 value=1.8}
C {devices/gnd.sym} 120 -2740 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 120 -2840 2 0 {name=p1160 sig_type=std_logic lab=vdd_syn1}
C {devices/vsource.sym} 220 -2790 0 0 {name=V24 value=1.8}
C {devices/gnd.sym} 220 -2740 0 0 {name=l420 lab=GND}
C {devices/lab_pin.sym} 220 -2840 2 0 {name=p1161 sig_type=std_logic lab=vdd_syn2}
C {devices/vsource.sym} 320 -2790 0 0 {name=V25 value=1.8}
C {devices/gnd.sym} 320 -2740 0 0 {name=l421 lab=GND}
C {devices/lab_pin.sym} 320 -2840 2 0 {name=p1162 sig_type=std_logic lab=vdd_syn3}
C {devices/vsource.sym} 420 -2790 0 0 {name=V26 value=1.8}
C {devices/gnd.sym} 420 -2740 0 0 {name=l422 lab=GND}
C {devices/lab_pin.sym} 420 -2840 2 0 {name=p1163 sig_type=std_logic lab=vdd_syn4}
C {devices/vsource.sym} 520 -2790 0 0 {name=V27 value=1.8}
C {devices/gnd.sym} 520 -2740 0 0 {name=l423 lab=GND}
C {devices/lab_pin.sym} 520 -2840 2 0 {name=p1164 sig_type=std_logic lab=vdd_syn5}
C {devices/vsource.sym} 620 -2790 0 0 {name=V28 value=1.8}
C {devices/gnd.sym} 620 -2740 0 0 {name=l424 lab=GND}
C {devices/lab_pin.sym} 620 -2840 2 0 {name=p1165 sig_type=std_logic lab=vdd_syn6}
C {devices/vsource.sym} 720 -2790 0 0 {name=V29 value=1.8}
C {devices/gnd.sym} 720 -2740 0 0 {name=l425 lab=GND}
C {devices/lab_pin.sym} 720 -2840 2 0 {name=p1166 sig_type=std_logic lab=vdd_syn7}
C {devices/vsource.sym} 820 -2790 0 0 {name=V30 value=1.8}
C {devices/gnd.sym} 820 -2740 0 0 {name=l426 lab=GND}
C {devices/lab_pin.sym} 820 -2840 2 0 {name=p1167 sig_type=std_logic lab=vdd_syn8}
C {devices/vsource.sym} 920 -2790 0 0 {name=V31 value=1.8}
C {devices/gnd.sym} 920 -2740 0 0 {name=l427 lab=GND}
C {devices/lab_pin.sym} 920 -2840 2 0 {name=p1168 sig_type=std_logic lab=vdd_syn9}
C {devices/vsource.sym} 700 -2650 0 0 {name=V32 value="PWL(0 0 59.9u 0 60u 1.8 94.9u 1.8 95u 0)"}
C {devices/gnd.sym} 700 -2600 0 0 {name=l428 lab=GND}
C {devices/lab_pin.sym} 700 -2700 2 0 {name=p1169 sig_type=std_logic lab=b_px}
C {devices/vsource.sym} 620 -2650 0 0 {name=V33 value=0}
C {devices/gnd.sym} 620 -2600 0 0 {name=l429 lab=GND}
C {devices/lab_pin.sym} 620 -2700 2 0 {name=p1170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -560 2 0 {name=p27 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -860 2 0 {name=p30 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -1160 2 0 {name=p160 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -1460 2 0 {name=p165 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -1760 2 0 {name=p170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -2060 2 0 {name=p177 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -2360 2 0 {name=p180 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -2660 2 0 {name=p185 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -2960 2 0 {name=p382 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -3260 2 0 {name=p392 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -3560 2 0 {name=p394 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -3860 2 0 {name=p396 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -4160 2 0 {name=p400 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -3010 -4460 2 0 {name=p401 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -3010 -4760 2 0 {name=p405 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -4460 2 0 {name=p437 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -3560 2 0 {name=p442 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -2660 2 0 {name=p447 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1760 2 0 {name=p452 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -860 2 0 {name=p457 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -560 2 0 {name=p462 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1160 2 0 {name=p469 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -1460 2 0 {name=p474 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -2060 2 0 {name=p499 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -2360 2 0 {name=p503 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -2960 2 0 {name=p504 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -3260 2 0 {name=p508 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -3860 2 0 {name=p509 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2690 -4160 2 0 {name=p514 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2690 -4760 2 0 {name=p516 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -4760 2 0 {name=p520 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -4760 2 0 {name=p521 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -4760 2 0 {name=p546 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -4760 2 0 {name=p550 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -4760 2 0 {name=p551 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -4760 2 0 {name=p555 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4760 2 0 {name=p556 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -4760 2 0 {name=p560 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -560 2 0 {name=p561 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -560 2 0 {name=p567 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -560 2 0 {name=p568 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -560 2 0 {name=p593 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -560 2 0 {name=p597 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -560 2 0 {name=p598 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -560 2 0 {name=p602 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -560 2 0 {name=p603 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -860 2 0 {name=p607 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -860 2 0 {name=p612 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -860 2 0 {name=p616 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -860 2 0 {name=p608 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -860 2 0 {name=p617 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -860 2 0 {name=p622 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -860 2 0 {name=p646 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -860 2 0 {name=p647 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -1160 2 0 {name=p651 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -1160 2 0 {name=p652 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -1160 2 0 {name=p656 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -1160 2 0 {name=p657 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -1160 2 0 {name=p663 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1160 2 0 {name=p668 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -1160 2 0 {name=p699 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -1160 2 0 {name=p707 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -1460 2 0 {name=p712 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -1460 2 0 {name=p717 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -1460 2 0 {name=p722 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -1460 2 0 {name=p727 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -1460 2 0 {name=p732 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -1460 2 0 {name=p737 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1460 2 0 {name=p742 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -1460 2 0 {name=p747 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -1760 2 0 {name=p752 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -1760 2 0 {name=p757 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -1760 2 0 {name=p762 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -1760 2 0 {name=p767 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -1760 2 0 {name=p772 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -1760 2 0 {name=p777 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -1760 2 0 {name=p782 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -1760 2 0 {name=p787 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -2060 2 0 {name=p792 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -2060 2 0 {name=p797 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -2060 2 0 {name=p802 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -2060 2 0 {name=p807 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -2060 2 0 {name=p812 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -2060 2 0 {name=p817 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -2060 2 0 {name=p822 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -2060 2 0 {name=p827 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -2360 2 0 {name=p832 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -2360 2 0 {name=p837 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -2360 2 0 {name=p842 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -2360 2 0 {name=p847 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -2360 2 0 {name=p852 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -2360 2 0 {name=p857 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -2360 2 0 {name=p862 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -2360 2 0 {name=p867 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -2660 2 0 {name=p872 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -2660 2 0 {name=p877 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -2660 2 0 {name=p882 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -2660 2 0 {name=p887 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -2660 2 0 {name=p892 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -2660 2 0 {name=p897 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -2660 2 0 {name=p902 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -2660 2 0 {name=p907 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -2960 2 0 {name=p912 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -2960 2 0 {name=p917 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -2960 2 0 {name=p922 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -2960 2 0 {name=p927 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -2960 2 0 {name=p932 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -2960 2 0 {name=p937 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -2960 2 0 {name=p942 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -2960 2 0 {name=p947 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -3260 2 0 {name=p952 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -3260 2 0 {name=p957 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -3260 2 0 {name=p962 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -3260 2 0 {name=p967 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -3260 2 0 {name=p972 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -3260 2 0 {name=p977 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -3260 2 0 {name=p982 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -3260 2 0 {name=p987 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2370 -3560 2 0 {name=p992 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -3560 2 0 {name=p997 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -3560 2 0 {name=p1002 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -3560 2 0 {name=p1007 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1090 -3560 2 0 {name=p1012 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -770 -3560 2 0 {name=p1017 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -3560 2 0 {name=p1022 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -3560 2 0 {name=p1027 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -3860 2 0 {name=p1032 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -3860 2 0 {name=p1037 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -3860 2 0 {name=p1042 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -3860 2 0 {name=p1047 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -3860 2 0 {name=p1052 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -3860 2 0 {name=p1057 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -3860 2 0 {name=p1062 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -3860 2 0 {name=p1067 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -4160 2 0 {name=p1072 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2050 -4160 2 0 {name=p1077 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1730 -4160 2 0 {name=p1082 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1410 -4160 2 0 {name=p1087 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -4160 2 0 {name=p1092 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -4160 2 0 {name=p1097 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4160 2 0 {name=p1102 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -130 -4160 2 0 {name=p1107 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -2370 -4460 2 0 {name=p1112 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -2050 -4460 2 0 {name=p1117 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1730 -4460 2 0 {name=p1122 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1410 -4460 2 0 {name=p1127 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1090 -4460 2 0 {name=p1132 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -770 -4460 2 0 {name=p1137 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4460 2 0 {name=p1142 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -130 -4460 2 0 {name=p1147 sig_type=std_logic lab=b_px}
C {devices/launcher.sym} 80 -1855 0 0 {name=h3
descr="load training 0 and 8"
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_InfStage_tb2.raw tran"
}
C {devices/launcher.sym} 80 -1815 0 0 {name=h4
descr="inhibitory"
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_InfStage_tb3.raw tran"
}
C {devices/lab_pin.sym} -3060 -260 1 0 {name=p2 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -3090 -140 0 0 {name=l16 lab=GND}
C {devices/ammeter.sym} -3020 -300 0 0 {name=Vmeas160 savecurrent=true}
C {devices/lab_pin.sym} -3020 -340 2 0 {name=p12 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -3020 -10 2 0 {name=p15 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} -2950 -140 3 0 {name=p16 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -3090 -260 1 0 {name=p17 sig_type=std_logic lab=inh0}
C {devices/lab_pin.sym} -2980 -260 1 0 {name=p20 sig_type=std_logic lab=vlky}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -3020 -160 1 0 {name=x200}
C {devices/lab_pin.sym} 30 -4350 0 0 {name=p24 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} 160 -4180 2 0 {name=p31 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4160 3 0 {name=M160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -4190 2 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} 120 -4130 2 0 {name=p32 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -4180 0 0 {name=p45 sig_type=std_logic lab=ctrl_vinh}
C {devices/launcher.sym} 80 -1765 0 0 {name=h5
descr="0 to 9"
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_InfStage_0to9tb.raw tran"
}
