v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1600 -1200 -800 -800 {flags=graph
y1=0.019
y2=2.2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 -800 -400 0 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 0 -2400 800 -2000 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=8}
B 2 -800 -1600 0 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 -1600 -800 -800 -400 {flags=graph
y1=3
y2=4.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -800 -800 0 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 800 -2400 1600 -2000 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16"
node="p0
p1"}
B 2 0 -2000 800 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 0 -1600 800 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 0 -1200 800 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 800 -2000 1600 -1600 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 800 -1600 1600 -1200 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 800 -1200 1600 -800 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 0 -800 800 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 0 -400 800 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 800 -800 1600 -400 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 800 -400 1600 0 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 -800 -1200 0 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
B 2 -1600 -400 -800 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 -1600 -1600 -800 -1200 {flags=graph
y1=0.019
y2=2.2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.13064e-05
x2=3.97429e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpre1; vpre1\\"
\\"vpre2; vpre2\\"
\\"vpre3; vpre3\\"
\\"vpre4; vpre4\\"
\\"vpre5; vpre5\\"
\\"vpre6; vpre6\\"
\\"vpre7; vpre7\\"
\\"vpre8; vpre8\\"
\\"vpre9; vpre9\\""}
N -1580 -2620 -1580 -2600 {
lab=GND}
N -1580 -2700 -1580 -2680 {
lab=vdd_in}
N -1500 -2620 -1500 -2600 {
lab=GND}
N -1500 -2700 -1500 -2680 {
lab=vdd_pre}
N -2480 -7250 -2480 -7230 {
lab=GND}
N -2480 -7410 -2480 -7390 {
lab=vdd_pre}
N -2860 -7240 -2860 -7220 {
lab=GND}
N -2660 -7340 -2660 -7320 {
lab=vc2}
N -2660 -7370 -2650 -7370 {
lab=vdd_in}
N -2650 -7400 -2650 -7370 {
lab=vdd_in}
N -2660 -7400 -2650 -7400 {
lab=vdd_in}
N -2740 -7370 -2700 -7370 {
lab=#net1}
N -2780 -7400 -2660 -7400 {
lab=vdd_in}
N -2790 -7370 -2780 -7370 {
lab=vdd_in}
N -2790 -7400 -2790 -7370 {
lab=vdd_in}
N -2790 -7400 -2780 -7400 {
lab=vdd_in}
N -2780 -7340 -2780 -7320 {
lab=#net1}
N -2780 -7320 -2720 -7320 {
lab=#net1}
N -2720 -7370 -2720 -7320 {
lab=#net1}
N -2860 -7320 -2860 -7300 {
lab=#net2}
N -1320 -2620 -1320 -2600 {
lab=GND}
N -1320 -2700 -1320 -2680 {
lab=vdd_stdp}
N -1800 -7780 -1800 -7770 {
lab=GND}
N -1800 -7890 -1800 -7880 {
lab=vdd_syn0}
N -1740 -7700 -1730 -7700 {
lab=GND}
N -1740 -7670 -1740 -7660 {
lab=p0}
N -1740 -260 -1740 -250 {
lab=#net3}
N -1740 -330 -1740 -320 {
lab=p0}
N -1740 -10 -1740 0 {
lab=8}
N -1580 -2200 -1580 -2180 {
lab=GND}
N -1580 -2280 -1580 -2260 {
lab=uw}
N -1400 -2200 -1400 -2180 {
lab=GND}
N -1400 -2280 -1400 -2260 {
lab=training}
N -2340 -7320 -2330 -7320 {
lab=vpre2}
N -1810 -150 -1810 -130 {
lab=GND}
N -1670 -150 -1670 -130 {
lab=vdd_pos}
N -1140 -2200 -1140 -2180 {
lab=GND}
N -1140 -2280 -1140 -2260 {
lab=inference}
N -2800 -7320 -2780 -7320 {
lab=#net1}
N -1580 -2340 -1580 -2320 {
lab=GND}
N -1580 -2420 -1580 -2400 {
lab=ctrl_wu}
N -1500 -2340 -1500 -2320 {
lab=GND}
N -1500 -2420 -1500 -2400 {
lab=ctrl_stdp}
N -1420 -2480 -1420 -2460 {
lab=GND}
N -1420 -2560 -1420 -2540 {
lab=vb_wu}
N -1410 -2620 -1410 -2600 {
lab=GND}
N -1410 -2700 -1410 -2680 {
lab=vdd_pos}
N -1220 -2620 -1220 -2600 {
lab=GND}
N -1220 -2700 -1220 -2680 {
lab=vdd_sw}
N -1140 -2620 -1140 -2600 {
lab=GND}
N -1140 -2700 -1140 -2680 {
lab=vdd_tg}
N -1580 -2480 -1580 -2460 {
lab=GND}
N -1580 -2560 -1580 -2540 {
lab=vb_pre}
N -1500 -2480 -1500 -2460 {
lab=GND}
N -1500 -2560 -1500 -2540 {
lab=vb_pos}
N -1870 -7840 -1860 -7840 {
lab=vpres1}
N -1740 -7840 -1730 -7840 {
lab=vpos1}
N -2480 -7770 -2480 -7750 {
lab=GND}
N -2480 -7930 -2480 -7910 {
lab=vdd_pre}
N -2860 -7760 -2860 -7740 {
lab=GND}
N -2660 -7860 -2660 -7840 {
lab=vc1}
N -2660 -7890 -2650 -7890 {
lab=vdd_in}
N -2650 -7920 -2650 -7890 {
lab=vdd_in}
N -2660 -7920 -2650 -7920 {
lab=vdd_in}
N -2740 -7890 -2700 -7890 {
lab=#net4}
N -2780 -7920 -2660 -7920 {
lab=vdd_in}
N -2790 -7890 -2780 -7890 {
lab=vdd_in}
N -2790 -7920 -2790 -7890 {
lab=vdd_in}
N -2790 -7920 -2780 -7920 {
lab=vdd_in}
N -2780 -7860 -2780 -7840 {
lab=#net4}
N -2780 -7840 -2720 -7840 {
lab=#net4}
N -2720 -7890 -2720 -7840 {
lab=#net4}
N -2860 -7840 -2860 -7820 {
lab=#net5}
N -1800 -7260 -1800 -7250 {
lab=GND}
N -1800 -7370 -1800 -7360 {
lab=vdd_syn0}
N -2110 -7950 -2110 -7940 {
lab=GND}
N -1740 -7180 -1730 -7180 {
lab=GND}
N -1740 -7150 -1740 -7140 {
lab=p0}
N -2340 -7840 -2330 -7840 {
lab=vpre1}
N -2800 -7840 -2780 -7840 {
lab=#net4}
N -2110 -7650 -2110 -7640 {
lab=GND}
N -2060 -7690 -2050 -7690 {
lab=vpres1}
N -2110 -7800 -2110 -7790 {
lab=GND}
N -2060 -7990 -2050 -7990 {
lab=vpos1}
N -2060 -7840 -2050 -7840 {
lab=vpres1}
N -1870 -7320 -1860 -7320 {
lab=vpres2}
N -1740 -7320 -1730 -7320 {
lab=vpos2}
N -1790 -7180 -1780 -7180 {
lab=ctrl_pos}
N -1790 -7700 -1780 -7700 {
lab=ctrl_pos}
N -1400 -2340 -1400 -2320 {
lab=GND}
N -1400 -2420 -1400 -2400 {
lab=ctrl_inf}
N -1060 -2620 -1060 -2600 {
lab=GND}
N -1060 -2700 -1060 -2680 {
lab=vdd_inh}
N -940 -1950 -940 -1940 {
lab=vdd_inh}
N -1240 -2340 -1240 -2320 {
lab=GND}
N -1240 -2420 -1240 -2400 {
lab=ctrl_vinh}
N -940 -1840 -940 -1830 {
lab=GND}
N -880 -1890 -870 -1890 {
lab=inh_d}
N -940 -1740 -930 -1740 {
lab=inh0}
N -970 -1750 -970 -1740 {
lab=GND}
N -970 -1700 -970 -1690 {
lab=inh_d}
N -1010 -1740 -1000 -1740 {
lab=ctrl_vinh}
N -1260 -2480 -1260 -2460 {
lab=GND}
N -1260 -2560 -1260 -2540 {
lab=vlky}
N -2660 -7840 -2580 -7840 {
lab=vc1}
N -2580 -7880 -2570 -7880 {
lab=vlky}
N -2580 -7800 -2570 -7800 {
lab=vb_pre}
N -2580 -7360 -2570 -7360 {
lab=vlky}
N -2660 -7320 -2580 -7320 {
lab=vc2}
N -2580 -7280 -2570 -7280 {
lab=vb_pre}
N -1810 -250 -1810 -240 {
lab=inh0}
N -1780 -250 -1780 -240 {
lab=vb_pos}
N -1700 -250 -1700 -240 {
lab=vlky}
N -980 -2620 -980 -2600 {
lab=GND}
N -980 -2700 -980 -2680 {
lab=vdd_syn0}
N -2170 -7660 -2160 -7660 {
lab=vb_wu}
N -1740 -7820 -1740 -7800 {
lab=#net6}
N -1740 -7740 -1740 -7730 {
lab=#net7}
N -1740 -7300 -1740 -7280 {
lab=#net8}
N -1740 -7220 -1740 -7210 {
lab=#net9}
N -1800 -6740 -1800 -6730 {
lab=GND}
N -1800 -6850 -1800 -6840 {
lab=vdd_syn0}
N -1740 -6660 -1730 -6660 {
lab=GND}
N -1740 -6630 -1740 -6620 {
lab=p0}
N -1870 -6800 -1860 -6800 {
lab=vpres3}
N -1740 -6800 -1730 -6800 {
lab=vpos3}
N -1790 -6660 -1780 -6660 {
lab=ctrl_pos}
N -1740 -6780 -1740 -6760 {
lab=#net10}
N -1740 -6700 -1740 -6690 {
lab=#net11}
N -1800 -6220 -1800 -6210 {
lab=GND}
N -1800 -6330 -1800 -6320 {
lab=vdd_syn0}
N -1740 -6140 -1730 -6140 {
lab=GND}
N -1740 -6110 -1740 -6100 {
lab=p0}
N -1870 -6280 -1860 -6280 {
lab=vpres4}
N -1740 -6280 -1730 -6280 {
lab=vpos4}
N -1790 -6140 -1780 -6140 {
lab=ctrl_pos}
N -1740 -6260 -1740 -6240 {
lab=#net12}
N -1740 -6180 -1740 -6170 {
lab=#net13}
N -1800 -5700 -1800 -5690 {
lab=GND}
N -1800 -5810 -1800 -5800 {
lab=vdd_syn0}
N -1740 -5620 -1730 -5620 {
lab=GND}
N -1740 -5590 -1740 -5580 {
lab=p0}
N -1870 -5760 -1860 -5760 {
lab=vpres5}
N -1740 -5760 -1730 -5760 {
lab=vpos5}
N -1790 -5620 -1780 -5620 {
lab=ctrl_pos}
N -1740 -5740 -1740 -5720 {
lab=#net14}
N -1740 -5660 -1740 -5650 {
lab=#net15}
N -1800 -5180 -1800 -5170 {
lab=GND}
N -1800 -5290 -1800 -5280 {
lab=vdd_syn0}
N -1740 -5100 -1730 -5100 {
lab=GND}
N -1740 -5070 -1740 -5060 {
lab=p0}
N -1870 -5240 -1860 -5240 {
lab=vpres6}
N -1740 -5240 -1730 -5240 {
lab=vpos6}
N -1790 -5100 -1780 -5100 {
lab=ctrl_pos}
N -1740 -5220 -1740 -5200 {
lab=#net16}
N -1740 -5140 -1740 -5130 {
lab=#net17}
N -1800 -4660 -1800 -4650 {
lab=GND}
N -1800 -4770 -1800 -4760 {
lab=vdd_syn0}
N -1740 -4580 -1730 -4580 {
lab=GND}
N -1740 -4550 -1740 -4540 {
lab=p0}
N -1870 -4720 -1860 -4720 {
lab=vpres7}
N -1740 -4720 -1730 -4720 {
lab=vpos7}
N -1790 -4580 -1780 -4580 {
lab=ctrl_pos}
N -1740 -4700 -1740 -4680 {
lab=#net18}
N -1740 -4620 -1740 -4610 {
lab=#net19}
N -1800 -4140 -1800 -4130 {
lab=GND}
N -1800 -4250 -1800 -4240 {
lab=vdd_syn0}
N -1740 -4060 -1730 -4060 {
lab=GND}
N -1740 -4030 -1740 -4020 {
lab=p0}
N -1870 -4200 -1860 -4200 {
lab=vpres8}
N -1740 -4200 -1730 -4200 {
lab=vpos8}
N -1790 -4060 -1780 -4060 {
lab=ctrl_pos}
N -1740 -4180 -1740 -4160 {
lab=#net20}
N -1740 -4100 -1740 -4090 {
lab=#net21}
N -1800 -3620 -1800 -3610 {
lab=GND}
N -1800 -3730 -1800 -3720 {
lab=vdd_syn0}
N -1740 -3540 -1730 -3540 {
lab=GND}
N -1740 -3510 -1740 -3500 {
lab=p0}
N -1870 -3680 -1860 -3680 {
lab=vpres9}
N -1740 -3680 -1730 -3680 {
lab=vpos9}
N -1790 -3540 -1780 -3540 {
lab=ctrl_pos}
N -1740 -3660 -1740 -3640 {
lab=#net22}
N -1740 -3580 -1740 -3570 {
lab=#net23}
N -2480 -6210 -2480 -6190 {
lab=GND}
N -2480 -6370 -2480 -6350 {
lab=vdd_pre}
N -2860 -6200 -2860 -6180 {
lab=GND}
N -2660 -6300 -2660 -6280 {
lab=vc4}
N -2660 -6330 -2650 -6330 {
lab=vdd_in}
N -2650 -6360 -2650 -6330 {
lab=vdd_in}
N -2660 -6360 -2650 -6360 {
lab=vdd_in}
N -2740 -6330 -2700 -6330 {
lab=#net24}
N -2780 -6360 -2660 -6360 {
lab=vdd_in}
N -2790 -6330 -2780 -6330 {
lab=vdd_in}
N -2790 -6360 -2790 -6330 {
lab=vdd_in}
N -2790 -6360 -2780 -6360 {
lab=vdd_in}
N -2780 -6300 -2780 -6280 {
lab=#net24}
N -2780 -6280 -2720 -6280 {
lab=#net24}
N -2720 -6330 -2720 -6280 {
lab=#net24}
N -2860 -6280 -2860 -6260 {
lab=#net25}
N -2340 -6280 -2330 -6280 {
lab=vpre4}
N -2800 -6280 -2780 -6280 {
lab=#net24}
N -2480 -6730 -2480 -6710 {
lab=GND}
N -2480 -6890 -2480 -6870 {
lab=vdd_pre}
N -2860 -6720 -2860 -6700 {
lab=GND}
N -2660 -6820 -2660 -6800 {
lab=vc3}
N -2660 -6850 -2650 -6850 {
lab=vdd_in}
N -2650 -6880 -2650 -6850 {
lab=vdd_in}
N -2660 -6880 -2650 -6880 {
lab=vdd_in}
N -2740 -6850 -2700 -6850 {
lab=#net26}
N -2780 -6880 -2660 -6880 {
lab=vdd_in}
N -2790 -6850 -2780 -6850 {
lab=vdd_in}
N -2790 -6880 -2790 -6850 {
lab=vdd_in}
N -2790 -6880 -2780 -6880 {
lab=vdd_in}
N -2780 -6820 -2780 -6800 {
lab=#net26}
N -2780 -6800 -2720 -6800 {
lab=#net26}
N -2720 -6850 -2720 -6800 {
lab=#net26}
N -2860 -6800 -2860 -6780 {
lab=#net27}
N -2340 -6800 -2330 -6800 {
lab=vpre3}
N -2800 -6800 -2780 -6800 {
lab=#net26}
N -2660 -6800 -2580 -6800 {
lab=vc3}
N -2580 -6840 -2570 -6840 {
lab=vlky}
N -2580 -6760 -2570 -6760 {
lab=vb_pre}
N -2580 -6320 -2570 -6320 {
lab=vlky}
N -2660 -6280 -2580 -6280 {
lab=vc4}
N -2580 -6240 -2570 -6240 {
lab=vb_pre}
N -2480 -5170 -2480 -5150 {
lab=GND}
N -2480 -5330 -2480 -5310 {
lab=vdd_pre}
N -2860 -5160 -2860 -5140 {
lab=GND}
N -2660 -5260 -2660 -5240 {
lab=vc6}
N -2660 -5290 -2650 -5290 {
lab=vdd_in}
N -2650 -5320 -2650 -5290 {
lab=vdd_in}
N -2660 -5320 -2650 -5320 {
lab=vdd_in}
N -2740 -5290 -2700 -5290 {
lab=#net28}
N -2780 -5320 -2660 -5320 {
lab=vdd_in}
N -2790 -5290 -2780 -5290 {
lab=vdd_in}
N -2790 -5320 -2790 -5290 {
lab=vdd_in}
N -2790 -5320 -2780 -5320 {
lab=vdd_in}
N -2780 -5260 -2780 -5240 {
lab=#net28}
N -2780 -5240 -2720 -5240 {
lab=#net28}
N -2720 -5290 -2720 -5240 {
lab=#net28}
N -2860 -5240 -2860 -5220 {
lab=#net29}
N -2340 -5240 -2330 -5240 {
lab=vpre6}
N -2800 -5240 -2780 -5240 {
lab=#net28}
N -2480 -5690 -2480 -5670 {
lab=GND}
N -2480 -5850 -2480 -5830 {
lab=vdd_pre}
N -2860 -5680 -2860 -5660 {
lab=GND}
N -2660 -5780 -2660 -5760 {
lab=vc5}
N -2660 -5810 -2650 -5810 {
lab=vdd_in}
N -2650 -5840 -2650 -5810 {
lab=vdd_in}
N -2660 -5840 -2650 -5840 {
lab=vdd_in}
N -2740 -5810 -2700 -5810 {
lab=#net30}
N -2780 -5840 -2660 -5840 {
lab=vdd_in}
N -2790 -5810 -2780 -5810 {
lab=vdd_in}
N -2790 -5840 -2790 -5810 {
lab=vdd_in}
N -2790 -5840 -2780 -5840 {
lab=vdd_in}
N -2780 -5780 -2780 -5760 {
lab=#net30}
N -2780 -5760 -2720 -5760 {
lab=#net30}
N -2720 -5810 -2720 -5760 {
lab=#net30}
N -2860 -5760 -2860 -5740 {
lab=#net31}
N -2340 -5760 -2330 -5760 {
lab=vpre5}
N -2800 -5760 -2780 -5760 {
lab=#net30}
N -2660 -5760 -2580 -5760 {
lab=vc5}
N -2580 -5800 -2570 -5800 {
lab=vlky}
N -2580 -5720 -2570 -5720 {
lab=vb_pre}
N -2580 -5280 -2570 -5280 {
lab=vlky}
N -2660 -5240 -2580 -5240 {
lab=vc6}
N -2580 -5200 -2570 -5200 {
lab=vb_pre}
N -2480 -4130 -2480 -4110 {
lab=GND}
N -2480 -4290 -2480 -4270 {
lab=vdd_pre}
N -2860 -4120 -2860 -4100 {
lab=GND}
N -2660 -4220 -2660 -4200 {
lab=vc8}
N -2660 -4250 -2650 -4250 {
lab=vdd_in}
N -2650 -4280 -2650 -4250 {
lab=vdd_in}
N -2660 -4280 -2650 -4280 {
lab=vdd_in}
N -2740 -4250 -2700 -4250 {
lab=#net32}
N -2780 -4280 -2660 -4280 {
lab=vdd_in}
N -2790 -4250 -2780 -4250 {
lab=vdd_in}
N -2790 -4280 -2790 -4250 {
lab=vdd_in}
N -2790 -4280 -2780 -4280 {
lab=vdd_in}
N -2780 -4220 -2780 -4200 {
lab=#net32}
N -2780 -4200 -2720 -4200 {
lab=#net32}
N -2720 -4250 -2720 -4200 {
lab=#net32}
N -2860 -4200 -2860 -4180 {
lab=#net33}
N -2340 -4200 -2330 -4200 {
lab=vpre8}
N -2800 -4200 -2780 -4200 {
lab=#net32}
N -2480 -4650 -2480 -4630 {
lab=GND}
N -2480 -4810 -2480 -4790 {
lab=vdd_pre}
N -2860 -4640 -2860 -4620 {
lab=GND}
N -2660 -4740 -2660 -4720 {
lab=vc7}
N -2660 -4770 -2650 -4770 {
lab=vdd_in}
N -2650 -4800 -2650 -4770 {
lab=vdd_in}
N -2660 -4800 -2650 -4800 {
lab=vdd_in}
N -2740 -4770 -2700 -4770 {
lab=#net34}
N -2780 -4800 -2660 -4800 {
lab=vdd_in}
N -2790 -4770 -2780 -4770 {
lab=vdd_in}
N -2790 -4800 -2790 -4770 {
lab=vdd_in}
N -2790 -4800 -2780 -4800 {
lab=vdd_in}
N -2780 -4740 -2780 -4720 {
lab=#net34}
N -2780 -4720 -2720 -4720 {
lab=#net34}
N -2720 -4770 -2720 -4720 {
lab=#net34}
N -2860 -4720 -2860 -4700 {
lab=#net35}
N -2340 -4720 -2330 -4720 {
lab=vpre7}
N -2800 -4720 -2780 -4720 {
lab=#net34}
N -2660 -4720 -2580 -4720 {
lab=vc7}
N -2580 -4760 -2570 -4760 {
lab=vlky}
N -2580 -4680 -2570 -4680 {
lab=vb_pre}
N -2580 -4240 -2570 -4240 {
lab=vlky}
N -2660 -4200 -2580 -4200 {
lab=vc8}
N -2580 -4160 -2570 -4160 {
lab=vb_pre}
N -2480 -3610 -2480 -3590 {
lab=GND}
N -2480 -3770 -2480 -3750 {
lab=vdd_pre}
N -2860 -3600 -2860 -3580 {
lab=GND}
N -2660 -3700 -2660 -3680 {
lab=vc9}
N -2660 -3730 -2650 -3730 {
lab=vdd_in}
N -2650 -3760 -2650 -3730 {
lab=vdd_in}
N -2660 -3760 -2650 -3760 {
lab=vdd_in}
N -2740 -3730 -2700 -3730 {
lab=#net36}
N -2780 -3760 -2660 -3760 {
lab=vdd_in}
N -2790 -3730 -2780 -3730 {
lab=vdd_in}
N -2790 -3760 -2790 -3730 {
lab=vdd_in}
N -2790 -3760 -2780 -3760 {
lab=vdd_in}
N -2780 -3700 -2780 -3680 {
lab=#net36}
N -2780 -3680 -2720 -3680 {
lab=#net36}
N -2720 -3730 -2720 -3680 {
lab=#net36}
N -2860 -3680 -2860 -3660 {
lab=#net37}
N -2340 -3680 -2330 -3680 {
lab=vpre9}
N -2800 -3680 -2780 -3680 {
lab=#net36}
N -2580 -3720 -2570 -3720 {
lab=vlky}
N -2660 -3680 -2580 -3680 {
lab=vc9}
N -2580 -3640 -2570 -3640 {
lab=vb_pre}
N -1020 -1870 -1010 -1870 {
lab=8}
N -1800 -3100 -1800 -3090 {
lab=GND}
N -1800 -3210 -1800 -3200 {
lab=vdd_syn0}
N -1740 -3020 -1730 -3020 {
lab=GND}
N -1740 -2990 -1740 -2980 {
lab=p0}
N -1870 -3160 -1860 -3160 {
lab=vpres10}
N -1740 -3160 -1730 -3160 {
lab=vpos10}
N -1790 -3020 -1780 -3020 {
lab=ctrl_pos}
N -1740 -3140 -1740 -3120 {
lab=#net38}
N -1740 -3060 -1740 -3050 {
lab=#net39}
N -1800 -2580 -1800 -2570 {
lab=GND}
N -1800 -2690 -1800 -2680 {
lab=vdd_syn0}
N -1740 -2500 -1730 -2500 {
lab=GND}
N -1740 -2470 -1740 -2460 {
lab=p0}
N -1870 -2640 -1860 -2640 {
lab=vpres11}
N -1740 -2640 -1730 -2640 {
lab=vpos11}
N -1790 -2500 -1780 -2500 {
lab=ctrl_pos}
N -1740 -2620 -1740 -2600 {
lab=#net40}
N -1740 -2540 -1740 -2530 {
lab=#net41}
N -1800 -2060 -1800 -2050 {
lab=GND}
N -1800 -2170 -1800 -2160 {
lab=vdd_syn0}
N -1740 -1980 -1730 -1980 {
lab=GND}
N -1740 -1950 -1740 -1940 {
lab=p0}
N -1870 -2120 -1860 -2120 {
lab=vpres12}
N -1740 -2120 -1730 -2120 {
lab=vpos12}
N -1790 -1980 -1780 -1980 {
lab=ctrl_pos}
N -1740 -2100 -1740 -2080 {
lab=#net42}
N -1740 -2020 -1740 -2010 {
lab=#net43}
N -1800 -1540 -1800 -1530 {
lab=GND}
N -1800 -1650 -1800 -1640 {
lab=vdd_syn0}
N -1740 -1460 -1730 -1460 {
lab=GND}
N -1740 -1430 -1740 -1420 {
lab=p0}
N -1870 -1600 -1860 -1600 {
lab=vpres13}
N -1740 -1600 -1730 -1600 {
lab=vpos13}
N -1790 -1460 -1780 -1460 {
lab=ctrl_pos}
N -1740 -1580 -1740 -1560 {
lab=#net44}
N -1740 -1500 -1740 -1490 {
lab=#net45}
N -1800 -1020 -1800 -1010 {
lab=GND}
N -1800 -1130 -1800 -1120 {
lab=vdd_syn0}
N -1740 -940 -1730 -940 {
lab=GND}
N -1740 -910 -1740 -900 {
lab=p0}
N -1790 -940 -1780 -940 {
lab=ctrl_pos}
N -1740 -1060 -1740 -1040 {
lab=#net46}
N -1740 -980 -1740 -970 {
lab=#net47}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn0}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p0}
N -1740 -560 -1730 -560 {
lab=vpos15}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net48}
N -1740 -460 -1740 -450 {
lab=#net49}
N -2480 -3090 -2480 -3070 {
lab=GND}
N -2480 -3250 -2480 -3230 {
lab=vdd_pre}
N -2860 -3080 -2860 -3060 {
lab=GND}
N -2660 -3180 -2660 -3160 {
lab=vc10}
N -2660 -3210 -2650 -3210 {
lab=vdd_in}
N -2650 -3240 -2650 -3210 {
lab=vdd_in}
N -2660 -3240 -2650 -3240 {
lab=vdd_in}
N -2740 -3210 -2700 -3210 {
lab=#net50}
N -2780 -3240 -2660 -3240 {
lab=vdd_in}
N -2790 -3210 -2780 -3210 {
lab=vdd_in}
N -2790 -3240 -2790 -3210 {
lab=vdd_in}
N -2790 -3240 -2780 -3240 {
lab=vdd_in}
N -2780 -3180 -2780 -3160 {
lab=#net50}
N -2780 -3160 -2720 -3160 {
lab=#net50}
N -2720 -3210 -2720 -3160 {
lab=#net50}
N -2860 -3160 -2860 -3140 {
lab=#net51}
N -2340 -3160 -2330 -3160 {
lab=vpre10}
N -2800 -3160 -2780 -3160 {
lab=#net50}
N -2580 -3200 -2570 -3200 {
lab=vlky}
N -2660 -3160 -2580 -3160 {
lab=vc10}
N -2580 -3120 -2570 -3120 {
lab=vb_pre}
N -2480 -2050 -2480 -2030 {
lab=GND}
N -2480 -2210 -2480 -2190 {
lab=vdd_pre}
N -2860 -2040 -2860 -2020 {
lab=GND}
N -2660 -2140 -2660 -2120 {
lab=vc12}
N -2660 -2170 -2650 -2170 {
lab=vdd_in}
N -2650 -2200 -2650 -2170 {
lab=vdd_in}
N -2660 -2200 -2650 -2200 {
lab=vdd_in}
N -2740 -2170 -2700 -2170 {
lab=#net52}
N -2780 -2200 -2660 -2200 {
lab=vdd_in}
N -2790 -2170 -2780 -2170 {
lab=vdd_in}
N -2790 -2200 -2790 -2170 {
lab=vdd_in}
N -2790 -2200 -2780 -2200 {
lab=vdd_in}
N -2780 -2140 -2780 -2120 {
lab=#net52}
N -2780 -2120 -2720 -2120 {
lab=#net52}
N -2720 -2170 -2720 -2120 {
lab=#net52}
N -2860 -2120 -2860 -2100 {
lab=#net53}
N -2340 -2120 -2330 -2120 {
lab=vpre12}
N -2800 -2120 -2780 -2120 {
lab=#net52}
N -2480 -2570 -2480 -2550 {
lab=GND}
N -2480 -2730 -2480 -2710 {
lab=vdd_pre}
N -2860 -2560 -2860 -2540 {
lab=GND}
N -2660 -2660 -2660 -2640 {
lab=vc11}
N -2660 -2690 -2650 -2690 {
lab=vdd_in}
N -2650 -2720 -2650 -2690 {
lab=vdd_in}
N -2660 -2720 -2650 -2720 {
lab=vdd_in}
N -2740 -2690 -2700 -2690 {
lab=#net54}
N -2780 -2720 -2660 -2720 {
lab=vdd_in}
N -2790 -2690 -2780 -2690 {
lab=vdd_in}
N -2790 -2720 -2790 -2690 {
lab=vdd_in}
N -2790 -2720 -2780 -2720 {
lab=vdd_in}
N -2780 -2660 -2780 -2640 {
lab=#net54}
N -2780 -2640 -2720 -2640 {
lab=#net54}
N -2720 -2690 -2720 -2640 {
lab=#net54}
N -2860 -2640 -2860 -2620 {
lab=#net55}
N -2340 -2640 -2330 -2640 {
lab=vpre11}
N -2800 -2640 -2780 -2640 {
lab=#net54}
N -2660 -2640 -2580 -2640 {
lab=vc11}
N -2580 -2680 -2570 -2680 {
lab=vlky}
N -2580 -2600 -2570 -2600 {
lab=vb_pre}
N -2580 -2160 -2570 -2160 {
lab=vlky}
N -2660 -2120 -2580 -2120 {
lab=vc12}
N -2580 -2080 -2570 -2080 {
lab=vb_pre}
N -2480 -1010 -2480 -990 {
lab=GND}
N -2480 -1170 -2480 -1150 {
lab=vdd_pre}
N -2860 -1000 -2860 -980 {
lab=GND}
N -2660 -1100 -2660 -1080 {
lab=vc14}
N -2660 -1130 -2650 -1130 {
lab=vdd_in}
N -2650 -1160 -2650 -1130 {
lab=vdd_in}
N -2660 -1160 -2650 -1160 {
lab=vdd_in}
N -2740 -1130 -2700 -1130 {
lab=#net56}
N -2780 -1160 -2660 -1160 {
lab=vdd_in}
N -2790 -1130 -2780 -1130 {
lab=vdd_in}
N -2790 -1160 -2790 -1130 {
lab=vdd_in}
N -2790 -1160 -2780 -1160 {
lab=vdd_in}
N -2780 -1100 -2780 -1080 {
lab=#net56}
N -2780 -1080 -2720 -1080 {
lab=#net56}
N -2720 -1130 -2720 -1080 {
lab=#net56}
N -2860 -1080 -2860 -1060 {
lab=#net57}
N -2340 -1080 -2330 -1080 {
lab=vpre14}
N -2800 -1080 -2780 -1080 {
lab=#net56}
N -2480 -1530 -2480 -1510 {
lab=GND}
N -2480 -1690 -2480 -1670 {
lab=vdd_pre}
N -2860 -1520 -2860 -1500 {
lab=GND}
N -2660 -1620 -2660 -1600 {
lab=vc13}
N -2660 -1650 -2650 -1650 {
lab=vdd_in}
N -2650 -1680 -2650 -1650 {
lab=vdd_in}
N -2660 -1680 -2650 -1680 {
lab=vdd_in}
N -2740 -1650 -2700 -1650 {
lab=#net58}
N -2780 -1680 -2660 -1680 {
lab=vdd_in}
N -2790 -1650 -2780 -1650 {
lab=vdd_in}
N -2790 -1680 -2790 -1650 {
lab=vdd_in}
N -2790 -1680 -2780 -1680 {
lab=vdd_in}
N -2780 -1620 -2780 -1600 {
lab=#net58}
N -2780 -1600 -2720 -1600 {
lab=#net58}
N -2720 -1650 -2720 -1600 {
lab=#net58}
N -2860 -1600 -2860 -1580 {
lab=#net59}
N -2340 -1600 -2330 -1600 {
lab=vpre13}
N -2800 -1600 -2780 -1600 {
lab=#net58}
N -2660 -1600 -2580 -1600 {
lab=vc13}
N -2580 -1640 -2570 -1640 {
lab=vlky}
N -2580 -1560 -2570 -1560 {
lab=vb_pre}
N -2580 -1120 -2570 -1120 {
lab=vlky}
N -2660 -1080 -2580 -1080 {
lab=vc14}
N -2580 -1040 -2570 -1040 {
lab=vb_pre}
N -2480 -490 -2480 -470 {
lab=GND}
N -2480 -650 -2480 -630 {
lab=vdd_pre}
N -2860 -480 -2860 -460 {
lab=GND}
N -2660 -580 -2660 -560 {
lab=vc15}
N -2660 -610 -2650 -610 {
lab=vdd_in}
N -2650 -640 -2650 -610 {
lab=vdd_in}
N -2660 -640 -2650 -640 {
lab=vdd_in}
N -2740 -610 -2700 -610 {
lab=#net60}
N -2780 -640 -2660 -640 {
lab=vdd_in}
N -2790 -610 -2780 -610 {
lab=vdd_in}
N -2790 -640 -2790 -610 {
lab=vdd_in}
N -2790 -640 -2780 -640 {
lab=vdd_in}
N -2780 -580 -2780 -560 {
lab=#net60}
N -2780 -560 -2720 -560 {
lab=#net60}
N -2720 -610 -2720 -560 {
lab=#net60}
N -2860 -560 -2860 -540 {
lab=#net61}
N -2340 -560 -2330 -560 {
lab=vpre15}
N -2800 -560 -2780 -560 {
lab=#net60}
N -2580 -600 -2570 -600 {
lab=vlky}
N -2660 -560 -2580 -560 {
lab=vc15}
N -2580 -520 -2570 -520 {
lab=vb_pre}
N -1020 -1910 -1020 -1900 {
lab=GND}
N -1020 -1910 -1010 -1910 {
lab=GND}
N -2170 -8020 -2160 -8020 {
lab=ctrl_stdp}
N -2170 -7870 -2160 -7870 {
lab=ctrl_inf}
N -2110 -7750 -2110 -7730 {
lab=vdd_wu}
N -2110 -7900 -2110 -7880 {
lab=vdd_inf}
N -2110 -8050 -2110 -8030 {
lab=vdd_stdp}
N -2170 -7720 -2160 -7720 {
lab=ctrl_wu}
N -2160 -7720 -2160 -7690 {
lab=ctrl_wu}
N -1320 -2340 -1320 -2320 {
lab=GND}
N -1320 -2420 -1320 -2400 {
lab=ctrl_pos}
N -2110 -7430 -2110 -7420 {
lab=GND}
N -2110 -7130 -2110 -7120 {
lab=GND}
N -2060 -7170 -2050 -7170 {
lab=vpres2}
N -2110 -7280 -2110 -7270 {
lab=GND}
N -2170 -7470 -2160 -7470 {
lab=vpre2}
N -2060 -7470 -2050 -7470 {
lab=vpos2}
N -2060 -7320 -2050 -7320 {
lab=vpres2}
N -2170 -7140 -2160 -7140 {
lab=vb_wu}
N -2170 -7500 -2160 -7500 {
lab=ctrl_stdp}
N -2170 -7350 -2160 -7350 {
lab=ctrl_inf}
N -2110 -7230 -2110 -7210 {
lab=vdd_wu}
N -2110 -7380 -2110 -7360 {
lab=vdd_inf}
N -2110 -7530 -2110 -7510 {
lab=vdd_stdp}
N -2170 -7200 -2160 -7200 {
lab=ctrl_wu}
N -2160 -7200 -2160 -7170 {
lab=ctrl_wu}
N -2110 -6910 -2110 -6900 {
lab=GND}
N -2110 -6610 -2110 -6600 {
lab=GND}
N -2060 -6650 -2050 -6650 {
lab=vpres3}
N -2110 -6760 -2110 -6750 {
lab=GND}
N -2170 -6800 -2160 -6800 {
lab=vpre3}
N -2170 -6950 -2160 -6950 {
lab=vpre3}
N -2060 -6950 -2050 -6950 {
lab=vpos3}
N -2060 -6800 -2050 -6800 {
lab=vpres3}
N -2170 -6620 -2160 -6620 {
lab=vb_wu}
N -2170 -6980 -2160 -6980 {
lab=ctrl_stdp}
N -2170 -6830 -2160 -6830 {
lab=ctrl_inf}
N -2110 -6710 -2110 -6690 {
lab=vdd_wu}
N -2110 -6860 -2110 -6840 {
lab=vdd_inf}
N -2110 -7010 -2110 -6990 {
lab=vdd_stdp}
N -2170 -6680 -2160 -6680 {
lab=ctrl_wu}
N -2160 -6680 -2160 -6650 {
lab=ctrl_wu}
N -2110 -6390 -2110 -6380 {
lab=GND}
N -2110 -6090 -2110 -6080 {
lab=GND}
N -2060 -6130 -2050 -6130 {
lab=vpres4}
N -2110 -6240 -2110 -6230 {
lab=GND}
N -2170 -6280 -2160 -6280 {
lab=vpre4}
N -2170 -6430 -2160 -6430 {
lab=vpre4}
N -2060 -6430 -2050 -6430 {
lab=vpos4}
N -2060 -6280 -2050 -6280 {
lab=vpres4}
N -2170 -6100 -2160 -6100 {
lab=vb_wu}
N -2170 -6460 -2160 -6460 {
lab=ctrl_stdp}
N -2170 -6310 -2160 -6310 {
lab=ctrl_inf}
N -2110 -6190 -2110 -6170 {
lab=vdd_wu}
N -2110 -6340 -2110 -6320 {
lab=vdd_inf}
N -2110 -6490 -2110 -6470 {
lab=vdd_stdp}
N -2170 -6160 -2160 -6160 {
lab=ctrl_wu}
N -2160 -6160 -2160 -6130 {
lab=ctrl_wu}
N -2110 -5870 -2110 -5860 {
lab=GND}
N -2110 -5570 -2110 -5560 {
lab=GND}
N -2060 -5610 -2050 -5610 {
lab=vpres5}
N -2110 -5720 -2110 -5710 {
lab=GND}
N -2170 -5760 -2160 -5760 {
lab=vpre5}
N -2170 -5910 -2160 -5910 {
lab=vpre5}
N -2060 -5910 -2050 -5910 {
lab=vpos5}
N -2060 -5760 -2050 -5760 {
lab=vpres5}
N -2170 -5580 -2160 -5580 {
lab=vb_wu}
N -2170 -5940 -2160 -5940 {
lab=ctrl_stdp}
N -2170 -5790 -2160 -5790 {
lab=ctrl_inf}
N -2110 -5670 -2110 -5650 {
lab=vdd_wu}
N -2110 -5820 -2110 -5800 {
lab=vdd_inf}
N -2110 -5970 -2110 -5950 {
lab=vdd_stdp}
N -2170 -5640 -2160 -5640 {
lab=ctrl_wu}
N -2160 -5640 -2160 -5610 {
lab=ctrl_wu}
N -2110 -5350 -2110 -5340 {
lab=GND}
N -2110 -5050 -2110 -5040 {
lab=GND}
N -2060 -5090 -2050 -5090 {
lab=vpres6}
N -2110 -5200 -2110 -5190 {
lab=GND}
N -2170 -5240 -2160 -5240 {
lab=vpre6}
N -2170 -5390 -2160 -5390 {
lab=vpre6}
N -2060 -5390 -2050 -5390 {
lab=vpos6}
N -2060 -5240 -2050 -5240 {
lab=vpres6}
N -2170 -5060 -2160 -5060 {
lab=vb_wu}
N -2170 -5420 -2160 -5420 {
lab=ctrl_stdp}
N -2170 -5270 -2160 -5270 {
lab=ctrl_inf}
N -2110 -5150 -2110 -5130 {
lab=vdd_wu}
N -2110 -5300 -2110 -5280 {
lab=vdd_inf}
N -2110 -5450 -2110 -5430 {
lab=vdd_stdp}
N -2170 -5120 -2160 -5120 {
lab=ctrl_wu}
N -2160 -5120 -2160 -5090 {
lab=ctrl_wu}
N -2110 -4830 -2110 -4820 {
lab=GND}
N -2110 -4530 -2110 -4520 {
lab=GND}
N -2060 -4570 -2050 -4570 {
lab=vpres7}
N -2110 -4680 -2110 -4670 {
lab=GND}
N -2170 -4720 -2160 -4720 {
lab=vpre7}
N -2170 -4870 -2160 -4870 {
lab=vpre7}
N -2060 -4870 -2050 -4870 {
lab=vpos7}
N -2060 -4720 -2050 -4720 {
lab=vpres7}
N -2170 -4540 -2160 -4540 {
lab=vb_wu}
N -2170 -4900 -2160 -4900 {
lab=ctrl_stdp}
N -2170 -4750 -2160 -4750 {
lab=ctrl_inf}
N -2110 -4630 -2110 -4610 {
lab=vdd_wu}
N -2110 -4780 -2110 -4760 {
lab=vdd_inf}
N -2110 -4930 -2110 -4910 {
lab=vdd_stdp}
N -2170 -4600 -2160 -4600 {
lab=ctrl_wu}
N -2160 -4600 -2160 -4570 {
lab=ctrl_wu}
N -2110 -4310 -2110 -4300 {
lab=GND}
N -2110 -4010 -2110 -4000 {
lab=GND}
N -2060 -4050 -2050 -4050 {
lab=vpres8}
N -2110 -4160 -2110 -4150 {
lab=GND}
N -2170 -4200 -2160 -4200 {
lab=vpre8}
N -2170 -4350 -2160 -4350 {
lab=vpre8}
N -2060 -4350 -2050 -4350 {
lab=vpos8}
N -2060 -4200 -2050 -4200 {
lab=vpres8}
N -2170 -4020 -2160 -4020 {
lab=vb_wu}
N -2170 -4380 -2160 -4380 {
lab=ctrl_stdp}
N -2170 -4230 -2160 -4230 {
lab=ctrl_inf}
N -2110 -4110 -2110 -4090 {
lab=vdd_wu}
N -2110 -4260 -2110 -4240 {
lab=vdd_inf}
N -2110 -4410 -2110 -4390 {
lab=vdd_stdp}
N -2170 -4080 -2160 -4080 {
lab=ctrl_wu}
N -2160 -4080 -2160 -4050 {
lab=ctrl_wu}
N -2110 -3790 -2110 -3780 {
lab=GND}
N -2110 -3490 -2110 -3480 {
lab=GND}
N -2060 -3530 -2050 -3530 {
lab=vpres9}
N -2110 -3640 -2110 -3630 {
lab=GND}
N -2170 -3680 -2160 -3680 {
lab=vpre9}
N -2170 -3830 -2160 -3830 {
lab=vpre9}
N -2060 -3830 -2050 -3830 {
lab=vpos9}
N -2060 -3680 -2050 -3680 {
lab=vpres9}
N -2170 -3500 -2160 -3500 {
lab=vb_wu}
N -2170 -3860 -2160 -3860 {
lab=ctrl_stdp}
N -2170 -3710 -2160 -3710 {
lab=ctrl_inf}
N -2110 -3590 -2110 -3570 {
lab=vdd_wu}
N -2110 -3740 -2110 -3720 {
lab=vdd_inf}
N -2110 -3890 -2110 -3870 {
lab=vdd_stdp}
N -2170 -3560 -2160 -3560 {
lab=ctrl_wu}
N -2160 -3560 -2160 -3530 {
lab=ctrl_wu}
N -2110 -3270 -2110 -3260 {
lab=GND}
N -2110 -2970 -2110 -2960 {
lab=GND}
N -2060 -3010 -2050 -3010 {
lab=vpres10}
N -2110 -3120 -2110 -3110 {
lab=GND}
N -2170 -3160 -2160 -3160 {
lab=vpre10}
N -2170 -3310 -2160 -3310 {
lab=vpre10}
N -2060 -3310 -2050 -3310 {
lab=vpos10}
N -2060 -3160 -2050 -3160 {
lab=vpres10}
N -2170 -2980 -2160 -2980 {
lab=vb_wu}
N -2170 -3340 -2160 -3340 {
lab=ctrl_stdp}
N -2170 -3190 -2160 -3190 {
lab=ctrl_inf}
N -2110 -3070 -2110 -3050 {
lab=vdd_wu}
N -2110 -3220 -2110 -3200 {
lab=vdd_inf}
N -2110 -3370 -2110 -3350 {
lab=vdd_stdp}
N -2170 -3040 -2160 -3040 {
lab=ctrl_wu}
N -2160 -3040 -2160 -3010 {
lab=ctrl_wu}
N -2110 -2750 -2110 -2740 {
lab=GND}
N -2110 -2450 -2110 -2440 {
lab=GND}
N -2060 -2490 -2050 -2490 {
lab=vpres11}
N -2110 -2600 -2110 -2590 {
lab=GND}
N -2170 -2640 -2160 -2640 {
lab=vpre11}
N -2170 -2790 -2160 -2790 {
lab=vpre11}
N -2060 -2790 -2050 -2790 {
lab=vpos11}
N -2060 -2640 -2050 -2640 {
lab=vpres11}
N -2170 -2460 -2160 -2460 {
lab=vb_wu}
N -2170 -2820 -2160 -2820 {
lab=ctrl_stdp}
N -2170 -2670 -2160 -2670 {
lab=ctrl_inf}
N -2110 -2550 -2110 -2530 {
lab=vdd_wu}
N -2110 -2700 -2110 -2680 {
lab=vdd_inf}
N -2110 -2850 -2110 -2830 {
lab=vdd_stdp}
N -2170 -2520 -2160 -2520 {
lab=ctrl_wu}
N -2160 -2520 -2160 -2490 {
lab=ctrl_wu}
N -2110 -2230 -2110 -2220 {
lab=GND}
N -2110 -1930 -2110 -1920 {
lab=GND}
N -2060 -1970 -2050 -1970 {
lab=vpres12}
N -2110 -2080 -2110 -2070 {
lab=GND}
N -2170 -2120 -2160 -2120 {
lab=vpre12}
N -2170 -2270 -2160 -2270 {
lab=vpre12}
N -2060 -2270 -2050 -2270 {
lab=vpos12}
N -2060 -2120 -2050 -2120 {
lab=vpres12}
N -2170 -1940 -2160 -1940 {
lab=vb_wu}
N -2170 -2300 -2160 -2300 {
lab=ctrl_stdp}
N -2170 -2150 -2160 -2150 {
lab=ctrl_inf}
N -2110 -2030 -2110 -2010 {
lab=vdd_wu}
N -2110 -2180 -2110 -2160 {
lab=vdd_inf}
N -2110 -2330 -2110 -2310 {
lab=vdd_stdp}
N -2170 -2000 -2160 -2000 {
lab=ctrl_wu}
N -2160 -2000 -2160 -1970 {
lab=ctrl_wu}
N -2110 -1710 -2110 -1700 {
lab=GND}
N -2110 -1410 -2110 -1400 {
lab=GND}
N -2060 -1450 -2050 -1450 {
lab=vpres13}
N -2110 -1560 -2110 -1550 {
lab=GND}
N -2170 -1600 -2160 -1600 {
lab=vpre13}
N -2170 -1750 -2160 -1750 {
lab=vpre13}
N -2060 -1750 -2050 -1750 {
lab=vpos13}
N -2060 -1600 -2050 -1600 {
lab=vpres13}
N -2170 -1420 -2160 -1420 {
lab=vb_wu}
N -2170 -1780 -2160 -1780 {
lab=ctrl_stdp}
N -2170 -1630 -2160 -1630 {
lab=ctrl_inf}
N -2110 -1510 -2110 -1490 {
lab=vdd_wu}
N -2110 -1660 -2110 -1640 {
lab=vdd_inf}
N -2110 -1810 -2110 -1790 {
lab=vdd_stdp}
N -2170 -1480 -2160 -1480 {
lab=ctrl_wu}
N -2160 -1480 -2160 -1450 {
lab=ctrl_wu}
N -2110 -1190 -2110 -1180 {
lab=GND}
N -2110 -890 -2110 -880 {
lab=GND}
N -2060 -930 -2050 -930 {
lab=vpres14}
N -2110 -1040 -2110 -1030 {
lab=GND}
N -2170 -1080 -2160 -1080 {
lab=vpre14}
N -2170 -1230 -2160 -1230 {
lab=vpre14}
N -2060 -1230 -2050 -1230 {
lab=vpos14}
N -2170 -900 -2160 -900 {
lab=vb_wu}
N -2170 -1260 -2160 -1260 {
lab=ctrl_stdp}
N -2170 -1110 -2160 -1110 {
lab=ctrl_inf}
N -2110 -990 -2110 -970 {
lab=vdd_wu}
N -2110 -1140 -2110 -1120 {
lab=vdd_inf}
N -2110 -1290 -2110 -1270 {
lab=vdd_stdp}
N -2170 -960 -2160 -960 {
lab=ctrl_wu}
N -2160 -960 -2160 -930 {
lab=ctrl_wu}
N -2110 -670 -2110 -660 {
lab=GND}
N -2110 -370 -2110 -360 {
lab=GND}
N -2060 -410 -2050 -410 {
lab=vpres15}
N -2110 -520 -2110 -510 {
lab=GND}
N -2170 -710 -2160 -710 {
lab=vpre15}
N -2060 -710 -2050 -710 {
lab=vpos15}
N -2170 -380 -2160 -380 {
lab=vb_wu}
N -2170 -740 -2160 -740 {
lab=ctrl_stdp}
N -2170 -590 -2160 -590 {
lab=ctrl_inf}
N -2110 -470 -2110 -450 {
lab=vdd_wu}
N -2110 -620 -2110 -600 {
lab=vdd_inf}
N -2110 -770 -2110 -750 {
lab=vdd_stdp}
N -2170 -440 -2160 -440 {
lab=ctrl_wu}
N -2160 -440 -2160 -410 {
lab=ctrl_wu}
N -2170 -7990 -2160 -7990 {
lab=vpre1}
N -2170 -7840 -2160 -7840 {
lab=vpre1}
N -2170 -7320 -2160 -7320 {
lab=vpre2}
N -2170 -560 -2160 -560 {
lab=vpre15}
N -2060 -560 -2050 -560 {
lab=vpres15}
N -1870 -560 -1860 -560 {
lab=vpres15}
N -1870 -1080 -1860 -1080 {
lab=vpres14}
N -1740 -1080 -1730 -1080 {
lab=vpos14}
N -2060 -1080 -2050 -1080 {
lab=vpres14}
N -1340 -2480 -1340 -2460 {
lab=GND}
N -1340 -2560 -1340 -2540 {
lab=vb_tr}
N -2170 -680 -2160 -680 {
lab=vb_tr}
N -2170 -1200 -2160 -1200 {
lab=vb_tr}
N -2170 -1720 -2160 -1720 {
lab=vb_tr}
N -2170 -2240 -2160 -2240 {
lab=vb_tr}
N -2170 -2760 -2160 -2760 {
lab=vb_tr}
N -2170 -3280 -2160 -3280 {
lab=vb_tr}
N -2170 -3800 -2160 -3800 {
lab=vb_tr}
N -2170 -4320 -2160 -4320 {
lab=vb_tr}
N -2170 -4840 -2160 -4840 {
lab=vb_tr}
N -2170 -5360 -2160 -5360 {
lab=vb_tr}
N -2170 -5880 -2160 -5880 {
lab=vb_tr}
N -2170 -6400 -2160 -6400 {
lab=vb_tr}
N -2170 -6920 -2160 -6920 {
lab=vb_tr}
N -2170 -7440 -2160 -7440 {
lab=vb_tr}
N -2170 -7960 -2160 -7960 {
lab=vb_tr}
C {devices/vsource.sym} -1580 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1580 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1500 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1500 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1500 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2480 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2580 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2860 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -1490 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1610 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1360 -2120 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
	save all
	tran 10n 140u
	wrdata SNN_15x1_tbv1.ssv v(8)
.endc
" }
C {devices/launcher.sym} -1520 -1735 0 0 {name=h1
descr="load 1" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tbv1.raw tran"
}
C {devices/lab_pin.sym} -2660 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} -1320 -2650 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} -1320 -2600 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1320 -2700 2 0 {name=p16 sig_type=std_logic lab=vdd_stdp}
C {devices/gnd.sym} -1800 -7770 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -1870 -7840 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1730 -7840 2 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1740 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -1740 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1780 -250 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -130 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -1740 -290 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -1740 -330 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1740 0 2 0 {name=p61 sig_type=std_logic lab=8}
C {devices/vsource.sym} -1580 -2230 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1580 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1400 -2230 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} -1400 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1400 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} -1140 -2230 0 0 {name=V15 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1140 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1140 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -2830 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} -1580 -2370 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1580 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} -1500 -2370 0 0 {name=V12 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} -1500 -2320 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1500 -2420 2 0 {name=p17 sig_type=std_logic lab=ctrl_stdp}
C {devices/vsource.sym} -1420 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1420 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1420 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} -1410 -2650 0 0 {name=V3 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1410 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1410 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1220 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1220 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1220 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1140 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1140 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1140 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1580 -2510 0 0 {name=V7 value="PWL(0 0.8 124.9u 0.8 125u 0.45)"
*0.55}
C {devices/gnd.sym} -1580 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1580 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1500 -2510 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1500 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1500 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2480 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1670 -130 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1580 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2720 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2580 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -7790 0 0 {name=I1 value=0}
C {devices/gnd.sym} -2860 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -1800 -7250 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -1870 -7320 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1730 -7320 2 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2110 -7940 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -2050 -7990 2 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2170 -7990 0 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -1740 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -1740 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -2050 -7690 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2330 -7840 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2830 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -2110 -7640 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -2050 -7840 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2170 -7840 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2170 -7870 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2480 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2110 -8050 0 0 {name=p45 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -7900 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2720 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1790 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1790 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1400 -2370 0 0 {name=V16 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1400 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1400 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} -1060 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -1060 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -1060 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} -940 -1830 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -940 -1950 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -1810 -250 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} -1240 -2370 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -1240 -2320 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -1240 -2420 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} -870 -1890 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -930 -1740 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} -970 -1720 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -970 -1750 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -970 -1690 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -1010 -1740 0 0 {name=p85 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} -1260 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -1260 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -1260 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1700 -250 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -980 -2650 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -980 -2600 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -980 -2700 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -1800 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -1740 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -1740 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -1870 -6280 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -1740 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -1740 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -1870 -5760 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -1740 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -1740 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -1740 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -1740 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -1740 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -1740 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -1740 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -1740 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -1870 -3680 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1730 -3680 2 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -1740 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -1740 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2480 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -2580 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -6230 0 0 {name=I4 value=0}
C {devices/gnd.sym} -2860 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -2830 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -2480 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -2580 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -6750 0 0 {name=I3 value=0}
C {devices/gnd.sym} -2860 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -2830 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -2480 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -2580 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -5190 0 0 {name=I6 value=0}
C {devices/gnd.sym} -2860 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -2830 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -2480 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -2580 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -5710 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2860 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -2830 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -2480 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -2580 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -4150 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2860 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -2830 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -2480 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -2580 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -4670 0 0 {name=I7 value=0}
C {devices/gnd.sym} -2860 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -2830 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -2480 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -2580 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -3630 0 0 {name=I9 value=0}
C {devices/gnd.sym} -2860 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -2830 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -2480 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1020 -1870 0 0 {name=p105 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} -2330 -7320 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2330 -6800 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1870 -6800 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2330 -3680 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1870 -4200 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2330 -4200 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1870 -4720 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2330 -4720 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1870 -5240 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2330 -5240 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2330 -5760 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2330 -6280 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1730 -4200 2 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1730 -4720 2 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1730 -5240 2 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1730 -5760 2 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1730 -6280 2 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1730 -6800 2 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/launcher.sym} -1510 -1815 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -150 1 0 {name=x0}
C {devices/gnd.sym} -1800 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -1740 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1740 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -1740 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -1740 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -1740 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -1740 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -1740 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -1740 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -1740 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -1740 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1800 -610 1 0 {name=p319 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2480 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -2580 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -3110 0 0 {name=I10 value=0}
C {devices/gnd.sym} -2860 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -2830 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -2480 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -2580 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -2070 0 0 {name=I12 value=0}
C {devices/gnd.sym} -2860 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -2830 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -2480 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -2580 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -2590 0 0 {name=I11 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2860 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -2830 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -2480 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -2580 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2860 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -2830 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -2480 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2480 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -2580 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -1550 0 0 {name=I13 value=0}
C {devices/gnd.sym} -2860 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -2830 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -2480 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2580 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2480 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -2580 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2860 -510 0 0 {name=I15 value=0}
C {devices/gnd.sym} -2860 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2680 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2760 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2660 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -2830 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -2480 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2720 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2580 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2330 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2330 -1080 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2330 -1600 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2330 -2640 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2330 -3160 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2480 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -1870 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1730 -560 2 0 {name=p405 sig_type=std_logic lab=vpos15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -940 -1890 0 0 {name=x2}
C {devices/lab_pin.sym} -1870 -1080 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1730 -1080 2 0 {name=p382 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -1870 -1600 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1730 -1600 2 0 {name=p392 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -1730 -3160 2 0 {name=p394 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -1870 -3160 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1870 -2640 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1730 -2640 2 0 {name=p400 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2330 -2120 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1870 -2120 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1730 -2120 2 0 {name=p396 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -1800 -7890 1 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -7370 1 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6850 1 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6330 1 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5810 1 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5290 1 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4770 1 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4250 1 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3730 1 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3210 1 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2690 1 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2170 1 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1650 1 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1130 1 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -1020 -1900 0 0 {name=l7 lab=GND}
C {devices/launcher.sym} -1520 -1675 0 0 {name=h3
descr="load 8" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tb.raw tran"
}
C {devices/lab_pin.sym} -2170 -8020 0 0 {name=p15 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -7690 0 0 {name=x2013}
C {devices/lab_pin.sym} -2170 -7720 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} -1320 -2370 0 0 {name=V20 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1320 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -1320 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2110 -7420 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -2050 -7470 2 0 {name=p2 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -2110 -7120 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -2170 -7350 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -7270 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -2110 -7530 0 0 {name=p24 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -7230 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -7380 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -7500 0 0 {name=p49 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -7320 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -7170 0 0 {name=x2023}
C {devices/lab_pin.sym} -2170 -7200 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -6900 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -2050 -6950 2 0 {name=p52 sig_type=std_logic lab=vpos3}
C {devices/gnd.sym} -2110 -6600 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -2170 -6830 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -6750 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2110 -7010 0 0 {name=p62 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -6710 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -6860 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -6980 0 0 {name=p69 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -6800 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -6650 0 0 {name=x2033}
C {devices/lab_pin.sym} -2170 -6680 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -6380 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -2050 -6430 2 0 {name=p77 sig_type=std_logic lab=vpos4}
C {devices/gnd.sym} -2110 -6080 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -2170 -6310 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -6230 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -2110 -6490 0 0 {name=p90 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -6190 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -6340 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -6460 0 0 {name=p99 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -6280 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -6130 0 0 {name=x2043}
C {devices/lab_pin.sym} -2170 -6160 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -5860 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -2050 -5910 2 0 {name=p102 sig_type=std_logic lab=vpos5}
C {devices/gnd.sym} -2110 -5560 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2170 -5790 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -5710 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -2110 -5970 0 0 {name=p112 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -5670 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -5820 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -5940 0 0 {name=p118 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -5760 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -5610 0 0 {name=x2053}
C {devices/lab_pin.sym} -2170 -5640 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -5340 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -2050 -5390 2 0 {name=p122 sig_type=std_logic lab=vpos6}
C {devices/gnd.sym} -2110 -5040 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -2170 -5270 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -5190 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -2110 -5450 0 0 {name=p132 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -5150 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -5300 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -5420 0 0 {name=p137 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -5240 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -5090 0 0 {name=x2063}
C {devices/lab_pin.sym} -2170 -5120 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -4820 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -2050 -4870 2 0 {name=p145 sig_type=std_logic lab=vpos7}
C {devices/gnd.sym} -2110 -4520 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -2170 -4750 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -4670 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -2110 -4930 0 0 {name=p151 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -4630 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -4780 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -4900 0 0 {name=p155 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -4720 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -4570 0 0 {name=x2073}
C {devices/lab_pin.sym} -2170 -4600 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -4300 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -2050 -4350 2 0 {name=p157 sig_type=std_logic lab=vpos8}
C {devices/gnd.sym} -2110 -4000 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -2170 -4230 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -4150 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -2110 -4410 0 0 {name=p166 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -4110 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -4260 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -4380 0 0 {name=p171 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -4200 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -4050 0 0 {name=x2083}
C {devices/lab_pin.sym} -2170 -4080 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -3780 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -2050 -3830 2 0 {name=p173 sig_type=std_logic lab=vpos9}
C {devices/gnd.sym} -2110 -3480 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -2170 -3710 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -3630 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -2110 -3890 0 0 {name=p181 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -3590 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -3740 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -3860 0 0 {name=p186 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -3680 0 0 {name=x2092}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -3530 0 0 {name=x2093}
C {devices/lab_pin.sym} -2170 -3560 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -3260 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -2050 -3310 2 0 {name=p188 sig_type=std_logic lab=vpos10}
C {devices/gnd.sym} -2110 -2960 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -2170 -3190 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -3110 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -2110 -3370 0 0 {name=p194 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -3070 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -3220 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -3340 0 0 {name=p198 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -3160 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -3010 0 0 {name=x2103}
C {devices/lab_pin.sym} -2170 -3040 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -2740 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -2050 -2790 2 0 {name=p200 sig_type=std_logic lab=vpos11}
C {devices/gnd.sym} -2110 -2440 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -2170 -2670 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -2590 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -2110 -2850 0 0 {name=p206 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -2550 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -2700 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -2820 0 0 {name=p210 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -2640 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -2490 0 0 {name=x2113}
C {devices/lab_pin.sym} -2170 -2520 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -2220 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -2050 -2270 2 0 {name=p212 sig_type=std_logic lab=vpos12}
C {devices/gnd.sym} -2110 -1920 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -2170 -2150 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -2070 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -2110 -2330 0 0 {name=p221 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -2030 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -2180 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -2300 0 0 {name=p227 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -2120 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -1970 0 0 {name=x2123}
C {devices/lab_pin.sym} -2170 -2000 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -1700 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -2050 -1750 2 0 {name=p229 sig_type=std_logic lab=vpos13}
C {devices/gnd.sym} -2110 -1400 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -2170 -1630 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -1550 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -2110 -1810 0 0 {name=p236 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -1510 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -1660 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -1780 0 0 {name=p240 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -1600 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -1450 0 0 {name=x2133}
C {devices/lab_pin.sym} -2170 -1480 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -1180 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -2050 -1230 2 0 {name=p242 sig_type=std_logic lab=vpos14}
C {devices/gnd.sym} -2110 -880 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -2170 -1110 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -1030 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -2110 -1290 0 0 {name=p248 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -990 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -1140 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -1260 0 0 {name=p253 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -1080 0 0 {name=x42}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -930 0 0 {name=x44}
C {devices/lab_pin.sym} -2170 -960 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -2110 -660 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -2050 -710 2 0 {name=p255 sig_type=std_logic lab=vpos15}
C {devices/gnd.sym} -2110 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -2170 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -2110 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -2110 -770 0 0 {name=p261 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -2110 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -2110 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2170 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -740 0 0 {name=p266 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -2110 -560 0 0 {name=x45}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -2110 -410 0 0 {name=x47}
C {devices/lab_pin.sym} -2170 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -2050 -7320 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2050 -7170 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2170 -7320 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2170 -7470 0 0 {name=p20 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2170 -6800 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2170 -6950 0 0 {name=p54 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2050 -6800 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2050 -6650 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2170 -6280 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2170 -6430 0 0 {name=p83 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2050 -6280 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2050 -6130 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -2050 -5760 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2050 -5610 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2170 -5760 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2170 -5910 0 0 {name=p109 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2170 -5240 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2170 -5390 0 0 {name=p126 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2050 -5240 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2050 -5090 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2170 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2170 -710 0 0 {name=p147 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2050 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2050 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2170 -1080 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2170 -1230 0 0 {name=p244 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2050 -1080 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2050 -930 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2170 -1600 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2170 -1750 0 0 {name=p231 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2050 -1600 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2050 -1450 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2170 -2120 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2170 -2270 0 0 {name=p214 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2050 -2120 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2050 -1970 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -2050 -2640 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2050 -2490 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2170 -2640 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2170 -2790 0 0 {name=p204 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2170 -3160 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2170 -3310 0 0 {name=p190 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2050 -3160 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2050 -3010 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2170 -3680 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2170 -3830 0 0 {name=p175 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2050 -3680 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2050 -3530 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2170 -4200 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2170 -4350 0 0 {name=p161 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2050 -4200 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2050 -4050 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2170 -4720 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2170 -4870 0 0 {name=p257 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2050 -4720 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2050 -4570 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -7990 0 0 {name=x2011}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -710 0 0 {name=x3}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -1230 0 0 {name=x6}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -1750 0 0 {name=x2131}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -2270 0 0 {name=x2121}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -2790 0 0 {name=x2111}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -3310 0 0 {name=x2101}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -3830 0 0 {name=x2091}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -4350 0 0 {name=x2081}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -4870 0 0 {name=x2071}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -5390 0 0 {name=x2061}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -5910 0 0 {name=x2051}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -6430 0 0 {name=x2041}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -6950 0 0 {name=x2031}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Tr_Circuit.sym} -2110 -7470 0 0 {name=x2021}
C {devices/vsource.sym} -1340 -2510 0 0 {name=V21 value=0.5}
C {devices/gnd.sym} -1340 -2460 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -1340 -2560 2 0 {name=p268 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -680 0 0 {name=p269 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -900 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -1200 0 0 {name=p68 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -1420 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -1720 0 0 {name=p100 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -1940 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -2240 0 0 {name=p135 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -2460 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -2760 0 0 {name=p169 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -2980 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -3280 0 0 {name=p197 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -3500 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -3800 0 0 {name=p226 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -4020 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -4320 0 0 {name=p251 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -4540 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -4840 0 0 {name=p271 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -5060 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -5360 0 0 {name=p273 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -5580 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -5880 0 0 {name=p275 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -6100 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -6400 0 0 {name=p278 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -6620 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -6920 0 0 {name=p280 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -7140 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -7440 0 0 {name=p282 sig_type=std_logic lab=vb_tr}
C {devices/lab_pin.sym} -2170 -7660 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -2170 -7960 0 0 {name=p284 sig_type=std_logic lab=vb_tr}
