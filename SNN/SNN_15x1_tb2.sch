v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1600 -1200 -800 -800 {flags=graph
y1=0.21
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpos1; vpos1\\"
\\"vpos2; vpos2\\"
\\"vpos3; vpos3\\"
\\"vpos4; vpos4\\"
\\"vpos5; vpos5\\"
\\"vpos6; vpos6\\"
\\"vpos7; vpos7\\"
\\"vpos8; vpos8\\"
\\"vpos9; vpos9\\""}
B 2 -800 -400 0 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Update Weights;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 -1600 -400 -800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="17 18 19"
node="\\"Syn1;vdd_syn1\\"
\\"Syn2;vdd_syn2\\"
\\"Syn3;vdd_syn3\\""}
B 2 0 -2400 800 -2000 {flags=graph
y1=-5.2e-07
y2=2.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas0)\\"
\\"Ip1;i(vmeas1)\\"
\\"Ip2;i(vmeas2)\\""}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=0.14
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=8}
B 2 -800 -1600 0 -1200 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16 18"
node="inh0
inh1
inh2"}
B 2 -1600 -800 -800 -400 {flags=graph
y1=2.2
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\""}
B 2 -800 -800 0 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 800 -2400 1600 -2000 {flags=graph
y1=-0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0



color="15 16"
node="p0
p1"}
B 2 0 -2000 800 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 0 -1600 800 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 0 -1200 800 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 800 -2000 1600 -1600 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 800 -1600 1600 -1200 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 800 -1200 1600 -800 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 0 -800 800 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 0 -400 800 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 800 -800 1600 -400 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 800 -400 1600 0 {flags=graph
y1=0.62
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 -800 -1200 0 -800 {flags=graph
y1=-7.4e-07
y2=7.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.02032e-05
x2=5.06486e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas0)}
N -1580 -2520 -1580 -2500 {
lab=GND}
N -1580 -2600 -1580 -2580 {
lab=vdd_in}
N -1500 -2520 -1500 -2500 {
lab=GND}
N -1500 -2600 -1500 -2580 {
lab=vdd_pre}
N -2310 -7250 -2310 -7230 {
lab=GND}
N -2310 -7410 -2310 -7390 {
lab=vdd_pre}
N -2690 -7240 -2690 -7220 {
lab=GND}
N -2490 -7340 -2490 -7320 {
lab=vc2}
N -2490 -7370 -2480 -7370 {
lab=vdd_in}
N -2480 -7400 -2480 -7370 {
lab=vdd_in}
N -2490 -7400 -2480 -7400 {
lab=vdd_in}
N -2570 -7370 -2530 -7370 {
lab=#net1}
N -2610 -7400 -2490 -7400 {
lab=vdd_in}
N -2620 -7370 -2610 -7370 {
lab=vdd_in}
N -2620 -7400 -2620 -7370 {
lab=vdd_in}
N -2620 -7400 -2610 -7400 {
lab=vdd_in}
N -2610 -7340 -2610 -7320 {
lab=#net1}
N -2610 -7320 -2550 -7320 {
lab=#net1}
N -2550 -7370 -2550 -7320 {
lab=#net1}
N -2690 -7320 -2690 -7300 {
lab=#net2}
N -1320 -2520 -1320 -2500 {
lab=GND}
N -1320 -2600 -1320 -2580 {
lab=vdd_stdp}
N -1800 -7780 -1800 -7770 {
lab=GND}
N -1800 -7890 -1800 -7880 {
lab=vdd_syn0}
N -1740 -7700 -1730 -7700 {
lab=GND}
N -1740 -7670 -1740 -7660 {
lab=p0}
N -1740 -260 -1740 -250 {
lab=#net3}
N -1740 -330 -1740 -320 {
lab=p0}
N -1740 -10 -1740 0 {
lab=8}
N -1580 -2100 -1580 -2080 {
lab=GND}
N -1580 -2180 -1580 -2160 {
lab=uw}
N -1400 -2100 -1400 -2080 {
lab=GND}
N -1400 -2180 -1400 -2160 {
lab=training}
N -2170 -7320 -2160 -7320 {
lab=vpre2}
N -1810 -150 -1810 -130 {
lab=GND}
N -1670 -150 -1670 -130 {
lab=vdd_pos}
N -1140 -2100 -1140 -2080 {
lab=GND}
N -1140 -2180 -1140 -2160 {
lab=inference}
N -2630 -7320 -2610 -7320 {
lab=#net1}
N -1580 -2240 -1580 -2220 {
lab=GND}
N -1580 -2320 -1580 -2300 {
lab=ctrl_wu}
N -1500 -2240 -1500 -2220 {
lab=GND}
N -1500 -2320 -1500 -2300 {
lab=ctrl_stdp}
N -1420 -2380 -1420 -2360 {
lab=GND}
N -1420 -2460 -1420 -2440 {
lab=vbias}
N -1410 -2520 -1410 -2500 {
lab=GND}
N -1410 -2600 -1410 -2580 {
lab=vdd_pos}
N -1220 -2520 -1220 -2500 {
lab=GND}
N -1220 -2600 -1220 -2580 {
lab=vdd_sw}
N -1140 -2520 -1140 -2500 {
lab=GND}
N -1140 -2600 -1140 -2580 {
lab=vdd_tg}
N -1580 -2380 -1580 -2360 {
lab=GND}
N -1580 -2460 -1580 -2440 {
lab=vb_pre}
N -1500 -2380 -1500 -2360 {
lab=GND}
N -1500 -2460 -1500 -2440 {
lab=vb_pos}
N -1860 -7850 -1860 -7840 {
lab=vpres1}
N -1740 -7850 -1740 -7840 {
lab=vpos1}
N -2310 -7770 -2310 -7750 {
lab=GND}
N -2310 -7930 -2310 -7910 {
lab=vdd_pre}
N -2690 -7760 -2690 -7740 {
lab=GND}
N -2490 -7860 -2490 -7840 {
lab=vc1}
N -2490 -7890 -2480 -7890 {
lab=vdd_in}
N -2480 -7920 -2480 -7890 {
lab=vdd_in}
N -2490 -7920 -2480 -7920 {
lab=vdd_in}
N -2570 -7890 -2530 -7890 {
lab=#net4}
N -2610 -7920 -2490 -7920 {
lab=vdd_in}
N -2620 -7890 -2610 -7890 {
lab=vdd_in}
N -2620 -7920 -2620 -7890 {
lab=vdd_in}
N -2620 -7920 -2610 -7920 {
lab=vdd_in}
N -2610 -7860 -2610 -7840 {
lab=#net4}
N -2610 -7840 -2550 -7840 {
lab=#net4}
N -2550 -7890 -2550 -7840 {
lab=#net4}
N -2690 -7840 -2690 -7820 {
lab=#net5}
N -1800 -7260 -1800 -7250 {
lab=GND}
N -1800 -7370 -1800 -7360 {
lab=vdd_syn0}
N -1990 -7950 -1990 -7940 {
lab=GND}
N -1740 -7180 -1730 -7180 {
lab=GND}
N -1740 -7150 -1740 -7140 {
lab=p0}
N -2170 -7840 -2160 -7840 {
lab=vpre1}
N -2630 -7840 -2610 -7840 {
lab=#net4}
N -1990 -7650 -1990 -7640 {
lab=GND}
N -1940 -7700 -1940 -7690 {
lab=vpres1}
N -1990 -7800 -1990 -7790 {
lab=GND}
N -2040 -7840 -2040 -7830 {
lab=vpre1}
N -2040 -7990 -2040 -7980 {
lab=vpre1}
N -1940 -7990 -1940 -7980 {
lab=vpos1}
N -1940 -7850 -1940 -7840 {
lab=vpres1}
N -1860 -7330 -1860 -7320 {
lab=vpres2}
N -1740 -7330 -1740 -7320 {
lab=vpos2}
N -1790 -7180 -1780 -7180 {
lab=ctrl_pos}
N -1790 -7700 -1780 -7700 {
lab=ctrl_pos}
N -1400 -2240 -1400 -2220 {
lab=GND}
N -1400 -2320 -1400 -2300 {
lab=ctrl_inf}
N -1060 -2520 -1060 -2500 {
lab=GND}
N -1060 -2600 -1060 -2580 {
lab=vdd_inh}
N -940 -1850 -940 -1840 {
lab=vdd_inh}
N -1240 -2240 -1240 -2220 {
lab=GND}
N -1240 -2320 -1240 -2300 {
lab=ctrl_vinh}
N -940 -1740 -940 -1730 {
lab=GND}
N -880 -1790 -870 -1790 {
lab=inh_d}
N -940 -1640 -930 -1640 {
lab=inh0}
N -970 -1650 -970 -1640 {
lab=GND}
N -970 -1600 -970 -1590 {
lab=inh_d}
N -1010 -1640 -1000 -1640 {
lab=ctrl_vinh}
N -1350 -2380 -1350 -2360 {
lab=GND}
N -1350 -2460 -1350 -2440 {
lab=vlky}
N -2490 -7840 -2410 -7840 {
lab=vc1}
N -2410 -7880 -2400 -7880 {
lab=vlky}
N -2410 -7800 -2400 -7800 {
lab=vb_pre}
N -2410 -7360 -2400 -7360 {
lab=vlky}
N -2490 -7320 -2410 -7320 {
lab=vc2}
N -2410 -7280 -2400 -7280 {
lab=vb_pre}
N -1810 -250 -1810 -240 {
lab=inh0}
N -1780 -250 -1780 -240 {
lab=vb_pos}
N -1700 -250 -1700 -240 {
lab=vlky}
N -980 -2520 -980 -2500 {
lab=GND}
N -980 -2600 -980 -2580 {
lab=vdd_syn0}
N -2050 -7660 -2040 -7660 {
lab=vbias}
N -1740 -7820 -1740 -7800 {
lab=#net6}
N -1740 -7740 -1740 -7730 {
lab=#net7}
N -1740 -7300 -1740 -7280 {
lab=#net8}
N -1740 -7220 -1740 -7210 {
lab=#net9}
N -1800 -6740 -1800 -6730 {
lab=GND}
N -1800 -6850 -1800 -6840 {
lab=vdd_syn0}
N -1740 -6660 -1730 -6660 {
lab=GND}
N -1740 -6630 -1740 -6620 {
lab=p0}
N -1860 -6810 -1860 -6800 {
lab=vpres3}
N -1740 -6810 -1740 -6800 {
lab=vpos3}
N -1790 -6660 -1780 -6660 {
lab=ctrl_pos}
N -1740 -6780 -1740 -6760 {
lab=#net10}
N -1740 -6700 -1740 -6690 {
lab=#net11}
N -1800 -6220 -1800 -6210 {
lab=GND}
N -1800 -6330 -1800 -6320 {
lab=vdd_syn0}
N -1740 -6140 -1730 -6140 {
lab=GND}
N -1740 -6110 -1740 -6100 {
lab=p0}
N -1860 -6290 -1860 -6280 {
lab=vpres4}
N -1740 -6290 -1740 -6280 {
lab=vpos4}
N -1790 -6140 -1780 -6140 {
lab=ctrl_pos}
N -1740 -6260 -1740 -6240 {
lab=#net12}
N -1740 -6180 -1740 -6170 {
lab=#net13}
N -1800 -5700 -1800 -5690 {
lab=GND}
N -1800 -5810 -1800 -5800 {
lab=vdd_syn0}
N -1740 -5620 -1730 -5620 {
lab=GND}
N -1740 -5590 -1740 -5580 {
lab=p0}
N -1860 -5770 -1860 -5760 {
lab=vpres5}
N -1740 -5770 -1740 -5760 {
lab=vpos5}
N -1790 -5620 -1780 -5620 {
lab=ctrl_pos}
N -1740 -5740 -1740 -5720 {
lab=#net14}
N -1740 -5660 -1740 -5650 {
lab=#net15}
N -1800 -5180 -1800 -5170 {
lab=GND}
N -1800 -5290 -1800 -5280 {
lab=vdd_syn0}
N -1740 -5100 -1730 -5100 {
lab=GND}
N -1740 -5070 -1740 -5060 {
lab=p0}
N -1860 -5250 -1860 -5240 {
lab=vpres6}
N -1740 -5250 -1740 -5240 {
lab=vpos6}
N -1790 -5100 -1780 -5100 {
lab=ctrl_pos}
N -1740 -5220 -1740 -5200 {
lab=#net16}
N -1740 -5140 -1740 -5130 {
lab=#net17}
N -1800 -4660 -1800 -4650 {
lab=GND}
N -1800 -4770 -1800 -4760 {
lab=vdd_syn0}
N -1740 -4580 -1730 -4580 {
lab=GND}
N -1740 -4550 -1740 -4540 {
lab=p0}
N -1860 -4730 -1860 -4720 {
lab=vpres7}
N -1740 -4730 -1740 -4720 {
lab=vpos7}
N -1790 -4580 -1780 -4580 {
lab=ctrl_pos}
N -1740 -4700 -1740 -4680 {
lab=#net18}
N -1740 -4620 -1740 -4610 {
lab=#net19}
N -1800 -4140 -1800 -4130 {
lab=GND}
N -1800 -4250 -1800 -4240 {
lab=vdd_syn0}
N -1740 -4060 -1730 -4060 {
lab=GND}
N -1740 -4030 -1740 -4020 {
lab=p0}
N -1860 -4210 -1860 -4200 {
lab=vpres8}
N -1740 -4210 -1740 -4200 {
lab=vpos8}
N -1790 -4060 -1780 -4060 {
lab=ctrl_pos}
N -1740 -4180 -1740 -4160 {
lab=#net20}
N -1740 -4100 -1740 -4090 {
lab=#net21}
N -1800 -3620 -1800 -3610 {
lab=GND}
N -1800 -3730 -1800 -3720 {
lab=vdd_syn0}
N -1740 -3540 -1730 -3540 {
lab=GND}
N -1740 -3510 -1740 -3500 {
lab=p0}
N -1860 -3690 -1860 -3680 {
lab=vpres9}
N -1740 -3690 -1740 -3680 {
lab=vpos9}
N -1790 -3540 -1780 -3540 {
lab=ctrl_pos}
N -1740 -3660 -1740 -3640 {
lab=#net22}
N -1740 -3580 -1740 -3570 {
lab=#net23}
N -2310 -6210 -2310 -6190 {
lab=GND}
N -2310 -6370 -2310 -6350 {
lab=vdd_pre}
N -2690 -6200 -2690 -6180 {
lab=GND}
N -2490 -6300 -2490 -6280 {
lab=vc4}
N -2490 -6330 -2480 -6330 {
lab=vdd_in}
N -2480 -6360 -2480 -6330 {
lab=vdd_in}
N -2490 -6360 -2480 -6360 {
lab=vdd_in}
N -2570 -6330 -2530 -6330 {
lab=#net24}
N -2610 -6360 -2490 -6360 {
lab=vdd_in}
N -2620 -6330 -2610 -6330 {
lab=vdd_in}
N -2620 -6360 -2620 -6330 {
lab=vdd_in}
N -2620 -6360 -2610 -6360 {
lab=vdd_in}
N -2610 -6300 -2610 -6280 {
lab=#net24}
N -2610 -6280 -2550 -6280 {
lab=#net24}
N -2550 -6330 -2550 -6280 {
lab=#net24}
N -2690 -6280 -2690 -6260 {
lab=#net25}
N -2170 -6280 -2160 -6280 {
lab=vpre4}
N -2630 -6280 -2610 -6280 {
lab=#net24}
N -2310 -6730 -2310 -6710 {
lab=GND}
N -2310 -6890 -2310 -6870 {
lab=vdd_pre}
N -2690 -6720 -2690 -6700 {
lab=GND}
N -2490 -6820 -2490 -6800 {
lab=vc3}
N -2490 -6850 -2480 -6850 {
lab=vdd_in}
N -2480 -6880 -2480 -6850 {
lab=vdd_in}
N -2490 -6880 -2480 -6880 {
lab=vdd_in}
N -2570 -6850 -2530 -6850 {
lab=#net26}
N -2610 -6880 -2490 -6880 {
lab=vdd_in}
N -2620 -6850 -2610 -6850 {
lab=vdd_in}
N -2620 -6880 -2620 -6850 {
lab=vdd_in}
N -2620 -6880 -2610 -6880 {
lab=vdd_in}
N -2610 -6820 -2610 -6800 {
lab=#net26}
N -2610 -6800 -2550 -6800 {
lab=#net26}
N -2550 -6850 -2550 -6800 {
lab=#net26}
N -2690 -6800 -2690 -6780 {
lab=#net27}
N -2170 -6800 -2160 -6800 {
lab=vpre3}
N -2630 -6800 -2610 -6800 {
lab=#net26}
N -2490 -6800 -2410 -6800 {
lab=vc3}
N -2410 -6840 -2400 -6840 {
lab=vlky}
N -2410 -6760 -2400 -6760 {
lab=vb_pre}
N -2410 -6320 -2400 -6320 {
lab=vlky}
N -2490 -6280 -2410 -6280 {
lab=vc4}
N -2410 -6240 -2400 -6240 {
lab=vb_pre}
N -2310 -5170 -2310 -5150 {
lab=GND}
N -2310 -5330 -2310 -5310 {
lab=vdd_pre}
N -2690 -5160 -2690 -5140 {
lab=GND}
N -2490 -5260 -2490 -5240 {
lab=vc6}
N -2490 -5290 -2480 -5290 {
lab=vdd_in}
N -2480 -5320 -2480 -5290 {
lab=vdd_in}
N -2490 -5320 -2480 -5320 {
lab=vdd_in}
N -2570 -5290 -2530 -5290 {
lab=#net28}
N -2610 -5320 -2490 -5320 {
lab=vdd_in}
N -2620 -5290 -2610 -5290 {
lab=vdd_in}
N -2620 -5320 -2620 -5290 {
lab=vdd_in}
N -2620 -5320 -2610 -5320 {
lab=vdd_in}
N -2610 -5260 -2610 -5240 {
lab=#net28}
N -2610 -5240 -2550 -5240 {
lab=#net28}
N -2550 -5290 -2550 -5240 {
lab=#net28}
N -2690 -5240 -2690 -5220 {
lab=#net29}
N -2170 -5240 -2160 -5240 {
lab=vpre6}
N -2630 -5240 -2610 -5240 {
lab=#net28}
N -2310 -5690 -2310 -5670 {
lab=GND}
N -2310 -5850 -2310 -5830 {
lab=vdd_pre}
N -2690 -5680 -2690 -5660 {
lab=GND}
N -2490 -5780 -2490 -5760 {
lab=vc5}
N -2490 -5810 -2480 -5810 {
lab=vdd_in}
N -2480 -5840 -2480 -5810 {
lab=vdd_in}
N -2490 -5840 -2480 -5840 {
lab=vdd_in}
N -2570 -5810 -2530 -5810 {
lab=#net30}
N -2610 -5840 -2490 -5840 {
lab=vdd_in}
N -2620 -5810 -2610 -5810 {
lab=vdd_in}
N -2620 -5840 -2620 -5810 {
lab=vdd_in}
N -2620 -5840 -2610 -5840 {
lab=vdd_in}
N -2610 -5780 -2610 -5760 {
lab=#net30}
N -2610 -5760 -2550 -5760 {
lab=#net30}
N -2550 -5810 -2550 -5760 {
lab=#net30}
N -2690 -5760 -2690 -5740 {
lab=#net31}
N -2170 -5760 -2160 -5760 {
lab=vpre5}
N -2630 -5760 -2610 -5760 {
lab=#net30}
N -2490 -5760 -2410 -5760 {
lab=vc5}
N -2410 -5800 -2400 -5800 {
lab=vlky}
N -2410 -5720 -2400 -5720 {
lab=vb_pre}
N -2410 -5280 -2400 -5280 {
lab=vlky}
N -2490 -5240 -2410 -5240 {
lab=vc6}
N -2410 -5200 -2400 -5200 {
lab=vb_pre}
N -2310 -4130 -2310 -4110 {
lab=GND}
N -2310 -4290 -2310 -4270 {
lab=vdd_pre}
N -2690 -4120 -2690 -4100 {
lab=GND}
N -2490 -4220 -2490 -4200 {
lab=vc8}
N -2490 -4250 -2480 -4250 {
lab=vdd_in}
N -2480 -4280 -2480 -4250 {
lab=vdd_in}
N -2490 -4280 -2480 -4280 {
lab=vdd_in}
N -2570 -4250 -2530 -4250 {
lab=#net32}
N -2610 -4280 -2490 -4280 {
lab=vdd_in}
N -2620 -4250 -2610 -4250 {
lab=vdd_in}
N -2620 -4280 -2620 -4250 {
lab=vdd_in}
N -2620 -4280 -2610 -4280 {
lab=vdd_in}
N -2610 -4220 -2610 -4200 {
lab=#net32}
N -2610 -4200 -2550 -4200 {
lab=#net32}
N -2550 -4250 -2550 -4200 {
lab=#net32}
N -2690 -4200 -2690 -4180 {
lab=#net33}
N -2170 -4200 -2160 -4200 {
lab=vpre8}
N -2630 -4200 -2610 -4200 {
lab=#net32}
N -2310 -4650 -2310 -4630 {
lab=GND}
N -2310 -4810 -2310 -4790 {
lab=vdd_pre}
N -2690 -4640 -2690 -4620 {
lab=GND}
N -2490 -4740 -2490 -4720 {
lab=vc7}
N -2490 -4770 -2480 -4770 {
lab=vdd_in}
N -2480 -4800 -2480 -4770 {
lab=vdd_in}
N -2490 -4800 -2480 -4800 {
lab=vdd_in}
N -2570 -4770 -2530 -4770 {
lab=#net34}
N -2610 -4800 -2490 -4800 {
lab=vdd_in}
N -2620 -4770 -2610 -4770 {
lab=vdd_in}
N -2620 -4800 -2620 -4770 {
lab=vdd_in}
N -2620 -4800 -2610 -4800 {
lab=vdd_in}
N -2610 -4740 -2610 -4720 {
lab=#net34}
N -2610 -4720 -2550 -4720 {
lab=#net34}
N -2550 -4770 -2550 -4720 {
lab=#net34}
N -2690 -4720 -2690 -4700 {
lab=#net35}
N -2170 -4720 -2160 -4720 {
lab=vpre7}
N -2630 -4720 -2610 -4720 {
lab=#net34}
N -2490 -4720 -2410 -4720 {
lab=vc7}
N -2410 -4760 -2400 -4760 {
lab=vlky}
N -2410 -4680 -2400 -4680 {
lab=vb_pre}
N -2410 -4240 -2400 -4240 {
lab=vlky}
N -2490 -4200 -2410 -4200 {
lab=vc8}
N -2410 -4160 -2400 -4160 {
lab=vb_pre}
N -2310 -3610 -2310 -3590 {
lab=GND}
N -2310 -3770 -2310 -3750 {
lab=vdd_pre}
N -2690 -3600 -2690 -3580 {
lab=GND}
N -2490 -3700 -2490 -3680 {
lab=vc9}
N -2490 -3730 -2480 -3730 {
lab=vdd_in}
N -2480 -3760 -2480 -3730 {
lab=vdd_in}
N -2490 -3760 -2480 -3760 {
lab=vdd_in}
N -2570 -3730 -2530 -3730 {
lab=#net36}
N -2610 -3760 -2490 -3760 {
lab=vdd_in}
N -2620 -3730 -2610 -3730 {
lab=vdd_in}
N -2620 -3760 -2620 -3730 {
lab=vdd_in}
N -2620 -3760 -2610 -3760 {
lab=vdd_in}
N -2610 -3700 -2610 -3680 {
lab=#net36}
N -2610 -3680 -2550 -3680 {
lab=#net36}
N -2550 -3730 -2550 -3680 {
lab=#net36}
N -2690 -3680 -2690 -3660 {
lab=#net37}
N -2170 -3680 -2160 -3680 {
lab=vpre9}
N -2630 -3680 -2610 -3680 {
lab=#net36}
N -2410 -3720 -2400 -3720 {
lab=vlky}
N -2490 -3680 -2410 -3680 {
lab=vc9}
N -2410 -3640 -2400 -3640 {
lab=vb_pre}
N -1020 -1770 -1010 -1770 {
lab=8}
N -1800 -3100 -1800 -3090 {
lab=GND}
N -1800 -3210 -1800 -3200 {
lab=vdd_syn0}
N -1740 -3020 -1730 -3020 {
lab=GND}
N -1740 -2990 -1740 -2980 {
lab=p0}
N -1860 -3170 -1860 -3160 {
lab=vpres10}
N -1740 -3170 -1740 -3160 {
lab=vpos10}
N -1790 -3020 -1780 -3020 {
lab=ctrl_pos}
N -1740 -3140 -1740 -3120 {
lab=#net38}
N -1740 -3060 -1740 -3050 {
lab=#net39}
N -1800 -2580 -1800 -2570 {
lab=GND}
N -1800 -2690 -1800 -2680 {
lab=vdd_syn0}
N -1740 -2500 -1730 -2500 {
lab=GND}
N -1740 -2470 -1740 -2460 {
lab=p0}
N -1860 -2650 -1860 -2640 {
lab=vpres11}
N -1740 -2650 -1740 -2640 {
lab=vpos11}
N -1790 -2500 -1780 -2500 {
lab=ctrl_pos}
N -1740 -2620 -1740 -2600 {
lab=#net40}
N -1740 -2540 -1740 -2530 {
lab=#net41}
N -1800 -2060 -1800 -2050 {
lab=GND}
N -1800 -2170 -1800 -2160 {
lab=vdd_syn0}
N -1740 -1980 -1730 -1980 {
lab=GND}
N -1740 -1950 -1740 -1940 {
lab=p0}
N -1860 -2130 -1860 -2120 {
lab=vpres12}
N -1740 -2130 -1740 -2120 {
lab=vpos12}
N -1790 -1980 -1780 -1980 {
lab=ctrl_pos}
N -1740 -2100 -1740 -2080 {
lab=#net42}
N -1740 -2020 -1740 -2010 {
lab=#net43}
N -1800 -1540 -1800 -1530 {
lab=GND}
N -1800 -1650 -1800 -1640 {
lab=vdd_syn0}
N -1740 -1460 -1730 -1460 {
lab=GND}
N -1740 -1430 -1740 -1420 {
lab=p0}
N -1860 -1610 -1860 -1600 {
lab=vpres13}
N -1740 -1610 -1740 -1600 {
lab=vpos13}
N -1790 -1460 -1780 -1460 {
lab=ctrl_pos}
N -1740 -1580 -1740 -1560 {
lab=#net44}
N -1740 -1500 -1740 -1490 {
lab=#net45}
N -1800 -1020 -1800 -1010 {
lab=GND}
N -1800 -1130 -1800 -1120 {
lab=vdd_syn0}
N -1740 -940 -1730 -940 {
lab=GND}
N -1740 -910 -1740 -900 {
lab=p0}
N -1860 -1090 -1860 -1080 {
lab=vpres14}
N -1740 -1090 -1740 -1080 {
lab=vpos14}
N -1790 -940 -1780 -940 {
lab=ctrl_pos}
N -1740 -1060 -1740 -1040 {
lab=#net46}
N -1740 -980 -1740 -970 {
lab=#net47}
N -1800 -500 -1800 -490 {
lab=GND}
N -1800 -610 -1800 -600 {
lab=vdd_syn0}
N -1740 -420 -1730 -420 {
lab=GND}
N -1740 -390 -1740 -380 {
lab=p0}
N -1860 -570 -1860 -560 {
lab=vpres15}
N -1740 -570 -1740 -560 {
lab=vpos15}
N -1790 -420 -1780 -420 {
lab=ctrl_pos}
N -1740 -540 -1740 -520 {
lab=#net48}
N -1740 -460 -1740 -450 {
lab=#net49}
N -2310 -3090 -2310 -3070 {
lab=GND}
N -2310 -3250 -2310 -3230 {
lab=vdd_pre}
N -2690 -3080 -2690 -3060 {
lab=GND}
N -2490 -3180 -2490 -3160 {
lab=vc10}
N -2490 -3210 -2480 -3210 {
lab=vdd_in}
N -2480 -3240 -2480 -3210 {
lab=vdd_in}
N -2490 -3240 -2480 -3240 {
lab=vdd_in}
N -2570 -3210 -2530 -3210 {
lab=#net50}
N -2610 -3240 -2490 -3240 {
lab=vdd_in}
N -2620 -3210 -2610 -3210 {
lab=vdd_in}
N -2620 -3240 -2620 -3210 {
lab=vdd_in}
N -2620 -3240 -2610 -3240 {
lab=vdd_in}
N -2610 -3180 -2610 -3160 {
lab=#net50}
N -2610 -3160 -2550 -3160 {
lab=#net50}
N -2550 -3210 -2550 -3160 {
lab=#net50}
N -2690 -3160 -2690 -3140 {
lab=#net51}
N -2170 -3160 -2160 -3160 {
lab=vpre10}
N -2630 -3160 -2610 -3160 {
lab=#net50}
N -2410 -3200 -2400 -3200 {
lab=vlky}
N -2490 -3160 -2410 -3160 {
lab=vc10}
N -2410 -3120 -2400 -3120 {
lab=vb_pre}
N -2310 -2050 -2310 -2030 {
lab=GND}
N -2310 -2210 -2310 -2190 {
lab=vdd_pre}
N -2690 -2040 -2690 -2020 {
lab=GND}
N -2490 -2140 -2490 -2120 {
lab=vc12}
N -2490 -2170 -2480 -2170 {
lab=vdd_in}
N -2480 -2200 -2480 -2170 {
lab=vdd_in}
N -2490 -2200 -2480 -2200 {
lab=vdd_in}
N -2570 -2170 -2530 -2170 {
lab=#net52}
N -2610 -2200 -2490 -2200 {
lab=vdd_in}
N -2620 -2170 -2610 -2170 {
lab=vdd_in}
N -2620 -2200 -2620 -2170 {
lab=vdd_in}
N -2620 -2200 -2610 -2200 {
lab=vdd_in}
N -2610 -2140 -2610 -2120 {
lab=#net52}
N -2610 -2120 -2550 -2120 {
lab=#net52}
N -2550 -2170 -2550 -2120 {
lab=#net52}
N -2690 -2120 -2690 -2100 {
lab=#net53}
N -2170 -2120 -2160 -2120 {
lab=vpre12}
N -2630 -2120 -2610 -2120 {
lab=#net52}
N -2310 -2570 -2310 -2550 {
lab=GND}
N -2310 -2730 -2310 -2710 {
lab=vdd_pre}
N -2690 -2560 -2690 -2540 {
lab=GND}
N -2490 -2660 -2490 -2640 {
lab=vc11}
N -2490 -2690 -2480 -2690 {
lab=vdd_in}
N -2480 -2720 -2480 -2690 {
lab=vdd_in}
N -2490 -2720 -2480 -2720 {
lab=vdd_in}
N -2570 -2690 -2530 -2690 {
lab=#net54}
N -2610 -2720 -2490 -2720 {
lab=vdd_in}
N -2620 -2690 -2610 -2690 {
lab=vdd_in}
N -2620 -2720 -2620 -2690 {
lab=vdd_in}
N -2620 -2720 -2610 -2720 {
lab=vdd_in}
N -2610 -2660 -2610 -2640 {
lab=#net54}
N -2610 -2640 -2550 -2640 {
lab=#net54}
N -2550 -2690 -2550 -2640 {
lab=#net54}
N -2690 -2640 -2690 -2620 {
lab=#net55}
N -2170 -2640 -2160 -2640 {
lab=vpre11}
N -2630 -2640 -2610 -2640 {
lab=#net54}
N -2490 -2640 -2410 -2640 {
lab=vc11}
N -2410 -2680 -2400 -2680 {
lab=vlky}
N -2410 -2600 -2400 -2600 {
lab=vb_pre}
N -2410 -2160 -2400 -2160 {
lab=vlky}
N -2490 -2120 -2410 -2120 {
lab=vc12}
N -2410 -2080 -2400 -2080 {
lab=vb_pre}
N -2310 -1010 -2310 -990 {
lab=GND}
N -2310 -1170 -2310 -1150 {
lab=vdd_pre}
N -2690 -1000 -2690 -980 {
lab=GND}
N -2490 -1100 -2490 -1080 {
lab=vc14}
N -2490 -1130 -2480 -1130 {
lab=vdd_in}
N -2480 -1160 -2480 -1130 {
lab=vdd_in}
N -2490 -1160 -2480 -1160 {
lab=vdd_in}
N -2570 -1130 -2530 -1130 {
lab=#net56}
N -2610 -1160 -2490 -1160 {
lab=vdd_in}
N -2620 -1130 -2610 -1130 {
lab=vdd_in}
N -2620 -1160 -2620 -1130 {
lab=vdd_in}
N -2620 -1160 -2610 -1160 {
lab=vdd_in}
N -2610 -1100 -2610 -1080 {
lab=#net56}
N -2610 -1080 -2550 -1080 {
lab=#net56}
N -2550 -1130 -2550 -1080 {
lab=#net56}
N -2690 -1080 -2690 -1060 {
lab=#net57}
N -2170 -1080 -2160 -1080 {
lab=vpre14}
N -2630 -1080 -2610 -1080 {
lab=#net56}
N -2310 -1530 -2310 -1510 {
lab=GND}
N -2310 -1690 -2310 -1670 {
lab=vdd_pre}
N -2690 -1520 -2690 -1500 {
lab=GND}
N -2490 -1620 -2490 -1600 {
lab=vc13}
N -2490 -1650 -2480 -1650 {
lab=vdd_in}
N -2480 -1680 -2480 -1650 {
lab=vdd_in}
N -2490 -1680 -2480 -1680 {
lab=vdd_in}
N -2570 -1650 -2530 -1650 {
lab=#net58}
N -2610 -1680 -2490 -1680 {
lab=vdd_in}
N -2620 -1650 -2610 -1650 {
lab=vdd_in}
N -2620 -1680 -2620 -1650 {
lab=vdd_in}
N -2620 -1680 -2610 -1680 {
lab=vdd_in}
N -2610 -1620 -2610 -1600 {
lab=#net58}
N -2610 -1600 -2550 -1600 {
lab=#net58}
N -2550 -1650 -2550 -1600 {
lab=#net58}
N -2690 -1600 -2690 -1580 {
lab=#net59}
N -2170 -1600 -2160 -1600 {
lab=vpre13}
N -2630 -1600 -2610 -1600 {
lab=#net58}
N -2490 -1600 -2410 -1600 {
lab=vc13}
N -2410 -1640 -2400 -1640 {
lab=vlky}
N -2410 -1560 -2400 -1560 {
lab=vb_pre}
N -2410 -1120 -2400 -1120 {
lab=vlky}
N -2490 -1080 -2410 -1080 {
lab=vc14}
N -2410 -1040 -2400 -1040 {
lab=vb_pre}
N -2310 -490 -2310 -470 {
lab=GND}
N -2310 -650 -2310 -630 {
lab=vdd_pre}
N -2690 -480 -2690 -460 {
lab=GND}
N -2490 -580 -2490 -560 {
lab=vc15}
N -2490 -610 -2480 -610 {
lab=vdd_in}
N -2480 -640 -2480 -610 {
lab=vdd_in}
N -2490 -640 -2480 -640 {
lab=vdd_in}
N -2570 -610 -2530 -610 {
lab=#net60}
N -2610 -640 -2490 -640 {
lab=vdd_in}
N -2620 -610 -2610 -610 {
lab=vdd_in}
N -2620 -640 -2620 -610 {
lab=vdd_in}
N -2620 -640 -2610 -640 {
lab=vdd_in}
N -2610 -580 -2610 -560 {
lab=#net60}
N -2610 -560 -2550 -560 {
lab=#net60}
N -2550 -610 -2550 -560 {
lab=#net60}
N -2690 -560 -2690 -540 {
lab=#net61}
N -2170 -560 -2160 -560 {
lab=vpre15}
N -2630 -560 -2610 -560 {
lab=#net60}
N -2410 -600 -2400 -600 {
lab=vlky}
N -2490 -560 -2410 -560 {
lab=vc15}
N -2410 -520 -2400 -520 {
lab=vb_pre}
N -1020 -1810 -1020 -1800 {
lab=GND}
N -1020 -1810 -1010 -1810 {
lab=GND}
N -2050 -8020 -2040 -8020 {
lab=ctrl_stdp}
N -2050 -7870 -2040 -7870 {
lab=ctrl_inf}
N -1990 -7750 -1990 -7730 {
lab=vdd_wu}
N -1990 -7900 -1990 -7880 {
lab=vdd_inf}
N -1990 -8050 -1990 -8030 {
lab=vdd_stdp}
N -2050 -7720 -2040 -7720 {
lab=ctrl_wu}
N -2040 -7720 -2040 -7690 {
lab=ctrl_wu}
N -1320 -2240 -1320 -2220 {
lab=GND}
N -1320 -2320 -1320 -2300 {
lab=ctrl_pos}
N -1990 -7430 -1990 -7420 {
lab=GND}
N -1990 -7130 -1990 -7120 {
lab=GND}
N -1940 -7180 -1940 -7170 {
lab=vpres2}
N -1990 -7280 -1990 -7270 {
lab=GND}
N -2040 -7320 -2040 -7310 {
lab=vpre2}
N -2040 -7470 -2040 -7460 {
lab=vpre2}
N -1940 -7470 -1940 -7460 {
lab=vpos2}
N -1940 -7330 -1940 -7320 {
lab=vpres2}
N -2050 -7140 -2040 -7140 {
lab=vbias}
N -2050 -7500 -2040 -7500 {
lab=ctrl_stdp}
N -2050 -7350 -2040 -7350 {
lab=ctrl_inf}
N -1990 -7230 -1990 -7210 {
lab=vdd_wu}
N -1990 -7380 -1990 -7360 {
lab=vdd_inf}
N -1990 -7530 -1990 -7510 {
lab=vdd_stdp}
N -2050 -7200 -2040 -7200 {
lab=ctrl_wu}
N -2040 -7200 -2040 -7170 {
lab=ctrl_wu}
N -1990 -6910 -1990 -6900 {
lab=GND}
N -1990 -6610 -1990 -6600 {
lab=GND}
N -1940 -6660 -1940 -6650 {
lab=vpres3}
N -1990 -6760 -1990 -6750 {
lab=GND}
N -2040 -6800 -2040 -6790 {
lab=vpre3}
N -2040 -6950 -2040 -6940 {
lab=vpre3}
N -1940 -6950 -1940 -6940 {
lab=vpos3}
N -1940 -6810 -1940 -6800 {
lab=vpres3}
N -2050 -6620 -2040 -6620 {
lab=vbias}
N -2050 -6980 -2040 -6980 {
lab=ctrl_stdp}
N -2050 -6830 -2040 -6830 {
lab=ctrl_inf}
N -1990 -6710 -1990 -6690 {
lab=vdd_wu}
N -1990 -6860 -1990 -6840 {
lab=vdd_inf}
N -1990 -7010 -1990 -6990 {
lab=vdd_stdp}
N -2050 -6680 -2040 -6680 {
lab=ctrl_wu}
N -2040 -6680 -2040 -6650 {
lab=ctrl_wu}
N -1990 -6390 -1990 -6380 {
lab=GND}
N -1990 -6090 -1990 -6080 {
lab=GND}
N -1940 -6140 -1940 -6130 {
lab=vpres4}
N -1990 -6240 -1990 -6230 {
lab=GND}
N -2040 -6280 -2040 -6270 {
lab=vpre4}
N -2040 -6430 -2040 -6420 {
lab=vpre4}
N -1940 -6430 -1940 -6420 {
lab=vpos4}
N -1940 -6290 -1940 -6280 {
lab=vpres4}
N -2050 -6100 -2040 -6100 {
lab=vbias}
N -2050 -6460 -2040 -6460 {
lab=ctrl_stdp}
N -2050 -6310 -2040 -6310 {
lab=ctrl_inf}
N -1990 -6190 -1990 -6170 {
lab=vdd_wu}
N -1990 -6340 -1990 -6320 {
lab=vdd_inf}
N -1990 -6490 -1990 -6470 {
lab=vdd_stdp}
N -2050 -6160 -2040 -6160 {
lab=ctrl_wu}
N -2040 -6160 -2040 -6130 {
lab=ctrl_wu}
N -1990 -5870 -1990 -5860 {
lab=GND}
N -1990 -5570 -1990 -5560 {
lab=GND}
N -1940 -5620 -1940 -5610 {
lab=vpres5}
N -1990 -5720 -1990 -5710 {
lab=GND}
N -2040 -5760 -2040 -5750 {
lab=vpre5}
N -2040 -5910 -2040 -5900 {
lab=vpre5}
N -1940 -5910 -1940 -5900 {
lab=vpos5}
N -1940 -5770 -1940 -5760 {
lab=vpres5}
N -2050 -5580 -2040 -5580 {
lab=vbias}
N -2050 -5940 -2040 -5940 {
lab=ctrl_stdp}
N -2050 -5790 -2040 -5790 {
lab=ctrl_inf}
N -1990 -5670 -1990 -5650 {
lab=vdd_wu}
N -1990 -5820 -1990 -5800 {
lab=vdd_inf}
N -1990 -5970 -1990 -5950 {
lab=vdd_stdp}
N -2050 -5640 -2040 -5640 {
lab=ctrl_wu}
N -2040 -5640 -2040 -5610 {
lab=ctrl_wu}
N -1990 -5350 -1990 -5340 {
lab=GND}
N -1990 -5050 -1990 -5040 {
lab=GND}
N -1940 -5100 -1940 -5090 {
lab=vpres6}
N -1990 -5200 -1990 -5190 {
lab=GND}
N -2040 -5240 -2040 -5230 {
lab=vpre6}
N -2040 -5390 -2040 -5380 {
lab=vpre6}
N -1940 -5390 -1940 -5380 {
lab=vpos6}
N -1940 -5250 -1940 -5240 {
lab=vpres6}
N -2050 -5060 -2040 -5060 {
lab=vbias}
N -2050 -5420 -2040 -5420 {
lab=ctrl_stdp}
N -2050 -5270 -2040 -5270 {
lab=ctrl_inf}
N -1990 -5150 -1990 -5130 {
lab=vdd_wu}
N -1990 -5300 -1990 -5280 {
lab=vdd_inf}
N -1990 -5450 -1990 -5430 {
lab=vdd_stdp}
N -2050 -5120 -2040 -5120 {
lab=ctrl_wu}
N -2040 -5120 -2040 -5090 {
lab=ctrl_wu}
N -1990 -4830 -1990 -4820 {
lab=GND}
N -1990 -4530 -1990 -4520 {
lab=GND}
N -1940 -4580 -1940 -4570 {
lab=vpres7}
N -1990 -4680 -1990 -4670 {
lab=GND}
N -2040 -4720 -2040 -4710 {
lab=vpre7}
N -2040 -4870 -2040 -4860 {
lab=vpre7}
N -1940 -4870 -1940 -4860 {
lab=vpos7}
N -1940 -4730 -1940 -4720 {
lab=vpres7}
N -2050 -4540 -2040 -4540 {
lab=vbias}
N -2050 -4900 -2040 -4900 {
lab=ctrl_stdp}
N -2050 -4750 -2040 -4750 {
lab=ctrl_inf}
N -1990 -4630 -1990 -4610 {
lab=vdd_wu}
N -1990 -4780 -1990 -4760 {
lab=vdd_inf}
N -1990 -4930 -1990 -4910 {
lab=vdd_stdp}
N -2050 -4600 -2040 -4600 {
lab=ctrl_wu}
N -2040 -4600 -2040 -4570 {
lab=ctrl_wu}
N -1990 -4310 -1990 -4300 {
lab=GND}
N -1990 -4010 -1990 -4000 {
lab=GND}
N -1940 -4060 -1940 -4050 {
lab=vpres8}
N -1990 -4160 -1990 -4150 {
lab=GND}
N -2040 -4200 -2040 -4190 {
lab=vpre8}
N -2040 -4350 -2040 -4340 {
lab=vpre8}
N -1940 -4350 -1940 -4340 {
lab=vpos8}
N -1940 -4210 -1940 -4200 {
lab=vpres8}
N -2050 -4020 -2040 -4020 {
lab=vbias}
N -2050 -4380 -2040 -4380 {
lab=ctrl_stdp}
N -2050 -4230 -2040 -4230 {
lab=ctrl_inf}
N -1990 -4110 -1990 -4090 {
lab=vdd_wu}
N -1990 -4260 -1990 -4240 {
lab=vdd_inf}
N -1990 -4410 -1990 -4390 {
lab=vdd_stdp}
N -2050 -4080 -2040 -4080 {
lab=ctrl_wu}
N -2040 -4080 -2040 -4050 {
lab=ctrl_wu}
N -1990 -3790 -1990 -3780 {
lab=GND}
N -1990 -3490 -1990 -3480 {
lab=GND}
N -1940 -3540 -1940 -3530 {
lab=vpres9}
N -1990 -3640 -1990 -3630 {
lab=GND}
N -2040 -3680 -2040 -3670 {
lab=vpre9}
N -2040 -3830 -2040 -3820 {
lab=vpre9}
N -1940 -3830 -1940 -3820 {
lab=vpos9}
N -1940 -3690 -1940 -3680 {
lab=vpres9}
N -2050 -3500 -2040 -3500 {
lab=vbias}
N -2050 -3860 -2040 -3860 {
lab=ctrl_stdp}
N -2050 -3710 -2040 -3710 {
lab=ctrl_inf}
N -1990 -3590 -1990 -3570 {
lab=vdd_wu}
N -1990 -3740 -1990 -3720 {
lab=vdd_inf}
N -1990 -3890 -1990 -3870 {
lab=vdd_stdp}
N -2050 -3560 -2040 -3560 {
lab=ctrl_wu}
N -2040 -3560 -2040 -3530 {
lab=ctrl_wu}
N -1990 -3270 -1990 -3260 {
lab=GND}
N -1990 -2970 -1990 -2960 {
lab=GND}
N -1940 -3020 -1940 -3010 {
lab=vpres10}
N -1990 -3120 -1990 -3110 {
lab=GND}
N -2040 -3160 -2040 -3150 {
lab=vpre10}
N -2040 -3310 -2040 -3300 {
lab=vpre10}
N -1940 -3310 -1940 -3300 {
lab=vpos10}
N -1940 -3170 -1940 -3160 {
lab=vpres10}
N -2050 -2980 -2040 -2980 {
lab=vbias}
N -2050 -3340 -2040 -3340 {
lab=ctrl_stdp}
N -2050 -3190 -2040 -3190 {
lab=ctrl_inf}
N -1990 -3070 -1990 -3050 {
lab=vdd_wu}
N -1990 -3220 -1990 -3200 {
lab=vdd_inf}
N -1990 -3370 -1990 -3350 {
lab=vdd_stdp}
N -2050 -3040 -2040 -3040 {
lab=ctrl_wu}
N -2040 -3040 -2040 -3010 {
lab=ctrl_wu}
N -1990 -2750 -1990 -2740 {
lab=GND}
N -1990 -2450 -1990 -2440 {
lab=GND}
N -1940 -2500 -1940 -2490 {
lab=vpres11}
N -1990 -2600 -1990 -2590 {
lab=GND}
N -2040 -2640 -2040 -2630 {
lab=vpre11}
N -2040 -2790 -2040 -2780 {
lab=vpre11}
N -1940 -2790 -1940 -2780 {
lab=vpos11}
N -1940 -2650 -1940 -2640 {
lab=vpres11}
N -2050 -2460 -2040 -2460 {
lab=vbias}
N -2050 -2820 -2040 -2820 {
lab=ctrl_stdp}
N -2050 -2670 -2040 -2670 {
lab=ctrl_inf}
N -1990 -2550 -1990 -2530 {
lab=vdd_wu}
N -1990 -2700 -1990 -2680 {
lab=vdd_inf}
N -1990 -2850 -1990 -2830 {
lab=vdd_stdp}
N -2050 -2520 -2040 -2520 {
lab=ctrl_wu}
N -2040 -2520 -2040 -2490 {
lab=ctrl_wu}
N -1990 -2230 -1990 -2220 {
lab=GND}
N -1990 -1930 -1990 -1920 {
lab=GND}
N -1940 -1980 -1940 -1970 {
lab=vpres12}
N -1990 -2080 -1990 -2070 {
lab=GND}
N -2040 -2120 -2040 -2110 {
lab=vpre12}
N -2040 -2270 -2040 -2260 {
lab=vpre12}
N -1940 -2270 -1940 -2260 {
lab=vpos12}
N -1940 -2130 -1940 -2120 {
lab=vpres12}
N -2050 -1940 -2040 -1940 {
lab=vbias}
N -2050 -2300 -2040 -2300 {
lab=ctrl_stdp}
N -2050 -2150 -2040 -2150 {
lab=ctrl_inf}
N -1990 -2030 -1990 -2010 {
lab=vdd_wu}
N -1990 -2180 -1990 -2160 {
lab=vdd_inf}
N -1990 -2330 -1990 -2310 {
lab=vdd_stdp}
N -2050 -2000 -2040 -2000 {
lab=ctrl_wu}
N -2040 -2000 -2040 -1970 {
lab=ctrl_wu}
N -1990 -1710 -1990 -1700 {
lab=GND}
N -1990 -1410 -1990 -1400 {
lab=GND}
N -1940 -1460 -1940 -1450 {
lab=vpres13}
N -1990 -1560 -1990 -1550 {
lab=GND}
N -2040 -1600 -2040 -1590 {
lab=vpre13}
N -2040 -1750 -2040 -1740 {
lab=vpre13}
N -1940 -1750 -1940 -1740 {
lab=vpos13}
N -1940 -1610 -1940 -1600 {
lab=vpres13}
N -2050 -1420 -2040 -1420 {
lab=vbias}
N -2050 -1780 -2040 -1780 {
lab=ctrl_stdp}
N -2050 -1630 -2040 -1630 {
lab=ctrl_inf}
N -1990 -1510 -1990 -1490 {
lab=vdd_wu}
N -1990 -1660 -1990 -1640 {
lab=vdd_inf}
N -1990 -1810 -1990 -1790 {
lab=vdd_stdp}
N -2050 -1480 -2040 -1480 {
lab=ctrl_wu}
N -2040 -1480 -2040 -1450 {
lab=ctrl_wu}
N -1990 -1190 -1990 -1180 {
lab=GND}
N -1990 -890 -1990 -880 {
lab=GND}
N -1940 -940 -1940 -930 {
lab=vpres14}
N -1990 -1040 -1990 -1030 {
lab=GND}
N -2040 -1080 -2040 -1070 {
lab=vpre14}
N -2040 -1230 -2040 -1220 {
lab=vpre14}
N -1940 -1230 -1940 -1220 {
lab=vpos14}
N -1940 -1090 -1940 -1080 {
lab=vpres14}
N -2050 -900 -2040 -900 {
lab=vbias}
N -2050 -1260 -2040 -1260 {
lab=ctrl_stdp}
N -2050 -1110 -2040 -1110 {
lab=ctrl_inf}
N -1990 -990 -1990 -970 {
lab=vdd_wu}
N -1990 -1140 -1990 -1120 {
lab=vdd_inf}
N -1990 -1290 -1990 -1270 {
lab=vdd_stdp}
N -2050 -960 -2040 -960 {
lab=ctrl_wu}
N -2040 -960 -2040 -930 {
lab=ctrl_wu}
N -1990 -670 -1990 -660 {
lab=GND}
N -1990 -370 -1990 -360 {
lab=GND}
N -1940 -420 -1940 -410 {
lab=vpres15}
N -1990 -520 -1990 -510 {
lab=GND}
N -2040 -560 -2040 -550 {
lab=vpre15}
N -2040 -710 -2040 -700 {
lab=vpre15}
N -1940 -710 -1940 -700 {
lab=vpos15}
N -1940 -570 -1940 -560 {
lab=vpres15}
N -2050 -380 -2040 -380 {
lab=vbias}
N -2050 -740 -2040 -740 {
lab=ctrl_stdp}
N -2050 -590 -2040 -590 {
lab=ctrl_inf}
N -1990 -470 -1990 -450 {
lab=vdd_wu}
N -1990 -620 -1990 -600 {
lab=vdd_inf}
N -1990 -770 -1990 -750 {
lab=vdd_stdp}
N -2050 -440 -2040 -440 {
lab=ctrl_wu}
N -2040 -440 -2040 -410 {
lab=ctrl_wu}
C {devices/vsource.sym} -1580 -2550 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} -1580 -2500 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} -1500 -2550 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} -1500 -2500 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -1500 -2600 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -2310 -7230 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -2410 -7280 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -7270 0 0 {name=I2 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2690 -7220 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -7370 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -7370 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} -1490 -2020 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -1610 -2020 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} -1360 -2020 0 0 {name=NGSPICE1
only_toplevel=true
value="
.param L_in=0.15
.param W_in=1.5
.param L_out=0.15
.param W_out=1.5
.param L_pre=0.15
.param W_pre=5
.param L_pos=0.15
.param W_pos=5
.param Wp_or=5
.param Lp_or=0.15
.param Wn_or=5
.param Ln_or=0.15
.control
  save all
  tran 1n 140u
  write SNN_15x1_tbv1.raw
.endc
" }
C {devices/launcher.sym} -1520 -1635 0 0 {name=h1
descr="load 1" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tbv1.raw tran"
}
C {devices/lab_pin.sym} -2490 -7320 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/vsource.sym} -1320 -2550 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} -1320 -2500 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} -1320 -2600 2 0 {name=p16 sig_type=std_logic lab=vdd_stdp}
C {devices/gnd.sym} -1800 -7770 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -1860 -7850 1 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1740 -7850 1 0 {name=p27 sig_type=std_logic lab=vpos1}
C {devices/ammeter.sym} -1740 -7770 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7700 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7700 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -1740 -7660 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1780 -250 1 0 {name=p59 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1810 -130 0 0 {name=l63 lab=GND}
C {devices/ammeter.sym} -1740 -290 0 0 {name=Vmeas0 savecurrent=true}
C {devices/lab_pin.sym} -1740 -330 2 0 {name=p60 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1740 0 2 0 {name=p61 sig_type=std_logic lab=8}
C {devices/vsource.sym} -1580 -2130 0 0 {name=V13 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2080 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} -1580 -2180 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} -1400 -2130 0 0 {name=V14 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} -1400 -2080 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} -1400 -2180 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} -1140 -2130 0 0 {name=V15 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1140 -2080 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} -1140 -2180 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -2660 -7320 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} -1580 -2270 0 0 {name=V11 value="PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1580 -2220 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} -1580 -2320 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} -1500 -2270 0 0 {name=V12 value="PWL(0 0 39.9u 0 40u 1.8 119.9u 1.8 120u 0)"}
C {devices/gnd.sym} -1500 -2220 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} -1500 -2320 2 0 {name=p17 sig_type=std_logic lab=ctrl_stdp}
C {devices/vsource.sym} -1420 -2410 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} -1420 -2360 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} -1420 -2460 2 0 {name=p82 sig_type=std_logic lab=vbias}
C {devices/vsource.sym} -1410 -2550 0 0 {name=V3 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1410 -2500 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -1410 -2600 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} -1220 -2550 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} -1220 -2500 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -1220 -2600 2 0 {name=p1 sig_type=std_logic lab=vdd_sw}
C {devices/vsource.sym} -1140 -2550 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} -1140 -2500 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -1140 -2600 2 0 {name=p3 sig_type=std_logic lab=vdd_tg}
C {devices/vsource.sym} -1580 -2410 0 0 {name=V7 value=0.7
*0.55}
C {devices/gnd.sym} -1580 -2360 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} -1580 -2460 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} -1500 -2410 0 0 {name=V8 value=0.5}
C {devices/gnd.sym} -1500 -2360 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1500 -2460 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -2310 -7410 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1670 -130 3 0 {name=p12 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1580 -2600 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2550 -7400 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -7750 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -2410 -7800 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -7790 0 0 {name=I1 value=0}
C {devices/gnd.sym} -2690 -7740 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -7890 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -7890 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -7840 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -1800 -7250 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -1860 -7330 1 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1740 -7330 1 0 {name=p30 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -1990 -7940 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -1940 -7980 3 0 {name=p31 sig_type=std_logic lab=vpos1}
C {devices/lab_pin.sym} -2040 -7980 3 0 {name=p32 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -1740 -7250 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -7180 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -7180 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -1740 -7140 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1940 -7700 1 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2160 -7840 3 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2660 -7840 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -1990 -7640 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -1940 -7850 1 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -2040 -7830 3 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -2050 -7870 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -7790 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -2310 -7930 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1990 -8050 0 0 {name=p45 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -7750 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -7900 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2550 -7920 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1790 -7180 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1790 -7700 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} -1400 -2270 0 0 {name=V16 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1400 -2220 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1400 -2320 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} -1060 -2550 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} -1060 -2500 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} -1060 -2600 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} -940 -1730 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} -940 -1850 0 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/lab_pin.sym} -1810 -250 1 0 {name=p87 sig_type=std_logic lab=inh0}
C {devices/vsource.sym} -1240 -2270 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} -1240 -2220 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -1240 -2320 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} -870 -1790 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -930 -1640 2 0 {name=p94 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} -970 -1620 3 0 {name=M200
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -970 -1650 2 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} -970 -1590 2 0 {name=p72 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} -1010 -1640 0 0 {name=p85 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} -1350 -2410 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} -1350 -2360 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} -1350 -2460 2 0 {name=p95 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -7880 1 0 {name=p96 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -7360 1 0 {name=p97 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1700 -250 1 0 {name=p56 sig_type=std_logic lab=vlky}
C {devices/vsource.sym} -980 -2550 0 0 {name=V10 value="PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -980 -2500 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} -980 -2600 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -2050 -7660 0 0 {name=p100 sig_type=std_logic lab=vbias}
C {devices/gnd.sym} -1800 -6730 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -1740 -6730 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6660 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6660 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -1740 -6620 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6660 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -6210 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -1860 -6290 1 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -1740 -6210 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -6140 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -6140 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -1740 -6100 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -6140 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5690 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -1860 -5770 1 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -1740 -5690 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5620 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5620 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -1740 -5580 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5620 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -5170 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -1740 -5170 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -5100 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -5100 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -1740 -5060 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -5100 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4650 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -1740 -4650 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4580 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4580 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -1740 -4540 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4580 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -4130 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -1740 -4130 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -4060 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -4060 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -1740 -4020 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -4060 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -3610 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -1860 -3690 1 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1740 -3690 1 0 {name=p612 sig_type=std_logic lab=vpos9}
C {devices/ammeter.sym} -1740 -3610 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3540 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3540 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -1740 -3500 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3540 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2310 -6190 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -2410 -6240 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -6230 0 0 {name=I4 value=0}
C {devices/gnd.sym} -2690 -6180 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -6330 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -6330 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -6280 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -2660 -6280 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -2310 -6370 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -6360 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -6710 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -2410 -6760 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -6750 0 0 {name=I3 value=0}
C {devices/gnd.sym} -2690 -6700 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -6850 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -6850 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -6800 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -2660 -6800 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -2310 -6890 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -6880 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -6840 1 0 {name=p671 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -6320 1 0 {name=p672 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -5150 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -2410 -5200 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -5190 0 0 {name=I6 value=0}
C {devices/gnd.sym} -2690 -5140 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -5290 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -5290 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -5240 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -2660 -5240 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -2310 -5330 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -5320 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -5670 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -2410 -5720 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -5710 0 0 {name=I5 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2690 -5660 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -5810 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -5810 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -5760 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -2660 -5760 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -2310 -5850 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -5840 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -5800 1 0 {name=p683 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -5280 1 0 {name=p684 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -4110 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -2410 -4160 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -4150 0 0 {name=I8 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2690 -4100 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -4250 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -4250 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -4200 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -2660 -4200 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -2310 -4290 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -4280 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -4630 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -2410 -4680 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -4670 0 0 {name=I7 value=0}
C {devices/gnd.sym} -2690 -4620 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -4770 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -4770 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -4720 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -2660 -4720 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -2310 -4810 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -4800 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -4760 1 0 {name=p695 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -4240 1 0 {name=p696 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -3590 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -2410 -3640 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -3630 0 0 {name=I9 value=0}
C {devices/gnd.sym} -2690 -3580 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -3730 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -3730 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -3680 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -2660 -3680 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -2310 -3770 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -3760 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -3720 1 0 {name=p702 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -1020 -1770 0 0 {name=p105 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} -2160 -7320 3 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2160 -6800 3 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1860 -6810 1 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2160 -3680 3 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1860 -4210 1 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2160 -4200 3 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1860 -4730 1 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -2160 -4720 3 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1860 -5250 1 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2160 -5240 3 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2160 -5760 3 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2160 -6280 3 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1740 -4210 1 0 {name=p160 sig_type=std_logic lab=vpos8}
C {devices/lab_pin.sym} -1740 -4730 1 0 {name=p165 sig_type=std_logic lab=vpos7}
C {devices/lab_pin.sym} -1740 -5250 1 0 {name=p170 sig_type=std_logic lab=vpos6}
C {devices/lab_pin.sym} -1740 -5770 1 0 {name=p177 sig_type=std_logic lab=vpos5}
C {devices/lab_pin.sym} -1740 -6290 1 0 {name=p180 sig_type=std_logic lab=vpos4}
C {devices/lab_pin.sym} -1740 -6810 1 0 {name=p185 sig_type=std_logic lab=vpos3}
C {devices/launcher.sym} -1510 -1715 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -3680 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -4200 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -4720 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -5240 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -5760 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -6280 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -6800 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -7320 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -7840 0 0 {name=x2010}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1740 -150 1 0 {name=x0}
C {devices/gnd.sym} -1800 -3090 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -1740 -3090 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -3020 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -3020 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1740 -2980 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -3020 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2570 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -1740 -2570 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -2500 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -2500 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -1740 -2460 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -2500 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -2050 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -1740 -2050 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1980 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1980 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -1740 -1940 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1980 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1530 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -1740 -1530 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -1460 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -1460 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -1740 -1420 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -1460 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -1010 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -1740 -1010 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -940 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -940 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -1740 -900 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1790 -940 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1800 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -1740 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1760 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1730 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1740 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1800 -610 1 0 {name=p319 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1790 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -2310 -3070 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -2410 -3120 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -3110 0 0 {name=I10 value=0}
C {devices/gnd.sym} -2690 -3060 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -3210 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -3210 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -3160 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -2660 -3160 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -2310 -3250 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -3240 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -3200 1 0 {name=p328 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -2030 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -2410 -2080 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -2070 0 0 {name=I12 value=0}
C {devices/gnd.sym} -2690 -2020 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -2170 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -2170 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -2120 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -2660 -2120 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -2310 -2210 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -2200 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -2550 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -2410 -2600 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -2590 0 0 {name=I11 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2690 -2540 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -2690 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -2690 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -2640 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -2660 -2640 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -2310 -2730 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -2720 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -2680 1 0 {name=p337 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -2160 1 0 {name=p338 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -990 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -2410 -1040 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -1030 0 0 {name=I14 value="PWL(0 0 39.9u 0 40u 5u 119.9u 5u 120u 0 124.999u 0 125u 5u)"}
C {devices/gnd.sym} -2690 -980 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -1130 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -1130 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -1080 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -2660 -1080 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -2310 -1170 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -1160 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -2310 -1510 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -2410 -1560 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -1550 0 0 {name=I13 value=0}
C {devices/gnd.sym} -2690 -1500 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -1650 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -1650 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -1600 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -2660 -1600 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -2310 -1690 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -1680 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -1640 1 0 {name=p347 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2410 -1120 1 0 {name=p348 sig_type=std_logic lab=vlky}
C {devices/gnd.sym} -2310 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -2410 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2690 -510 0 0 {name=I15 value=0}
C {devices/gnd.sym} -2690 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -2510 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2590 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2490 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -2660 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -2310 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2550 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2410 -600 1 0 {name=p353 sig_type=std_logic lab=vlky}
C {devices/lab_pin.sym} -2160 -560 3 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2160 -1080 3 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2160 -1600 3 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2160 -2640 3 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2160 -3160 3 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -1080 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -1600 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -2120 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -2640 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -2310 -3160 0 0 {name=x2100}
C {devices/lab_pin.sym} -1860 -570 1 0 {name=p312 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1740 -570 1 0 {name=p405 sig_type=std_logic lab=vpos15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7660 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -7140 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6620 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -6100 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5580 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -5060 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4540 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -4020 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -3500 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2980 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -2460 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1940 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -1420 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -900 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1740 -380 0 0 {name=x150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/inhibitory/or_2.sym} -940 -1790 0 0 {name=x2}
C {devices/lab_pin.sym} -1860 -1090 1 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1740 -1090 1 0 {name=p382 sig_type=std_logic lab=vpos14}
C {devices/lab_pin.sym} -1860 -1610 1 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1740 -1610 1 0 {name=p392 sig_type=std_logic lab=vpos13}
C {devices/lab_pin.sym} -1740 -3170 1 0 {name=p394 sig_type=std_logic lab=vpos10}
C {devices/lab_pin.sym} -1860 -3170 1 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1860 -2650 1 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1740 -2650 1 0 {name=p400 sig_type=std_logic lab=vpos11}
C {devices/lab_pin.sym} -2160 -2120 3 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1860 -2130 1 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1740 -2130 1 0 {name=p396 sig_type=std_logic lab=vpos12}
C {devices/lab_pin.sym} -1800 -7890 1 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -7370 1 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6850 1 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -6330 1 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5810 1 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -5290 1 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4770 1 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -4250 1 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3730 1 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -3210 1 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2690 1 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -2170 1 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1650 1 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1800 -1130 1 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -1020 -1800 0 0 {name=l7 lab=GND}
C {devices/launcher.sym} -1520 -1575 0 0 {name=h3
descr="load 8" 
tclcommand="xschem raw_read $netlist_dir/SNN_15x1_tb.raw tran"
}
C {devices/lab_pin.sym} -2050 -8020 0 0 {name=p15 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -7840 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -7990 0 0 {name=x2011}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -7690 0 0 {name=x2013}
C {devices/lab_pin.sym} -2050 -7720 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} -1320 -2270 0 0 {name=V20 value="PWL(0 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} -1320 -2220 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} -1320 -2320 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1990 -7420 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} -1940 -7460 3 0 {name=p2 sig_type=std_logic lab=vpos2}
C {devices/gnd.sym} -1990 -7120 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -2050 -7350 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -7270 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -1990 -7530 0 0 {name=p24 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -7230 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -7380 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -7140 0 0 {name=p44 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -7500 0 0 {name=p49 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -7320 0 0 {name=x1}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -7470 0 0 {name=x3}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -7170 0 0 {name=x4}
C {devices/lab_pin.sym} -2050 -7200 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -6900 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} -1940 -6940 3 0 {name=p52 sig_type=std_logic lab=vpos3}
C {devices/gnd.sym} -1990 -6600 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -2050 -6830 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -6750 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -1990 -7010 0 0 {name=p62 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -6710 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -6860 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -6620 0 0 {name=p68 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -6980 0 0 {name=p69 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -6800 0 0 {name=x5}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -6950 0 0 {name=x6}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -6650 0 0 {name=x7}
C {devices/lab_pin.sym} -2050 -6680 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -6380 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} -1940 -6420 3 0 {name=p77 sig_type=std_logic lab=vpos4}
C {devices/gnd.sym} -1990 -6080 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -2050 -6310 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -6230 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -1990 -6490 0 0 {name=p90 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -6190 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -6340 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -6100 0 0 {name=p98 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -6460 0 0 {name=p99 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -6280 0 0 {name=x8}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -6430 0 0 {name=x9}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -6130 0 0 {name=x11}
C {devices/lab_pin.sym} -2050 -6160 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -5860 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} -1940 -5900 3 0 {name=p102 sig_type=std_logic lab=vpos5}
C {devices/gnd.sym} -1990 -5560 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -2050 -5790 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -5710 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -1990 -5970 0 0 {name=p112 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -5670 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -5820 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -5580 0 0 {name=p116 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -5940 0 0 {name=p118 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -5760 0 0 {name=x12}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -5910 0 0 {name=x13}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -5610 0 0 {name=x14}
C {devices/lab_pin.sym} -2050 -5640 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -5340 0 0 {name=l42 lab=GND}
C {devices/lab_pin.sym} -1940 -5380 3 0 {name=p122 sig_type=std_logic lab=vpos6}
C {devices/gnd.sym} -1990 -5040 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -2050 -5270 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -5190 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -1990 -5450 0 0 {name=p132 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -5150 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -5300 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -5060 0 0 {name=p135 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -5420 0 0 {name=p137 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -5240 0 0 {name=x15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -5390 0 0 {name=x16}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -5090 0 0 {name=x17}
C {devices/lab_pin.sym} -2050 -5120 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -4820 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -1940 -4860 3 0 {name=p145 sig_type=std_logic lab=vpos7}
C {devices/gnd.sym} -1990 -4520 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -2050 -4750 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -4670 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -1990 -4930 0 0 {name=p151 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -4630 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -4780 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -4540 0 0 {name=p154 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -4900 0 0 {name=p155 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -4720 0 0 {name=x18}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -4870 0 0 {name=x19}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -4570 0 0 {name=x21}
C {devices/lab_pin.sym} -2050 -4600 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -4300 0 0 {name=l48 lab=GND}
C {devices/lab_pin.sym} -1940 -4340 3 0 {name=p157 sig_type=std_logic lab=vpos8}
C {devices/gnd.sym} -1990 -4000 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -2050 -4230 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -4150 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -1990 -4410 0 0 {name=p166 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -4110 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -4260 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -4020 0 0 {name=p169 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -4380 0 0 {name=p171 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -4200 0 0 {name=x22}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -4350 0 0 {name=x23}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -4050 0 0 {name=x24}
C {devices/lab_pin.sym} -2050 -4080 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -3780 0 0 {name=l51 lab=GND}
C {devices/lab_pin.sym} -1940 -3820 3 0 {name=p173 sig_type=std_logic lab=vpos9}
C {devices/gnd.sym} -1990 -3480 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -2050 -3710 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -3630 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1990 -3890 0 0 {name=p181 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -3590 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -3740 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -3500 0 0 {name=p184 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -3860 0 0 {name=p186 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -3680 0 0 {name=x25}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -3830 0 0 {name=x26}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -3530 0 0 {name=x27}
C {devices/lab_pin.sym} -2050 -3560 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -3260 0 0 {name=l54 lab=GND}
C {devices/lab_pin.sym} -1940 -3300 3 0 {name=p188 sig_type=std_logic lab=vpos10}
C {devices/gnd.sym} -1990 -2960 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -2050 -3190 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -3110 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -1990 -3370 0 0 {name=p194 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -3070 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -3220 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -2980 0 0 {name=p197 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -3340 0 0 {name=p198 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -3160 0 0 {name=x28}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -3310 0 0 {name=x29}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -3010 0 0 {name=x31}
C {devices/lab_pin.sym} -2050 -3040 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -2740 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} -1940 -2780 3 0 {name=p200 sig_type=std_logic lab=vpos11}
C {devices/gnd.sym} -1990 -2440 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -2050 -2670 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -2590 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -1990 -2850 0 0 {name=p206 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -2550 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -2700 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -2460 0 0 {name=p209 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -2820 0 0 {name=p210 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -2640 0 0 {name=x32}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -2790 0 0 {name=x33}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -2490 0 0 {name=x34}
C {devices/lab_pin.sym} -2050 -2520 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -2220 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} -1940 -2260 3 0 {name=p212 sig_type=std_logic lab=vpos12}
C {devices/gnd.sym} -1990 -1920 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -2050 -2150 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -2070 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -1990 -2330 0 0 {name=p221 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -2030 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -2180 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -1940 0 0 {name=p226 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -2300 0 0 {name=p227 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -2120 0 0 {name=x35}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -2270 0 0 {name=x36}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -1970 0 0 {name=x37}
C {devices/lab_pin.sym} -2050 -2000 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -1700 0 0 {name=l74 lab=GND}
C {devices/lab_pin.sym} -1940 -1740 3 0 {name=p229 sig_type=std_logic lab=vpos13}
C {devices/gnd.sym} -1990 -1400 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -2050 -1630 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -1550 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -1990 -1810 0 0 {name=p236 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -1510 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -1660 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -1420 0 0 {name=p239 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -1780 0 0 {name=p240 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -1600 0 0 {name=x38}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -1750 0 0 {name=x39}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -1450 0 0 {name=x41}
C {devices/lab_pin.sym} -2050 -1480 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -1180 0 0 {name=l82 lab=GND}
C {devices/lab_pin.sym} -1940 -1220 3 0 {name=p242 sig_type=std_logic lab=vpos14}
C {devices/gnd.sym} -1990 -880 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -2050 -1110 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -1030 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -1990 -1290 0 0 {name=p248 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -990 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -1140 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -900 0 0 {name=p251 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -1260 0 0 {name=p253 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -1080 0 0 {name=x42}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -1230 0 0 {name=x43}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -930 0 0 {name=x44}
C {devices/lab_pin.sym} -2050 -960 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1990 -660 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -1940 -700 3 0 {name=p255 sig_type=std_logic lab=vpos15}
C {devices/gnd.sym} -1990 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -2050 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1990 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -1990 -770 0 0 {name=p261 sig_type=std_logic lab=vdd_stdp}
C {devices/lab_pin.sym} -1990 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1990 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2050 -380 0 0 {name=p265 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} -2050 -740 0 0 {name=p266 sig_type=std_logic lab=ctrl_stdp}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1990 -560 0 0 {name=x45}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/STDP_circuit.sym} -1990 -710 0 0 {name=x46}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1990 -410 0 0 {name=x47}
C {devices/lab_pin.sym} -2050 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -1940 -7330 1 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1940 -7180 1 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -2040 -7310 3 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2040 -7460 3 0 {name=p20 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -2040 -6790 3 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -2040 -6940 3 0 {name=p54 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1940 -6810 1 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1940 -6660 1 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -2040 -6270 3 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -2040 -6420 3 0 {name=p83 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1940 -6290 1 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1940 -6140 1 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1940 -5770 1 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1940 -5620 1 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -2040 -5750 3 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2040 -5900 3 0 {name=p109 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -2040 -5230 3 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -2040 -5380 3 0 {name=p126 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -1940 -5250 1 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1940 -5100 1 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -2040 -550 3 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -2040 -700 3 0 {name=p147 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -1940 -570 1 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1940 -420 1 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -2040 -1070 3 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -2040 -1220 3 0 {name=p244 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -1940 -1090 1 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1940 -940 1 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -2040 -1590 3 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -2040 -1740 3 0 {name=p231 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -1940 -1610 1 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1940 -1460 1 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -2040 -2110 3 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -2040 -2260 3 0 {name=p214 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1940 -2130 1 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1940 -1980 1 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1940 -2650 1 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1940 -2500 1 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -2040 -2630 3 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2040 -2780 3 0 {name=p204 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -2040 -3150 3 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -2040 -3300 3 0 {name=p190 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -1940 -3170 1 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1940 -3020 1 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -2040 -3670 3 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -2040 -3820 3 0 {name=p175 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1940 -3690 1 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1940 -3540 1 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -2040 -4190 3 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -2040 -4340 3 0 {name=p161 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1940 -4210 1 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1940 -4060 1 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -2040 -4710 3 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -2040 -4860 3 0 {name=p257 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1940 -4730 1 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1940 -4580 1 0 {name=p259 sig_type=std_logic lab=vpres7}
