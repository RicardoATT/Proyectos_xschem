v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 0 -1200 800 -800 {flags=graph
y1=-0.053
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vps1; vpre1\\"
\\"vps2; vpre2\\"
\\"vps3; vpre3\\"
\\"vps4; vpre4\\"
\\"vps5; vpre5\\"
\\"vps6; vpre6\\"
\\"vps7; vpre7\\"
\\"vps8; vpre8\\"
\\"vps9; vpre9\\""}
B 2 0 -400 800 0 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="7 8 11"
node="\\"Weights updating ;uw\\"
\\"Training;training\\"
\\"Inference;inference\\""}
B 2 1600 -2800 2400 -2400 {flags=graph
y1=-1.2e-06
y2=1.2e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color="15 16 17"
node="\\"Ip0;i(vmeas160)\\"
\\"Ip6;i(vmeas8)\\"
\\"Ip8;i(vmeas6)\\""}
B 2 3200 -2400 4000 -2000 {flags=graph
y1=-0.46
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="\\"0; N0\\"
\\"1;N1\\"
\\"2;N2\\"
\\"3;N3\\"
\\"4;N4\\"
\\"5;N5\\"
\\"6;N6\\"
\\"7;N7\\"
\\"8;N8\\"
\\"9;N9\\""}
B 2 0 -800 800 -400 {flags=graph
y1=3.3
y2=5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21 17"
node="\\"S10; 5 n.x10.xr1.n1#ngap -\\"
\\"S20; 5 n.x20.xr1.n1#ngap -\\"
\\"S30; 5 n.x30.xr1.n1#ngap -\\"
\\"S40; 5 n.x40.xr1.n1#ngap -\\"
\\"S50; 5 n.x50.xr1.n1#ngap -\\"
\\"S60; 5 n.x60.xr1.n1#ngap -\\"
\\"S70; 5 n.x70.xr1.n1#ngap -\\"
\\"S80; 5 n.x80.xr1.n1#ngap -\\"
\\"S90; 5 n.x90.xr1.n1#ngap -\\"
\\"S100; 5 n.x100.xr1.n1#ngap -\\"
\\"S110; 5 n.x110.xr1.n1#ngap -\\"
\\"S120; 5 n.x120.xr1.n1#ngap -\\"
\\"S130; 5 n.x130.xr1.n1#ngap -\\"
\\"S140; 5 n.x140.xr1.n1#ngap -\\"
\\"S150; 5 n.x150.xr1.n1#ngap -\\"
\\"[nm]\\"
gnd"}
B 2 800 -800 1600 -400 {flags=graph
y1=-2.7e-06
y2=2.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 11 12 13 15 21 5 14 16 17 18 21"
node="\\"I10; i(Vmeas10)\\"
\\"I20; i(Vmeas20)\\"
\\"I30; i(Vmeas30)\\"
\\"I40; i(Vmeas40)\\"
\\"I50; i(Vmeas50)\\"
\\"I60; i(Vmeas60)\\"
\\"I70; i(Vmeas70)\\"
\\"I80; i(Vmeas80)\\"
\\"I90; i(Vmeas90)\\"
\\"I100; i(Vmeas100)\\"
\\"I110; i(Vmeas110)\\"
\\"I120; i(Vmeas120)\\"
\\"I130; i(Vmeas130)\\"
\\"I140; i(Vmeas140)\\"
\\"I150; i(Vmeas150)\\"
\\"[A]\\""}
B 2 1600 -2000 2400 -1600 {flags=graph
y1=0.0031
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre1}
B 2 1600 -1600 2400 -1200 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre4}
B 2 1600 -1200 2400 -800 {flags=graph
y1=0.57
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre7}
B 2 2400 -2000 3200 -1600 {flags=graph
y1=0.019
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre2}
B 2 2400 -1600 3200 -1200 {flags=graph
y1=0.0031
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre5}
B 2 2400 -1200 3200 -800 {flags=graph
y1=0.0031
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre8}
B 2 3200 -2000 4000 -1600 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre3}
B 2 3200 -1600 4000 -1200 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre6}
B 2 3200 -1200 4000 -800 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre9}
B 2 1600 -800 2400 -400 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre10}
B 2 1600 -400 2400 0 {flags=graph
y1=0.54
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre13}
B 2 2400 -800 3200 -400 {flags=graph
y1=0.0031
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre11}
B 2 2400 -400 3200 0 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre14}
B 2 3200 -800 4000 -400 {flags=graph
y1=0.12
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre12}
B 2 3200 -400 4000 0 {flags=graph
y1=0.0031
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color=4
node=vpre15}
B 2 800 -1200 1600 -800 {flags=graph
y1=-4.9e-07
y2=2.4e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color=15
node=i(Vmeas10)}
B 2 800 -400 1600 0 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 0 -1600 800 -1200 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 6 7 8 10 11 12 13 15"
node="\\"vpres1; vpres1\\"
\\"vpres2; vpres2\\"
\\"vpres3; vpres3\\"
\\"vpres4; vpres4\\"
\\"vpres5; vpres5\\"
\\"vpres6; vpres6\\"
\\"vpres7; vpres7\\"
\\"vpres8; vpres8\\"
\\"vpres9; vpres9\\""}
B 2 2400 -2400 3200 -2000 {flags=graph
y1=-0.084
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="p0
p1
p2
p3
p4
p5
p6
p7
p8
p9"}
B 2 800 -1600 1600 -1200 {flags=graph
y1=-8.4e-09
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0





color="4 6 7 8 10 12 14 15 21 16"
node="inh0
inh1
inh2
inh3
inh4
inh5
inh6
inh7
inh8
inh9"}
B 2 1600 -2400 2400 -2000 {flags=graph
y1=0.3848
y2=2.4038
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.409e-05
x2=0.000177809
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0






color=9
node=inh_d}
N 20 -2620 20 -2600 {
lab=GND}
N 20 -2700 20 -2680 {
lab=vdd_in}
N 100 -2620 100 -2600 {
lab=GND}
N 100 -2700 100 -2680 {
lab=vdd_pre}
N -1780 -4390 -1780 -4370 {
lab=GND}
N -1780 -4550 -1780 -4530 {
lab=vdd_pre}
N -2160 -4380 -2160 -4360 {
lab=GND}
N -1960 -4480 -1960 -4460 {
lab=vc2}
N -1960 -4510 -1950 -4510 {
lab=vdd_in}
N -1950 -4540 -1950 -4510 {
lab=vdd_in}
N -1960 -4540 -1950 -4540 {
lab=vdd_in}
N -2040 -4510 -2000 -4510 {
lab=#net1}
N -2080 -4540 -1960 -4540 {
lab=vdd_in}
N -2090 -4510 -2080 -4510 {
lab=vdd_in}
N -2090 -4540 -2090 -4510 {
lab=vdd_in}
N -2090 -4540 -2080 -4540 {
lab=vdd_in}
N -2080 -4480 -2080 -4460 {
lab=#net1}
N -2080 -4460 -2020 -4460 {
lab=#net1}
N -2020 -4510 -2020 -4460 {
lab=#net1}
N -2160 -4460 -2160 -4440 {
lab=#net2}
N -1100 -4700 -1100 -4690 {
lab=GND}
N -1100 -4810 -1100 -4800 {
lab=vdd_syn0}
N -1040 -4620 -1030 -4620 {
lab=GND}
N -1040 -4590 -1040 -4580 {
lab=p0}
N 20 -2200 20 -2180 {
lab=GND}
N 20 -2280 20 -2260 {
lab=uw}
N 200 -2200 200 -2180 {
lab=GND}
N 200 -2280 200 -2260 {
lab=training}
N -1640 -4460 -1630 -4460 {
lab=vpre2}
N 460 -2200 460 -2180 {
lab=GND}
N 460 -2280 460 -2260 {
lab=inference}
N -2100 -4460 -2080 -4460 {
lab=#net1}
N 20 -2340 20 -2320 {
lab=GND}
N 20 -2420 20 -2400 {
lab=ctrl_wu}
N 190 -2480 190 -2460 {
lab=GND}
N 190 -2560 190 -2540 {
lab=vb_wu}
N 190 -2620 190 -2600 {
lab=GND}
N 190 -2700 190 -2680 {
lab=vdd_pos}
N 280 -2620 280 -2600 {
lab=GND}
N 280 -2700 280 -2680 {
lab=vdd_wu}
N 360 -2620 360 -2600 {
lab=GND}
N 360 -2700 360 -2680 {
lab=vdd_tr}
N 110 -2480 110 -2460 {
lab=GND}
N 110 -2560 110 -2540 {
lab=vb_pre}
N 340 -2480 340 -2460 {
lab=GND}
N 340 -2560 340 -2540 {
lab=vb_pos}
N -1170 -4760 -1160 -4760 {
lab=vpres1}
N -1040 -4760 -1030 -4760 {
lab=w_px}
N -1780 -4690 -1780 -4670 {
lab=GND}
N -1780 -4850 -1780 -4830 {
lab=vdd_pre}
N -2160 -4680 -2160 -4660 {
lab=GND}
N -1960 -4780 -1960 -4760 {
lab=vc1}
N -1960 -4810 -1950 -4810 {
lab=vdd_in}
N -1950 -4840 -1950 -4810 {
lab=vdd_in}
N -1960 -4840 -1950 -4840 {
lab=vdd_in}
N -2040 -4810 -2000 -4810 {
lab=#net3}
N -2080 -4840 -1960 -4840 {
lab=vdd_in}
N -2090 -4810 -2080 -4810 {
lab=vdd_in}
N -2090 -4840 -2090 -4810 {
lab=vdd_in}
N -2090 -4840 -2080 -4840 {
lab=vdd_in}
N -2080 -4780 -2080 -4760 {
lab=#net3}
N -2080 -4760 -2020 -4760 {
lab=#net3}
N -2020 -4810 -2020 -4760 {
lab=#net3}
N -2160 -4760 -2160 -4740 {
lab=#net4}
N -1100 -4400 -1100 -4390 {
lab=GND}
N -1100 -4510 -1100 -4500 {
lab=vdd_syn0}
N -1040 -4320 -1030 -4320 {
lab=GND}
N -1040 -4290 -1040 -4280 {
lab=p0}
N -1640 -4760 -1630 -4760 {
lab=vpre1}
N -2100 -4760 -2080 -4760 {
lab=#net3}
N -1410 -4570 -1410 -4560 {
lab=GND}
N -1360 -4610 -1350 -4610 {
lab=vpres1}
N -1410 -4720 -1410 -4710 {
lab=GND}
N -1360 -4760 -1350 -4760 {
lab=vpres1}
N -1170 -4460 -1160 -4460 {
lab=vpres2}
N -1040 -4460 -1030 -4460 {
lab=b_px}
N -1090 -4320 -1080 -4320 {
lab=ctrl_pos}
N -1090 -4620 -1080 -4620 {
lab=ctrl_pos}
N 170 -2340 170 -2320 {
lab=GND}
N 170 -2420 170 -2400 {
lab=ctrl_inf}
N 520 -2620 520 -2600 {
lab=GND}
N 520 -2700 520 -2680 {
lab=vdd_inh}
N 120 -4590 120 -4580 {
lab=vdd_inh}
N 330 -2340 330 -2320 {
lab=GND}
N 330 -2420 330 -2400 {
lab=ctrl_vinh}
N 120 -4300 120 -4290 {
lab=GND}
N 300 -4440 310 -4440 {
lab=inh_d}
N 20 -2480 20 -2460 {
lab=GND}
N 20 -2560 20 -2540 {
lab=vlky_pre}
N -1960 -4760 -1880 -4760 {
lab=vc1}
N -1880 -4800 -1870 -4800 {
lab=vlky_pre}
N -1880 -4720 -1870 -4720 {
lab=vb_pre}
N -1880 -4500 -1870 -4500 {
lab=vlky_pre}
N -1960 -4460 -1880 -4460 {
lab=vc2}
N -1880 -4420 -1870 -4420 {
lab=vb_pre}
N 20 -2760 20 -2740 {
lab=GND}
N 20 -2840 20 -2820 {
lab=vdd_syn0}
N -1470 -4580 -1460 -4580 {
lab=vb_wu}
N -1040 -4740 -1040 -4720 {
lab=#net5}
N -1040 -4660 -1040 -4650 {
lab=#net6}
N -1040 -4440 -1040 -4420 {
lab=#net7}
N -1040 -4360 -1040 -4350 {
lab=#net8}
N -1100 -4100 -1100 -4090 {
lab=GND}
N -1100 -4210 -1100 -4200 {
lab=vdd_syn0}
N -1040 -4020 -1030 -4020 {
lab=GND}
N -1040 -3990 -1040 -3980 {
lab=p0}
N -1170 -4160 -1160 -4160 {
lab=vpres3}
N -1040 -4160 -1030 -4160 {
lab=w_px}
N -1090 -4020 -1080 -4020 {
lab=ctrl_pos}
N -1040 -4140 -1040 -4120 {
lab=#net9}
N -1040 -4060 -1040 -4050 {
lab=#net10}
N -1100 -3800 -1100 -3790 {
lab=GND}
N -1100 -3910 -1100 -3900 {
lab=vdd_syn0}
N -1040 -3720 -1030 -3720 {
lab=GND}
N -1040 -3690 -1040 -3680 {
lab=p0}
N -1170 -3860 -1160 -3860 {
lab=vpres4}
N -1040 -3860 -1030 -3860 {
lab=b_px}
N -1090 -3720 -1080 -3720 {
lab=ctrl_pos}
N -1040 -3840 -1040 -3820 {
lab=#net11}
N -1040 -3760 -1040 -3750 {
lab=#net12}
N -1100 -3500 -1100 -3490 {
lab=GND}
N -1100 -3610 -1100 -3600 {
lab=vdd_syn0}
N -1040 -3420 -1030 -3420 {
lab=GND}
N -1040 -3390 -1040 -3380 {
lab=p0}
N -1170 -3560 -1160 -3560 {
lab=vpres5}
N -1040 -3560 -1030 -3560 {
lab=w_px}
N -1090 -3420 -1080 -3420 {
lab=ctrl_pos}
N -1040 -3540 -1040 -3520 {
lab=#net13}
N -1040 -3460 -1040 -3450 {
lab=#net14}
N -1100 -3200 -1100 -3190 {
lab=GND}
N -1100 -3310 -1100 -3300 {
lab=vdd_syn0}
N -1040 -3120 -1030 -3120 {
lab=GND}
N -1040 -3090 -1040 -3080 {
lab=p0}
N -1170 -3260 -1160 -3260 {
lab=vpres6}
N -1040 -3260 -1030 -3260 {
lab=b_px}
N -1090 -3120 -1080 -3120 {
lab=ctrl_pos}
N -1040 -3240 -1040 -3220 {
lab=#net15}
N -1040 -3160 -1040 -3150 {
lab=#net16}
N -1100 -2900 -1100 -2890 {
lab=GND}
N -1100 -3010 -1100 -3000 {
lab=vdd_syn0}
N -1040 -2820 -1030 -2820 {
lab=GND}
N -1040 -2790 -1040 -2780 {
lab=p0}
N -1170 -2960 -1160 -2960 {
lab=vpres7}
N -1040 -2960 -1030 -2960 {
lab=b_px}
N -1090 -2820 -1080 -2820 {
lab=ctrl_pos}
N -1040 -2940 -1040 -2920 {
lab=#net17}
N -1040 -2860 -1040 -2850 {
lab=#net18}
N -1100 -2600 -1100 -2590 {
lab=GND}
N -1100 -2710 -1100 -2700 {
lab=vdd_syn0}
N -1040 -2520 -1030 -2520 {
lab=GND}
N -1040 -2490 -1040 -2480 {
lab=p0}
N -1170 -2660 -1160 -2660 {
lab=vpres8}
N -1040 -2660 -1030 -2660 {
lab=w_px}
N -1090 -2520 -1080 -2520 {
lab=ctrl_pos}
N -1040 -2640 -1040 -2620 {
lab=#net19}
N -1040 -2560 -1040 -2550 {
lab=#net20}
N -1100 -2300 -1100 -2290 {
lab=GND}
N -1100 -2410 -1100 -2400 {
lab=vdd_syn0}
N -1040 -2220 -1030 -2220 {
lab=GND}
N -1040 -2190 -1040 -2180 {
lab=p0}
N -1170 -2360 -1160 -2360 {
lab=vpres9}
N -1040 -2360 -1030 -2360 {
lab=b_px}
N -1090 -2220 -1080 -2220 {
lab=ctrl_pos}
N -1040 -2340 -1040 -2320 {
lab=#net21}
N -1040 -2260 -1040 -2250 {
lab=#net22}
N -1780 -3790 -1780 -3770 {
lab=GND}
N -1780 -3950 -1780 -3930 {
lab=vdd_pre}
N -2160 -3780 -2160 -3760 {
lab=GND}
N -1960 -3880 -1960 -3860 {
lab=vc4}
N -1960 -3910 -1950 -3910 {
lab=vdd_in}
N -1950 -3940 -1950 -3910 {
lab=vdd_in}
N -1960 -3940 -1950 -3940 {
lab=vdd_in}
N -2040 -3910 -2000 -3910 {
lab=#net23}
N -2080 -3940 -1960 -3940 {
lab=vdd_in}
N -2090 -3910 -2080 -3910 {
lab=vdd_in}
N -2090 -3940 -2090 -3910 {
lab=vdd_in}
N -2090 -3940 -2080 -3940 {
lab=vdd_in}
N -2080 -3880 -2080 -3860 {
lab=#net23}
N -2080 -3860 -2020 -3860 {
lab=#net23}
N -2020 -3910 -2020 -3860 {
lab=#net23}
N -2160 -3860 -2160 -3840 {
lab=#net24}
N -1640 -3860 -1630 -3860 {
lab=vpre4}
N -2100 -3860 -2080 -3860 {
lab=#net23}
N -1780 -4090 -1780 -4070 {
lab=GND}
N -1780 -4250 -1780 -4230 {
lab=vdd_pre}
N -2160 -4080 -2160 -4060 {
lab=GND}
N -1960 -4180 -1960 -4160 {
lab=vc3}
N -1960 -4210 -1950 -4210 {
lab=vdd_in}
N -1950 -4240 -1950 -4210 {
lab=vdd_in}
N -1960 -4240 -1950 -4240 {
lab=vdd_in}
N -2040 -4210 -2000 -4210 {
lab=#net25}
N -2080 -4240 -1960 -4240 {
lab=vdd_in}
N -2090 -4210 -2080 -4210 {
lab=vdd_in}
N -2090 -4240 -2090 -4210 {
lab=vdd_in}
N -2090 -4240 -2080 -4240 {
lab=vdd_in}
N -2080 -4180 -2080 -4160 {
lab=#net25}
N -2080 -4160 -2020 -4160 {
lab=#net25}
N -2020 -4210 -2020 -4160 {
lab=#net25}
N -2160 -4160 -2160 -4140 {
lab=#net26}
N -1640 -4160 -1630 -4160 {
lab=vpre3}
N -2100 -4160 -2080 -4160 {
lab=#net25}
N -1960 -4160 -1880 -4160 {
lab=vc3}
N -1880 -4200 -1870 -4200 {
lab=vlky_pre}
N -1880 -4120 -1870 -4120 {
lab=vb_pre}
N -1880 -3900 -1870 -3900 {
lab=vlky_pre}
N -1960 -3860 -1880 -3860 {
lab=vc4}
N -1880 -3820 -1870 -3820 {
lab=vb_pre}
N -1780 -3190 -1780 -3170 {
lab=GND}
N -1780 -3350 -1780 -3330 {
lab=vdd_pre}
N -2160 -3180 -2160 -3160 {
lab=GND}
N -1960 -3280 -1960 -3260 {
lab=vc6}
N -1960 -3310 -1950 -3310 {
lab=vdd_in}
N -1950 -3340 -1950 -3310 {
lab=vdd_in}
N -1960 -3340 -1950 -3340 {
lab=vdd_in}
N -2040 -3310 -2000 -3310 {
lab=#net27}
N -2080 -3340 -1960 -3340 {
lab=vdd_in}
N -2090 -3310 -2080 -3310 {
lab=vdd_in}
N -2090 -3340 -2090 -3310 {
lab=vdd_in}
N -2090 -3340 -2080 -3340 {
lab=vdd_in}
N -2080 -3280 -2080 -3260 {
lab=#net27}
N -2080 -3260 -2020 -3260 {
lab=#net27}
N -2020 -3310 -2020 -3260 {
lab=#net27}
N -2160 -3260 -2160 -3240 {
lab=#net28}
N -1640 -3260 -1630 -3260 {
lab=vpre6}
N -2100 -3260 -2080 -3260 {
lab=#net27}
N -1780 -3490 -1780 -3470 {
lab=GND}
N -1780 -3650 -1780 -3630 {
lab=vdd_pre}
N -2160 -3480 -2160 -3460 {
lab=GND}
N -1960 -3580 -1960 -3560 {
lab=vc5}
N -1960 -3610 -1950 -3610 {
lab=vdd_in}
N -1950 -3640 -1950 -3610 {
lab=vdd_in}
N -1960 -3640 -1950 -3640 {
lab=vdd_in}
N -2040 -3610 -2000 -3610 {
lab=#net29}
N -2080 -3640 -1960 -3640 {
lab=vdd_in}
N -2090 -3610 -2080 -3610 {
lab=vdd_in}
N -2090 -3640 -2090 -3610 {
lab=vdd_in}
N -2090 -3640 -2080 -3640 {
lab=vdd_in}
N -2080 -3580 -2080 -3560 {
lab=#net29}
N -2080 -3560 -2020 -3560 {
lab=#net29}
N -2020 -3610 -2020 -3560 {
lab=#net29}
N -2160 -3560 -2160 -3540 {
lab=#net30}
N -1640 -3560 -1630 -3560 {
lab=vpre5}
N -2100 -3560 -2080 -3560 {
lab=#net29}
N -1960 -3560 -1880 -3560 {
lab=vc5}
N -1880 -3600 -1870 -3600 {
lab=vlky_pre}
N -1880 -3520 -1870 -3520 {
lab=vb_pre}
N -1880 -3300 -1870 -3300 {
lab=vlky_pre}
N -1960 -3260 -1880 -3260 {
lab=vc6}
N -1880 -3220 -1870 -3220 {
lab=vb_pre}
N -1780 -2590 -1780 -2570 {
lab=GND}
N -1780 -2750 -1780 -2730 {
lab=vdd_pre}
N -2160 -2580 -2160 -2560 {
lab=GND}
N -1960 -2680 -1960 -2660 {
lab=vc8}
N -1960 -2710 -1950 -2710 {
lab=vdd_in}
N -1950 -2740 -1950 -2710 {
lab=vdd_in}
N -1960 -2740 -1950 -2740 {
lab=vdd_in}
N -2040 -2710 -2000 -2710 {
lab=#net31}
N -2080 -2740 -1960 -2740 {
lab=vdd_in}
N -2090 -2710 -2080 -2710 {
lab=vdd_in}
N -2090 -2740 -2090 -2710 {
lab=vdd_in}
N -2090 -2740 -2080 -2740 {
lab=vdd_in}
N -2080 -2680 -2080 -2660 {
lab=#net31}
N -2080 -2660 -2020 -2660 {
lab=#net31}
N -2020 -2710 -2020 -2660 {
lab=#net31}
N -2160 -2660 -2160 -2640 {
lab=#net32}
N -1640 -2660 -1630 -2660 {
lab=vpre8}
N -2100 -2660 -2080 -2660 {
lab=#net31}
N -1780 -2890 -1780 -2870 {
lab=GND}
N -1780 -3050 -1780 -3030 {
lab=vdd_pre}
N -2160 -2880 -2160 -2860 {
lab=GND}
N -1960 -2980 -1960 -2960 {
lab=vc7}
N -1960 -3010 -1950 -3010 {
lab=vdd_in}
N -1950 -3040 -1950 -3010 {
lab=vdd_in}
N -1960 -3040 -1950 -3040 {
lab=vdd_in}
N -2040 -3010 -2000 -3010 {
lab=#net33}
N -2080 -3040 -1960 -3040 {
lab=vdd_in}
N -2090 -3010 -2080 -3010 {
lab=vdd_in}
N -2090 -3040 -2090 -3010 {
lab=vdd_in}
N -2090 -3040 -2080 -3040 {
lab=vdd_in}
N -2080 -2980 -2080 -2960 {
lab=#net33}
N -2080 -2960 -2020 -2960 {
lab=#net33}
N -2020 -3010 -2020 -2960 {
lab=#net33}
N -2160 -2960 -2160 -2940 {
lab=#net34}
N -1640 -2960 -1630 -2960 {
lab=vpre7}
N -2100 -2960 -2080 -2960 {
lab=#net33}
N -1960 -2960 -1880 -2960 {
lab=vc7}
N -1880 -3000 -1870 -3000 {
lab=vlky_pre}
N -1880 -2920 -1870 -2920 {
lab=vb_pre}
N -1880 -2700 -1870 -2700 {
lab=vlky_pre}
N -1960 -2660 -1880 -2660 {
lab=vc8}
N -1880 -2620 -1870 -2620 {
lab=vb_pre}
N -1780 -2290 -1780 -2270 {
lab=GND}
N -1780 -2450 -1780 -2430 {
lab=vdd_pre}
N -2160 -2280 -2160 -2260 {
lab=GND}
N -1960 -2380 -1960 -2360 {
lab=vc9}
N -1960 -2410 -1950 -2410 {
lab=vdd_in}
N -1950 -2440 -1950 -2410 {
lab=vdd_in}
N -1960 -2440 -1950 -2440 {
lab=vdd_in}
N -2040 -2410 -2000 -2410 {
lab=#net35}
N -2080 -2440 -1960 -2440 {
lab=vdd_in}
N -2090 -2410 -2080 -2410 {
lab=vdd_in}
N -2090 -2440 -2090 -2410 {
lab=vdd_in}
N -2090 -2440 -2080 -2440 {
lab=vdd_in}
N -2080 -2380 -2080 -2360 {
lab=#net35}
N -2080 -2360 -2020 -2360 {
lab=#net35}
N -2020 -2410 -2020 -2360 {
lab=#net35}
N -2160 -2360 -2160 -2340 {
lab=#net36}
N -1640 -2360 -1630 -2360 {
lab=vpre9}
N -2100 -2360 -2080 -2360 {
lab=#net35}
N -1880 -2400 -1870 -2400 {
lab=vlky_pre}
N -1960 -2360 -1880 -2360 {
lab=vc9}
N -1880 -2320 -1870 -2320 {
lab=vb_pre}
N 30 -4360 40 -4360 {
lab=N0}
N -1100 -2000 -1100 -1990 {
lab=GND}
N -1100 -2110 -1100 -2100 {
lab=vdd_syn0}
N -1040 -1920 -1030 -1920 {
lab=GND}
N -1040 -1890 -1040 -1880 {
lab=p0}
N -1170 -2060 -1160 -2060 {
lab=vpres10}
N -1040 -2060 -1030 -2060 {
lab=b_px}
N -1090 -1920 -1080 -1920 {
lab=ctrl_pos}
N -1040 -2040 -1040 -2020 {
lab=#net37}
N -1040 -1960 -1040 -1950 {
lab=#net38}
N -1100 -1700 -1100 -1690 {
lab=GND}
N -1100 -1810 -1100 -1800 {
lab=vdd_syn0}
N -1040 -1620 -1030 -1620 {
lab=GND}
N -1040 -1590 -1040 -1580 {
lab=p0}
N -1170 -1760 -1160 -1760 {
lab=vpres11}
N -1040 -1760 -1030 -1760 {
lab=w_px}
N -1090 -1620 -1080 -1620 {
lab=ctrl_pos}
N -1040 -1740 -1040 -1720 {
lab=#net39}
N -1040 -1660 -1040 -1650 {
lab=#net40}
N -1100 -1400 -1100 -1390 {
lab=GND}
N -1100 -1510 -1100 -1500 {
lab=vdd_syn0}
N -1040 -1320 -1030 -1320 {
lab=GND}
N -1040 -1290 -1040 -1280 {
lab=p0}
N -1170 -1460 -1160 -1460 {
lab=vpres12}
N -1040 -1460 -1030 -1460 {
lab=b_px}
N -1090 -1320 -1080 -1320 {
lab=ctrl_pos}
N -1040 -1440 -1040 -1420 {
lab=#net41}
N -1040 -1360 -1040 -1350 {
lab=#net42}
N -1100 -1100 -1100 -1090 {
lab=GND}
N -1100 -1210 -1100 -1200 {
lab=vdd_syn0}
N -1040 -1020 -1030 -1020 {
lab=GND}
N -1040 -990 -1040 -980 {
lab=p0}
N -1170 -1160 -1160 -1160 {
lab=vpres13}
N -1040 -1160 -1030 -1160 {
lab=w_px}
N -1090 -1020 -1080 -1020 {
lab=ctrl_pos}
N -1040 -1140 -1040 -1120 {
lab=#net43}
N -1040 -1060 -1040 -1050 {
lab=#net44}
N -1100 -800 -1100 -790 {
lab=GND}
N -1100 -910 -1100 -900 {
lab=vdd_syn0}
N -1040 -720 -1030 -720 {
lab=GND}
N -1040 -690 -1040 -680 {
lab=p0}
N -1090 -720 -1080 -720 {
lab=ctrl_pos}
N -1040 -840 -1040 -820 {
lab=#net45}
N -1040 -760 -1040 -750 {
lab=#net46}
N -1100 -500 -1100 -490 {
lab=GND}
N -1100 -610 -1100 -600 {
lab=vdd_syn0}
N -1040 -420 -1030 -420 {
lab=GND}
N -1040 -390 -1040 -380 {
lab=p0}
N -1040 -560 -1030 -560 {
lab=w_px}
N -1090 -420 -1080 -420 {
lab=ctrl_pos}
N -1040 -540 -1040 -520 {
lab=#net47}
N -1040 -460 -1040 -450 {
lab=#net48}
N -1780 -1990 -1780 -1970 {
lab=GND}
N -1780 -2150 -1780 -2130 {
lab=vdd_pre}
N -2160 -1980 -2160 -1960 {
lab=GND}
N -1960 -2080 -1960 -2060 {
lab=vc10}
N -1960 -2110 -1950 -2110 {
lab=vdd_in}
N -1950 -2140 -1950 -2110 {
lab=vdd_in}
N -1960 -2140 -1950 -2140 {
lab=vdd_in}
N -2040 -2110 -2000 -2110 {
lab=#net49}
N -2080 -2140 -1960 -2140 {
lab=vdd_in}
N -2090 -2110 -2080 -2110 {
lab=vdd_in}
N -2090 -2140 -2090 -2110 {
lab=vdd_in}
N -2090 -2140 -2080 -2140 {
lab=vdd_in}
N -2080 -2080 -2080 -2060 {
lab=#net49}
N -2080 -2060 -2020 -2060 {
lab=#net49}
N -2020 -2110 -2020 -2060 {
lab=#net49}
N -2160 -2060 -2160 -2040 {
lab=#net50}
N -1640 -2060 -1630 -2060 {
lab=vpre10}
N -2100 -2060 -2080 -2060 {
lab=#net49}
N -1880 -2100 -1870 -2100 {
lab=vlky_pre}
N -1960 -2060 -1880 -2060 {
lab=vc10}
N -1880 -2020 -1870 -2020 {
lab=vb_pre}
N -1780 -1390 -1780 -1370 {
lab=GND}
N -1780 -1550 -1780 -1530 {
lab=vdd_pre}
N -2160 -1380 -2160 -1360 {
lab=GND}
N -1960 -1480 -1960 -1460 {
lab=vc12}
N -1960 -1510 -1950 -1510 {
lab=vdd_in}
N -1950 -1540 -1950 -1510 {
lab=vdd_in}
N -1960 -1540 -1950 -1540 {
lab=vdd_in}
N -2040 -1510 -2000 -1510 {
lab=#net51}
N -2080 -1540 -1960 -1540 {
lab=vdd_in}
N -2090 -1510 -2080 -1510 {
lab=vdd_in}
N -2090 -1540 -2090 -1510 {
lab=vdd_in}
N -2090 -1540 -2080 -1540 {
lab=vdd_in}
N -2080 -1480 -2080 -1460 {
lab=#net51}
N -2080 -1460 -2020 -1460 {
lab=#net51}
N -2020 -1510 -2020 -1460 {
lab=#net51}
N -2160 -1460 -2160 -1440 {
lab=#net52}
N -1640 -1460 -1630 -1460 {
lab=vpre12}
N -2100 -1460 -2080 -1460 {
lab=#net51}
N -1780 -1690 -1780 -1670 {
lab=GND}
N -1780 -1850 -1780 -1830 {
lab=vdd_pre}
N -2160 -1680 -2160 -1660 {
lab=GND}
N -1960 -1780 -1960 -1760 {
lab=vc11}
N -1960 -1810 -1950 -1810 {
lab=vdd_in}
N -1950 -1840 -1950 -1810 {
lab=vdd_in}
N -1960 -1840 -1950 -1840 {
lab=vdd_in}
N -2040 -1810 -2000 -1810 {
lab=#net53}
N -2080 -1840 -1960 -1840 {
lab=vdd_in}
N -2090 -1810 -2080 -1810 {
lab=vdd_in}
N -2090 -1840 -2090 -1810 {
lab=vdd_in}
N -2090 -1840 -2080 -1840 {
lab=vdd_in}
N -2080 -1780 -2080 -1760 {
lab=#net53}
N -2080 -1760 -2020 -1760 {
lab=#net53}
N -2020 -1810 -2020 -1760 {
lab=#net53}
N -2160 -1760 -2160 -1740 {
lab=#net54}
N -1640 -1760 -1630 -1760 {
lab=vpre11}
N -2100 -1760 -2080 -1760 {
lab=#net53}
N -1960 -1760 -1880 -1760 {
lab=vc11}
N -1880 -1800 -1870 -1800 {
lab=vlky_pre}
N -1880 -1720 -1870 -1720 {
lab=vb_pre}
N -1880 -1500 -1870 -1500 {
lab=vlky_pre}
N -1960 -1460 -1880 -1460 {
lab=vc12}
N -1880 -1420 -1870 -1420 {
lab=vb_pre}
N -1780 -790 -1780 -770 {
lab=GND}
N -1780 -950 -1780 -930 {
lab=vdd_pre}
N -2160 -780 -2160 -760 {
lab=GND}
N -1960 -880 -1960 -860 {
lab=vc14}
N -1960 -910 -1950 -910 {
lab=vdd_in}
N -1950 -940 -1950 -910 {
lab=vdd_in}
N -1960 -940 -1950 -940 {
lab=vdd_in}
N -2040 -910 -2000 -910 {
lab=#net55}
N -2080 -940 -1960 -940 {
lab=vdd_in}
N -2090 -910 -2080 -910 {
lab=vdd_in}
N -2090 -940 -2090 -910 {
lab=vdd_in}
N -2090 -940 -2080 -940 {
lab=vdd_in}
N -2080 -880 -2080 -860 {
lab=#net55}
N -2080 -860 -2020 -860 {
lab=#net55}
N -2020 -910 -2020 -860 {
lab=#net55}
N -2160 -860 -2160 -840 {
lab=#net56}
N -1640 -860 -1630 -860 {
lab=vpre14}
N -2100 -860 -2080 -860 {
lab=#net55}
N -1780 -1090 -1780 -1070 {
lab=GND}
N -1780 -1250 -1780 -1230 {
lab=vdd_pre}
N -2160 -1080 -2160 -1060 {
lab=GND}
N -1960 -1180 -1960 -1160 {
lab=vc13}
N -1960 -1210 -1950 -1210 {
lab=vdd_in}
N -1950 -1240 -1950 -1210 {
lab=vdd_in}
N -1960 -1240 -1950 -1240 {
lab=vdd_in}
N -2040 -1210 -2000 -1210 {
lab=#net57}
N -2080 -1240 -1960 -1240 {
lab=vdd_in}
N -2090 -1210 -2080 -1210 {
lab=vdd_in}
N -2090 -1240 -2090 -1210 {
lab=vdd_in}
N -2090 -1240 -2080 -1240 {
lab=vdd_in}
N -2080 -1180 -2080 -1160 {
lab=#net57}
N -2080 -1160 -2020 -1160 {
lab=#net57}
N -2020 -1210 -2020 -1160 {
lab=#net57}
N -2160 -1160 -2160 -1140 {
lab=#net58}
N -1640 -1160 -1630 -1160 {
lab=vpre13}
N -2100 -1160 -2080 -1160 {
lab=#net57}
N -1960 -1160 -1880 -1160 {
lab=vc13}
N -1880 -1200 -1870 -1200 {
lab=vlky_pre}
N -1880 -1120 -1870 -1120 {
lab=vb_pre}
N -1880 -900 -1870 -900 {
lab=vlky_pre}
N -1960 -860 -1880 -860 {
lab=vc14}
N -1880 -820 -1870 -820 {
lab=vb_pre}
N -1780 -490 -1780 -470 {
lab=GND}
N -1780 -650 -1780 -630 {
lab=vdd_pre}
N -2160 -480 -2160 -460 {
lab=GND}
N -1960 -580 -1960 -560 {
lab=vc15}
N -1960 -610 -1950 -610 {
lab=vdd_in}
N -1950 -640 -1950 -610 {
lab=vdd_in}
N -1960 -640 -1950 -640 {
lab=vdd_in}
N -2040 -610 -2000 -610 {
lab=#net59}
N -2080 -640 -1960 -640 {
lab=vdd_in}
N -2090 -610 -2080 -610 {
lab=vdd_in}
N -2090 -640 -2090 -610 {
lab=vdd_in}
N -2090 -640 -2080 -640 {
lab=vdd_in}
N -2080 -580 -2080 -560 {
lab=#net59}
N -2080 -560 -2020 -560 {
lab=#net59}
N -2020 -610 -2020 -560 {
lab=#net59}
N -2160 -560 -2160 -540 {
lab=#net60}
N -1640 -560 -1630 -560 {
lab=vpre15}
N -2100 -560 -2080 -560 {
lab=#net59}
N -1880 -600 -1870 -600 {
lab=vlky_pre}
N -1960 -560 -1880 -560 {
lab=vc15}
N -1880 -520 -1870 -520 {
lab=vb_pre}
N -1470 -4790 -1460 -4790 {
lab=ctrl_inf}
N -1410 -4670 -1410 -4650 {
lab=vdd_wu}
N -1410 -4820 -1410 -4800 {
lab=vdd_inf}
N -1470 -4640 -1460 -4640 {
lab=ctrl_wu}
N -1460 -4640 -1460 -4610 {
lab=ctrl_wu}
N 250 -2340 250 -2320 {
lab=GND}
N 250 -2420 250 -2400 {
lab=ctrl_pos}
N -1410 -4270 -1410 -4260 {
lab=GND}
N -1360 -4310 -1350 -4310 {
lab=vpres2}
N -1410 -4420 -1410 -4410 {
lab=GND}
N -1360 -4460 -1350 -4460 {
lab=vpres2}
N -1470 -4280 -1460 -4280 {
lab=vb_wu}
N -1470 -4490 -1460 -4490 {
lab=ctrl_inf}
N -1410 -4370 -1410 -4350 {
lab=vdd_wu}
N -1410 -4520 -1410 -4500 {
lab=vdd_inf}
N -1470 -4340 -1460 -4340 {
lab=ctrl_wu}
N -1460 -4340 -1460 -4310 {
lab=ctrl_wu}
N -1410 -3970 -1410 -3960 {
lab=GND}
N -1360 -4010 -1350 -4010 {
lab=vpres3}
N -1410 -4120 -1410 -4110 {
lab=GND}
N -1470 -4160 -1460 -4160 {
lab=vpre3}
N -1360 -4160 -1350 -4160 {
lab=vpres3}
N -1470 -3980 -1460 -3980 {
lab=vb_wu}
N -1470 -4190 -1460 -4190 {
lab=ctrl_inf}
N -1410 -4070 -1410 -4050 {
lab=vdd_wu}
N -1410 -4220 -1410 -4200 {
lab=vdd_inf}
N -1470 -4040 -1460 -4040 {
lab=ctrl_wu}
N -1460 -4040 -1460 -4010 {
lab=ctrl_wu}
N -1410 -3670 -1410 -3660 {
lab=GND}
N -1360 -3710 -1350 -3710 {
lab=vpres4}
N -1410 -3820 -1410 -3810 {
lab=GND}
N -1470 -3860 -1460 -3860 {
lab=vpre4}
N -1360 -3860 -1350 -3860 {
lab=vpres4}
N -1470 -3680 -1460 -3680 {
lab=vb_wu}
N -1470 -3890 -1460 -3890 {
lab=ctrl_inf}
N -1410 -3770 -1410 -3750 {
lab=vdd_wu}
N -1410 -3920 -1410 -3900 {
lab=vdd_inf}
N -1470 -3740 -1460 -3740 {
lab=ctrl_wu}
N -1460 -3740 -1460 -3710 {
lab=ctrl_wu}
N -1410 -3370 -1410 -3360 {
lab=GND}
N -1360 -3410 -1350 -3410 {
lab=vpres5}
N -1410 -3520 -1410 -3510 {
lab=GND}
N -1470 -3560 -1460 -3560 {
lab=vpre5}
N -1360 -3560 -1350 -3560 {
lab=vpres5}
N -1470 -3380 -1460 -3380 {
lab=vb_wu}
N -1470 -3590 -1460 -3590 {
lab=ctrl_inf}
N -1410 -3470 -1410 -3450 {
lab=vdd_wu}
N -1410 -3620 -1410 -3600 {
lab=vdd_inf}
N -1470 -3440 -1460 -3440 {
lab=ctrl_wu}
N -1460 -3440 -1460 -3410 {
lab=ctrl_wu}
N -1410 -3070 -1410 -3060 {
lab=GND}
N -1360 -3110 -1350 -3110 {
lab=vpres6}
N -1410 -3220 -1410 -3210 {
lab=GND}
N -1470 -3260 -1460 -3260 {
lab=vpre6}
N -1360 -3260 -1350 -3260 {
lab=vpres6}
N -1470 -3080 -1460 -3080 {
lab=vb_wu}
N -1470 -3290 -1460 -3290 {
lab=ctrl_inf}
N -1410 -3170 -1410 -3150 {
lab=vdd_wu}
N -1410 -3320 -1410 -3300 {
lab=vdd_inf}
N -1470 -3140 -1460 -3140 {
lab=ctrl_wu}
N -1460 -3140 -1460 -3110 {
lab=ctrl_wu}
N -1410 -2770 -1410 -2760 {
lab=GND}
N -1360 -2810 -1350 -2810 {
lab=vpres7}
N -1410 -2920 -1410 -2910 {
lab=GND}
N -1470 -2960 -1460 -2960 {
lab=vpre7}
N -1360 -2960 -1350 -2960 {
lab=vpres7}
N -1470 -2780 -1460 -2780 {
lab=vb_wu}
N -1470 -2990 -1460 -2990 {
lab=ctrl_inf}
N -1410 -2870 -1410 -2850 {
lab=vdd_wu}
N -1410 -3020 -1410 -3000 {
lab=vdd_inf}
N -1470 -2840 -1460 -2840 {
lab=ctrl_wu}
N -1460 -2840 -1460 -2810 {
lab=ctrl_wu}
N -1410 -2470 -1410 -2460 {
lab=GND}
N -1360 -2510 -1350 -2510 {
lab=vpres8}
N -1410 -2620 -1410 -2610 {
lab=GND}
N -1470 -2660 -1460 -2660 {
lab=vpre8}
N -1360 -2660 -1350 -2660 {
lab=vpres8}
N -1470 -2480 -1460 -2480 {
lab=vb_wu}
N -1470 -2690 -1460 -2690 {
lab=ctrl_inf}
N -1410 -2570 -1410 -2550 {
lab=vdd_wu}
N -1410 -2720 -1410 -2700 {
lab=vdd_inf}
N -1470 -2540 -1460 -2540 {
lab=ctrl_wu}
N -1460 -2540 -1460 -2510 {
lab=ctrl_wu}
N -1410 -2170 -1410 -2160 {
lab=GND}
N -1360 -2210 -1350 -2210 {
lab=vpres9}
N -1410 -2320 -1410 -2310 {
lab=GND}
N -1470 -2360 -1460 -2360 {
lab=vpre9}
N -1360 -2360 -1350 -2360 {
lab=vpres9}
N -1470 -2180 -1460 -2180 {
lab=vb_wu}
N -1470 -2390 -1460 -2390 {
lab=ctrl_inf}
N -1410 -2270 -1410 -2250 {
lab=vdd_wu}
N -1410 -2420 -1410 -2400 {
lab=vdd_inf}
N -1470 -2240 -1460 -2240 {
lab=ctrl_wu}
N -1460 -2240 -1460 -2210 {
lab=ctrl_wu}
N -1410 -1870 -1410 -1860 {
lab=GND}
N -1360 -1910 -1350 -1910 {
lab=vpres10}
N -1410 -2020 -1410 -2010 {
lab=GND}
N -1470 -2060 -1460 -2060 {
lab=vpre10}
N -1360 -2060 -1350 -2060 {
lab=vpres10}
N -1470 -1880 -1460 -1880 {
lab=vb_wu}
N -1470 -2090 -1460 -2090 {
lab=ctrl_inf}
N -1410 -1970 -1410 -1950 {
lab=vdd_wu}
N -1410 -2120 -1410 -2100 {
lab=vdd_inf}
N -1470 -1940 -1460 -1940 {
lab=ctrl_wu}
N -1460 -1940 -1460 -1910 {
lab=ctrl_wu}
N -1410 -1570 -1410 -1560 {
lab=GND}
N -1360 -1610 -1350 -1610 {
lab=vpres11}
N -1410 -1720 -1410 -1710 {
lab=GND}
N -1470 -1760 -1460 -1760 {
lab=vpre11}
N -1360 -1760 -1350 -1760 {
lab=vpres11}
N -1470 -1580 -1460 -1580 {
lab=vb_wu}
N -1470 -1790 -1460 -1790 {
lab=ctrl_inf}
N -1410 -1670 -1410 -1650 {
lab=vdd_wu}
N -1410 -1820 -1410 -1800 {
lab=vdd_inf}
N -1470 -1640 -1460 -1640 {
lab=ctrl_wu}
N -1460 -1640 -1460 -1610 {
lab=ctrl_wu}
N -1410 -1270 -1410 -1260 {
lab=GND}
N -1360 -1310 -1350 -1310 {
lab=vpres12}
N -1410 -1420 -1410 -1410 {
lab=GND}
N -1470 -1460 -1460 -1460 {
lab=vpre12}
N -1360 -1460 -1350 -1460 {
lab=vpres12}
N -1470 -1280 -1460 -1280 {
lab=vb_wu}
N -1470 -1490 -1460 -1490 {
lab=ctrl_inf}
N -1410 -1370 -1410 -1350 {
lab=vdd_wu}
N -1410 -1520 -1410 -1500 {
lab=vdd_inf}
N -1470 -1340 -1460 -1340 {
lab=ctrl_wu}
N -1460 -1340 -1460 -1310 {
lab=ctrl_wu}
N -1410 -970 -1410 -960 {
lab=GND}
N -1360 -1010 -1350 -1010 {
lab=vpres13}
N -1410 -1120 -1410 -1110 {
lab=GND}
N -1470 -1160 -1460 -1160 {
lab=vpre13}
N -1360 -1160 -1350 -1160 {
lab=vpres13}
N -1470 -980 -1460 -980 {
lab=vb_wu}
N -1470 -1190 -1460 -1190 {
lab=ctrl_inf}
N -1410 -1070 -1410 -1050 {
lab=vdd_wu}
N -1410 -1220 -1410 -1200 {
lab=vdd_inf}
N -1470 -1040 -1460 -1040 {
lab=ctrl_wu}
N -1460 -1040 -1460 -1010 {
lab=ctrl_wu}
N -1410 -670 -1410 -660 {
lab=GND}
N -1360 -710 -1350 -710 {
lab=vpres14}
N -1410 -820 -1410 -810 {
lab=GND}
N -1470 -860 -1460 -860 {
lab=vpre14}
N -1470 -680 -1460 -680 {
lab=vb_wu}
N -1470 -890 -1460 -890 {
lab=ctrl_inf}
N -1410 -770 -1410 -750 {
lab=vdd_wu}
N -1410 -920 -1410 -900 {
lab=vdd_inf}
N -1470 -740 -1460 -740 {
lab=ctrl_wu}
N -1460 -740 -1460 -710 {
lab=ctrl_wu}
N -1410 -370 -1410 -360 {
lab=GND}
N -1360 -410 -1350 -410 {
lab=vpres15}
N -1410 -520 -1410 -510 {
lab=GND}
N -1470 -380 -1460 -380 {
lab=vb_wu}
N -1470 -590 -1460 -590 {
lab=ctrl_inf}
N -1410 -470 -1410 -450 {
lab=vdd_wu}
N -1410 -620 -1410 -600 {
lab=vdd_inf}
N -1470 -440 -1460 -440 {
lab=ctrl_wu}
N -1460 -440 -1460 -410 {
lab=ctrl_wu}
N -1470 -4760 -1460 -4760 {
lab=vpre1}
N -1470 -4460 -1460 -4460 {
lab=vpre2}
N -1470 -560 -1460 -560 {
lab=vpre15}
N -1360 -560 -1350 -560 {
lab=vpres15}
N -1170 -560 -1160 -560 {
lab=vpres15}
N -1170 -860 -1160 -860 {
lab=vpres14}
N -1040 -860 -1030 -860 {
lab=b_px}
N -1360 -860 -1350 -860 {
lab=vpres14}
N 440 -2620 440 -2600 {
lab=GND}
N 440 -2700 440 -2680 {
lab=vdd_inf}
N -750 -270 -750 -260 {
lab=#net61}
N -750 -340 -750 -330 {
lab=p6}
N -750 -20 -750 -10 {
lab=N6}
N -820 -160 -820 -140 {
lab=GND}
N -680 -160 -680 -140 {
lab=vdd_pos}
N -820 -260 -820 -250 {
lab=inh6}
N -790 -260 -790 -250 {
lab=vb_pos}
N -710 -260 -710 -250 {
lab=vlky_pos}
N -460 -270 -460 -260 {
lab=#net62}
N -460 -340 -460 -330 {
lab=p8}
N -460 -20 -460 -10 {
lab=N8}
N -530 -160 -530 -140 {
lab=GND}
N -390 -160 -390 -140 {
lab=vdd_pos}
N -530 -260 -530 -250 {
lab=inh8}
N -500 -260 -500 -250 {
lab=vb_pos}
N -420 -260 -420 -250 {
lab=vlky_pos}
N 150 -3170 160 -3170 {
lab=inh6}
N 120 -3180 120 -3170 {
lab=GND}
N 120 -3130 120 -3120 {
lab=inh_d}
N 80 -3170 90 -3170 {
lab=ctrl_vinh}
N 150 -3060 160 -3060 {
lab=inh8}
N 120 -3070 120 -3060 {
lab=GND}
N 120 -3020 120 -3010 {
lab=inh_d}
N 80 -3060 90 -3060 {
lab=ctrl_vinh}
N -810 -4700 -810 -4690 {
lab=GND}
N -810 -4810 -810 -4800 {
lab=vdd_syn6}
N -750 -4620 -740 -4620 {
lab=GND}
N -750 -4590 -750 -4580 {
lab=p6}
N -880 -4760 -870 -4760 {
lab=vpres1}
N -750 -4760 -740 -4760 {
lab=w_px}
N -800 -4620 -790 -4620 {
lab=ctrl_pos}
N -750 -4740 -750 -4720 {
lab=#net63}
N -750 -4660 -750 -4650 {
lab=#net64}
N -520 -4700 -520 -4690 {
lab=GND}
N -520 -4810 -520 -4800 {
lab=vdd_syn8}
N -460 -4620 -450 -4620 {
lab=GND}
N -460 -4590 -460 -4580 {
lab=p8}
N -590 -4760 -580 -4760 {
lab=vpres1}
N -460 -4760 -450 -4760 {
lab=w_px}
N -510 -4620 -500 -4620 {
lab=ctrl_pos}
N -460 -4740 -460 -4720 {
lab=#net65}
N -460 -4660 -460 -4650 {
lab=#net66}
N -810 -4400 -810 -4390 {
lab=GND}
N -810 -4510 -810 -4500 {
lab=vdd_syn6}
N -750 -4320 -740 -4320 {
lab=GND}
N -750 -4290 -750 -4280 {
lab=p6}
N -880 -4460 -870 -4460 {
lab=vpres2}
N -750 -4460 -740 -4460 {
lab=b_px}
N -800 -4320 -790 -4320 {
lab=ctrl_pos}
N -750 -4440 -750 -4420 {
lab=#net67}
N -750 -4360 -750 -4350 {
lab=#net68}
N -520 -4400 -520 -4390 {
lab=GND}
N -520 -4510 -520 -4500 {
lab=vdd_syn8}
N -460 -4320 -450 -4320 {
lab=GND}
N -460 -4290 -460 -4280 {
lab=p8}
N -590 -4460 -580 -4460 {
lab=vpres2}
N -460 -4460 -450 -4460 {
lab=b_px}
N -510 -4320 -500 -4320 {
lab=ctrl_pos}
N -460 -4440 -460 -4420 {
lab=#net69}
N -460 -4360 -460 -4350 {
lab=#net70}
N -810 -4100 -810 -4090 {
lab=GND}
N -810 -4210 -810 -4200 {
lab=vdd_syn6}
N -750 -4020 -740 -4020 {
lab=GND}
N -750 -3990 -750 -3980 {
lab=p6}
N -880 -4160 -870 -4160 {
lab=vpres3}
N -750 -4160 -740 -4160 {
lab=b_px}
N -800 -4020 -790 -4020 {
lab=ctrl_pos}
N -750 -4140 -750 -4120 {
lab=#net71}
N -750 -4060 -750 -4050 {
lab=#net72}
N -520 -4100 -520 -4090 {
lab=GND}
N -520 -4210 -520 -4200 {
lab=vdd_syn8}
N -460 -4020 -450 -4020 {
lab=GND}
N -460 -3990 -460 -3980 {
lab=p8}
N -590 -4160 -580 -4160 {
lab=vpres3}
N -460 -4160 -450 -4160 {
lab=w_px}
N -510 -4020 -500 -4020 {
lab=ctrl_pos}
N -460 -4140 -460 -4120 {
lab=#net73}
N -460 -4060 -460 -4050 {
lab=#net74}
N -810 -3800 -810 -3790 {
lab=GND}
N -810 -3910 -810 -3900 {
lab=vdd_syn6}
N -750 -3720 -740 -3720 {
lab=GND}
N -750 -3690 -750 -3680 {
lab=p6}
N -880 -3860 -870 -3860 {
lab=vpres4}
N -750 -3860 -740 -3860 {
lab=b_px}
N -800 -3720 -790 -3720 {
lab=ctrl_pos}
N -750 -3840 -750 -3820 {
lab=#net75}
N -750 -3760 -750 -3750 {
lab=#net76}
N -520 -3800 -520 -3790 {
lab=GND}
N -520 -3910 -520 -3900 {
lab=vdd_syn8}
N -460 -3720 -450 -3720 {
lab=GND}
N -460 -3690 -460 -3680 {
lab=p8}
N -590 -3860 -580 -3860 {
lab=vpres4}
N -460 -3860 -450 -3860 {
lab=b_px}
N -510 -3720 -500 -3720 {
lab=ctrl_pos}
N -460 -3840 -460 -3820 {
lab=#net77}
N -460 -3760 -460 -3750 {
lab=#net78}
N -810 -3500 -810 -3490 {
lab=GND}
N -810 -3610 -810 -3600 {
lab=vdd_syn6}
N -750 -3420 -740 -3420 {
lab=GND}
N -750 -3390 -750 -3380 {
lab=p6}
N -880 -3560 -870 -3560 {
lab=vpres5}
N -750 -3560 -740 -3560 {
lab=w_px}
N -800 -3420 -790 -3420 {
lab=ctrl_pos}
N -750 -3540 -750 -3520 {
lab=#net79}
N -750 -3460 -750 -3450 {
lab=#net80}
N -520 -3500 -520 -3490 {
lab=GND}
N -520 -3610 -520 -3600 {
lab=vdd_syn8}
N -460 -3420 -450 -3420 {
lab=GND}
N -460 -3390 -460 -3380 {
lab=p8}
N -590 -3560 -580 -3560 {
lab=vpres5}
N -460 -3560 -450 -3560 {
lab=w_px}
N -510 -3420 -500 -3420 {
lab=ctrl_pos}
N -460 -3540 -460 -3520 {
lab=#net81}
N -460 -3460 -460 -3450 {
lab=#net82}
N -810 -3200 -810 -3190 {
lab=GND}
N -810 -3310 -810 -3300 {
lab=vdd_syn6}
N -750 -3120 -740 -3120 {
lab=GND}
N -750 -3090 -750 -3080 {
lab=p6}
N -880 -3260 -870 -3260 {
lab=vpres6}
N -750 -3260 -740 -3260 {
lab=w_px}
N -800 -3120 -790 -3120 {
lab=ctrl_pos}
N -750 -3240 -750 -3220 {
lab=#net83}
N -750 -3160 -750 -3150 {
lab=#net84}
N -520 -3200 -520 -3190 {
lab=GND}
N -520 -3310 -520 -3300 {
lab=vdd_syn8}
N -460 -3120 -450 -3120 {
lab=GND}
N -460 -3090 -460 -3080 {
lab=p8}
N -590 -3260 -580 -3260 {
lab=vpres6}
N -460 -3260 -450 -3260 {
lab=b_px}
N -510 -3120 -500 -3120 {
lab=ctrl_pos}
N -460 -3240 -460 -3220 {
lab=#net85}
N -460 -3160 -460 -3150 {
lab=#net86}
N -810 -2900 -810 -2890 {
lab=GND}
N -810 -3010 -810 -3000 {
lab=vdd_syn6}
N -750 -2820 -740 -2820 {
lab=GND}
N -750 -2790 -750 -2780 {
lab=p6}
N -880 -2960 -870 -2960 {
lab=vpres7}
N -750 -2960 -740 -2960 {
lab=b_px}
N -800 -2820 -790 -2820 {
lab=ctrl_pos}
N -750 -2940 -750 -2920 {
lab=#net87}
N -750 -2860 -750 -2850 {
lab=#net88}
N -520 -2900 -520 -2890 {
lab=GND}
N -520 -3010 -520 -3000 {
lab=vdd_syn8}
N -460 -2820 -450 -2820 {
lab=GND}
N -460 -2790 -460 -2780 {
lab=p8}
N -590 -2960 -580 -2960 {
lab=vpres7}
N -460 -2960 -450 -2960 {
lab=w_px}
N -510 -2820 -500 -2820 {
lab=ctrl_pos}
N -460 -2940 -460 -2920 {
lab=#net89}
N -460 -2860 -460 -2850 {
lab=#net90}
N -810 -2600 -810 -2590 {
lab=GND}
N -810 -2710 -810 -2700 {
lab=vdd_syn6}
N -750 -2520 -740 -2520 {
lab=GND}
N -750 -2490 -750 -2480 {
lab=p6}
N -880 -2660 -870 -2660 {
lab=vpres8}
N -750 -2660 -740 -2660 {
lab=b_px}
N -800 -2520 -790 -2520 {
lab=ctrl_pos}
N -750 -2640 -750 -2620 {
lab=#net91}
N -750 -2560 -750 -2550 {
lab=#net92}
N -520 -2600 -520 -2590 {
lab=GND}
N -520 -2710 -520 -2700 {
lab=vdd_syn8}
N -460 -2520 -450 -2520 {
lab=GND}
N -460 -2490 -460 -2480 {
lab=p8}
N -590 -2660 -580 -2660 {
lab=vpres8}
N -460 -2660 -450 -2660 {
lab=b_px}
N -510 -2520 -500 -2520 {
lab=ctrl_pos}
N -460 -2640 -460 -2620 {
lab=#net93}
N -460 -2560 -460 -2550 {
lab=#net94}
N -810 -2300 -810 -2290 {
lab=GND}
N -810 -2410 -810 -2400 {
lab=vdd_syn6}
N -750 -2220 -740 -2220 {
lab=GND}
N -750 -2190 -750 -2180 {
lab=p6}
N -880 -2360 -870 -2360 {
lab=vpres9}
N -750 -2360 -740 -2360 {
lab=w_px}
N -800 -2220 -790 -2220 {
lab=ctrl_pos}
N -750 -2340 -750 -2320 {
lab=#net95}
N -750 -2260 -750 -2250 {
lab=#net96}
N -520 -2300 -520 -2290 {
lab=GND}
N -520 -2410 -520 -2400 {
lab=vdd_syn8}
N -460 -2220 -450 -2220 {
lab=GND}
N -460 -2190 -460 -2180 {
lab=p8}
N -590 -2360 -580 -2360 {
lab=vpres9}
N -460 -2360 -450 -2360 {
lab=w_px}
N -510 -2220 -500 -2220 {
lab=ctrl_pos}
N -460 -2340 -460 -2320 {
lab=#net97}
N -460 -2260 -460 -2250 {
lab=#net98}
N -810 -2000 -810 -1990 {
lab=GND}
N -810 -2110 -810 -2100 {
lab=vdd_syn6}
N -750 -1920 -740 -1920 {
lab=GND}
N -750 -1890 -750 -1880 {
lab=p6}
N -880 -2060 -870 -2060 {
lab=vpres10}
N -750 -2060 -740 -2060 {
lab=b_px}
N -800 -1920 -790 -1920 {
lab=ctrl_pos}
N -750 -2040 -750 -2020 {
lab=#net99}
N -750 -1960 -750 -1950 {
lab=#net100}
N -520 -2000 -520 -1990 {
lab=GND}
N -520 -2110 -520 -2100 {
lab=vdd_syn8}
N -460 -1920 -450 -1920 {
lab=GND}
N -460 -1890 -460 -1880 {
lab=p8}
N -590 -2060 -580 -2060 {
lab=vpres10}
N -460 -2060 -450 -2060 {
lab=b_px}
N -510 -1920 -500 -1920 {
lab=ctrl_pos}
N -460 -2040 -460 -2020 {
lab=#net101}
N -460 -1960 -460 -1950 {
lab=#net102}
N -810 -1700 -810 -1690 {
lab=GND}
N -810 -1810 -810 -1800 {
lab=vdd_syn6}
N -750 -1620 -740 -1620 {
lab=GND}
N -750 -1590 -750 -1580 {
lab=p6}
N -880 -1760 -870 -1760 {
lab=vpres11}
N -750 -1760 -740 -1760 {
lab=w_px}
N -800 -1620 -790 -1620 {
lab=ctrl_pos}
N -750 -1740 -750 -1720 {
lab=#net103}
N -750 -1660 -750 -1650 {
lab=#net104}
N -520 -1700 -520 -1690 {
lab=GND}
N -520 -1810 -520 -1800 {
lab=vdd_syn8}
N -460 -1620 -450 -1620 {
lab=GND}
N -460 -1590 -460 -1580 {
lab=p8}
N -590 -1760 -580 -1760 {
lab=vpres11}
N -460 -1760 -450 -1760 {
lab=w_px}
N -510 -1620 -500 -1620 {
lab=ctrl_pos}
N -460 -1740 -460 -1720 {
lab=#net105}
N -460 -1660 -460 -1650 {
lab=#net106}
N -810 -1400 -810 -1390 {
lab=GND}
N -810 -1510 -810 -1500 {
lab=vdd_syn6}
N -750 -1320 -740 -1320 {
lab=GND}
N -750 -1290 -750 -1280 {
lab=p6}
N -880 -1460 -870 -1460 {
lab=vpres12}
N -750 -1460 -740 -1460 {
lab=b_px}
N -800 -1320 -790 -1320 {
lab=ctrl_pos}
N -750 -1440 -750 -1420 {
lab=#net107}
N -750 -1360 -750 -1350 {
lab=#net108}
N -520 -1400 -520 -1390 {
lab=GND}
N -520 -1510 -520 -1500 {
lab=vdd_syn8}
N -460 -1320 -450 -1320 {
lab=GND}
N -460 -1290 -460 -1280 {
lab=p8}
N -590 -1460 -580 -1460 {
lab=vpres12}
N -460 -1460 -450 -1460 {
lab=b_px}
N -510 -1320 -500 -1320 {
lab=ctrl_pos}
N -460 -1440 -460 -1420 {
lab=#net109}
N -460 -1360 -460 -1350 {
lab=#net110}
N -810 -1100 -810 -1090 {
lab=GND}
N -810 -1210 -810 -1200 {
lab=vdd_syn6}
N -750 -1020 -740 -1020 {
lab=GND}
N -750 -990 -750 -980 {
lab=p6}
N -880 -1160 -870 -1160 {
lab=vpres13}
N -750 -1160 -740 -1160 {
lab=w_px}
N -800 -1020 -790 -1020 {
lab=ctrl_pos}
N -750 -1140 -750 -1120 {
lab=#net111}
N -750 -1060 -750 -1050 {
lab=#net112}
N -520 -1100 -520 -1090 {
lab=GND}
N -520 -1210 -520 -1200 {
lab=vdd_syn8}
N -460 -1020 -450 -1020 {
lab=GND}
N -460 -990 -460 -980 {
lab=p8}
N -590 -1160 -580 -1160 {
lab=vpres13}
N -460 -1160 -450 -1160 {
lab=w_px}
N -510 -1020 -500 -1020 {
lab=ctrl_pos}
N -460 -1140 -460 -1120 {
lab=#net113}
N -460 -1060 -460 -1050 {
lab=#net114}
N -810 -800 -810 -790 {
lab=GND}
N -810 -910 -810 -900 {
lab=vdd_syn6}
N -750 -720 -740 -720 {
lab=GND}
N -750 -690 -750 -680 {
lab=p6}
N -880 -860 -870 -860 {
lab=vpres14}
N -750 -860 -740 -860 {
lab=b_px}
N -800 -720 -790 -720 {
lab=ctrl_pos}
N -750 -840 -750 -820 {
lab=#net115}
N -750 -760 -750 -750 {
lab=#net116}
N -520 -800 -520 -790 {
lab=GND}
N -520 -910 -520 -900 {
lab=vdd_syn8}
N -460 -720 -450 -720 {
lab=GND}
N -460 -690 -460 -680 {
lab=p8}
N -590 -860 -580 -860 {
lab=vpres14}
N -460 -860 -450 -860 {
lab=b_px}
N -510 -720 -500 -720 {
lab=ctrl_pos}
N -460 -840 -460 -820 {
lab=#net117}
N -460 -760 -460 -750 {
lab=#net118}
N -810 -500 -810 -490 {
lab=GND}
N -810 -610 -810 -600 {
lab=vdd_syn6}
N -750 -420 -740 -420 {
lab=GND}
N -750 -390 -750 -380 {
lab=p6}
N -880 -560 -870 -560 {
lab=vpres15}
N -750 -560 -740 -560 {
lab=w_px}
N -800 -420 -790 -420 {
lab=ctrl_pos}
N -750 -540 -750 -520 {
lab=#net119}
N -750 -460 -750 -450 {
lab=#net120}
N -520 -500 -520 -490 {
lab=GND}
N -520 -610 -520 -600 {
lab=vdd_syn8}
N -460 -420 -450 -420 {
lab=GND}
N -460 -390 -460 -380 {
lab=p8}
N -590 -560 -580 -560 {
lab=vpres15}
N -460 -560 -450 -560 {
lab=w_px}
N -510 -420 -500 -420 {
lab=ctrl_pos}
N -460 -540 -460 -520 {
lab=#net121}
N -460 -460 -460 -450 {
lab=#net122}
N 30 -4380 40 -4380 {
lab=N6}
N 30 -4400 40 -4400 {
lab=N8}
N 30 -4420 40 -4420 {
lab=GND}
N 30 -4440 40 -4440 {
lab=GND}
N 30 -4460 40 -4460 {
lab=GND}
N 30 -4480 40 -4480 {
lab=GND}
N 30 -4500 40 -4500 {
lab=GND}
N 30 -4520 40 -4520 {
lab=GND}
N 30 -4540 40 -4540 {
lab=GND}
N 620 -2760 620 -2740 {
lab=GND}
N 620 -2840 620 -2820 {
lab=vdd_syn6}
N 820 -2760 820 -2740 {
lab=GND}
N 820 -2840 820 -2820 {
lab=vdd_syn8}
N 700 -2620 700 -2600 {
lab=GND}
N 700 -2700 700 -2680 {
lab=b_px}
N 620 -2620 620 -2600 {
lab=GND}
N 620 -2700 620 -2680 {
lab=w_px}
N -1040 -270 -1040 -260 {
lab=#net123}
N -1040 -340 -1040 -330 {
lab=p0}
N -1040 -20 -1040 -10 {
lab=N0}
N -1110 -160 -1110 -140 {
lab=GND}
N -970 -160 -970 -140 {
lab=vdd_pos}
N -1110 -260 -1110 -250 {
lab=inh0}
N -1080 -260 -1080 -250 {
lab=vb_pos}
N -1000 -260 -1000 -250 {
lab=vlky_pos}
N 150 -4180 160 -4180 {
lab=inh0}
N 120 -4190 120 -4180 {
lab=GND}
N 120 -4140 120 -4130 {
lab=inh_d}
N 80 -4180 90 -4180 {
lab=ctrl_vinh}
N 270 -2560 270 -2540 {
lab=vb_tr}
N 270 -2480 270 -2460 {
lab=GND}
N 100 -2420 100 -2400 {
lab=ctrl_tr}
N 100 -2340 100 -2320 {
lab=GND}
N 30 -4540 30 -4520 {
lab=GND}
N 30 -4520 30 -4500 {
lab=GND}
N 30 -4500 30 -4480 {
lab=GND}
N 30 -4480 30 -4460 {
lab=GND}
N 30 -4460 30 -4420 {
lab=GND}
N 420 -2480 420 -2460 {
lab=GND}
N 420 -2560 420 -2540 {
lab=vlky_pos}
N 420 -2340 420 -2320 {
lab=GND}
N 420 -2420 420 -2400 {
lab=ctrl_newp}
N 20 -4340 40 -4340 {
lab=ctrl_newp}
C {devices/vsource.sym} 20 -2650 0 0 {name=V1 value=1.8}
C {devices/gnd.sym} 20 -2600 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 100 -2650 0 0 {name=V2 value=1.8}
C {devices/gnd.sym} 100 -2600 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 100 -2700 2 0 {name=p9 sig_type=std_logic lab=vdd_pre}
C {devices/gnd.sym} -1780 -4370 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} -1880 -4420 0 0 {name=p13 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -4410 0 0 {name=I2 value="PWL(0 0 44.99u 0 45u 4u)"
*"PWL(0 0 99.9u 0 100u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u)"}
C {devices/gnd.sym} -2160 -4360 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -4510 0 0 {name=M173
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -4510 0 1 {name=M172
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/corner.sym} 110 -2120 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/code.sym} -10 -2120 0 0 {name=MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice
"
spice_ignore=false}
C {devices/code_shown.sym} 600 -2530 0 0 {name=NGSPICE1
only_toplevel=true
value="
.option set_threads = 16
.option klu
*--Current Injection--*
.param L_in=0.15
.param W_in=1
*--Memristor Output--*
.param L_out=0.15
.param W_out=1.5
*--Memristor synapse--*
.param L_pre=0.45
.param W_pre=0.45
.param L_pos=0.15
.param W_pos=15
.param L_mem_in=0.15
.param W_mem_in=30
.param L_mem_out=0.4
.param W_mem_out=0.45
*--WTA circuit--*
.param Wp_or=1
.param Lp_or=0.15
.param Wn_or=1
.param Ln_or=0.15
.param Wp_or_inv=1
.param Lp_or_inv=0.15
.param Wn_or_inv=1
.param Ln_or_inv=0.15
.control
	save all
	*--weight update and pre-training--*
	tran 10n 205u 0
	write SNN_15x3_InfStage_3p_tb.raw
	*--weight update and pre-training--*
	*tran 10n 95u 0
	*write SNN_15x3_InfStage_068_tb.raw
	*--weight update and pre-training--*
	*tran 100n 50u 0
	*write SNN_15x10_InfStage_tb.raw
	*wrdata SNN_15x1_lt_tb.ssv v(8)
.endc
" }
C {devices/launcher.sym} 90 -1945 0 0 {name=h1
descr="weight update and pre-training"
tclcommand="xschem raw_read $netlist_dir/SNN_15x10_InfStage_tb.raw tran"
}
C {devices/lab_pin.sym} -1960 -4460 0 0 {name=p10 sig_type=std_logic lab=vc2}
C {devices/gnd.sym} -1100 -4690 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} -1170 -4760 0 0 {name=p26 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -1040 -4690 0 0 {name=Vmeas10 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -4620 0 0 {name=M10
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -4620 3 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -1040 -4580 2 0 {name=p46 sig_type=std_logic lab=p0}
C {devices/vsource.sym} 20 -2230 0 0 {name=V13 value="PWL(0 1.8 4.9u 1.8 5u 0)"}
C {devices/gnd.sym} 20 -2180 0 0 {name=l67 lab=GND}
C {devices/lab_pin.sym} 20 -2280 2 0 {name=p65 sig_type=std_logic lab=uw}
C {devices/vsource.sym} 200 -2230 0 0 {name=V14 value="PWL(0 0 9.9u 0 10u 1.8 39.9u 1.8 40u 0)"}
C {devices/gnd.sym} 200 -2180 0 0 {name=l68 lab=GND}
C {devices/lab_pin.sym} 200 -2280 2 0 {name=p66 sig_type=std_logic lab=training}
C {devices/vsource.sym} 460 -2230 0 0 {name=V15 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 460 -2180 0 0 {name=l69 lab=GND}
C {devices/lab_pin.sym} 460 -2280 2 0 {name=p73 sig_type=std_logic lab=inference}
C {devices/ammeter.sym} -2130 -4460 1 0 {name=Vmeas202 savecurrent=true}
C {devices/vsource.sym} 20 -2370 0 0 {name=V11 value="PWL(0 1.8 4.9u 1.8 5u 0)"}
C {devices/gnd.sym} 20 -2320 0 0 {name=l72 lab=GND}
C {devices/lab_pin.sym} 20 -2420 2 0 {name=p75 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 190 -2510 0 0 {name=V9 value=0.5}
C {devices/gnd.sym} 190 -2460 0 0 {name=l75 lab=GND}
C {devices/lab_pin.sym} 190 -2560 2 0 {name=p82 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 190 -2650 0 0 {name=V3 value=1.8}
C {devices/gnd.sym} 190 -2600 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 190 -2700 2 0 {name=p6 sig_type=std_logic lab=vdd_pos}
C {devices/vsource.sym} 280 -2650 0 0 {name=V5 value=1.8
*"PWL(0 1.8 34.9u 1.8 35u 0)"}
C {devices/gnd.sym} 280 -2600 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 280 -2700 2 0 {name=p1 sig_type=std_logic lab=vdd_wu}
C {devices/vsource.sym} 360 -2650 0 0 {name=V6 value=1.8}
C {devices/gnd.sym} 360 -2600 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 360 -2700 2 0 {name=p3 sig_type=std_logic lab=vdd_tr}
C {devices/vsource.sym} 110 -2510 0 0 {name=V7 value=0.5}
C {devices/gnd.sym} 110 -2460 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 110 -2560 2 0 {name=p8 sig_type=std_logic lab=vb_pre}
C {devices/vsource.sym} 340 -2510 0 0 {name=V8 value=0.6}
C {devices/gnd.sym} 340 -2460 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 340 -2560 2 0 {name=p11 sig_type=std_logic lab=vb_pos}
C {devices/lab_pin.sym} -1780 -4550 2 0 {name=p4 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} 20 -2700 2 0 {name=p21 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -2020 -4540 1 0 {name=p40 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -4670 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} -1880 -4720 0 0 {name=p23 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -4710 0 0 {name=I1 value=0
*"PWL(0 0 109.9u 0 110u 5u 129.9u 5u 130u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -2160 -4660 0 0 {name=l14 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -4810 0 0 {name=M171
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -4810 0 1 {name=M170
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -4760 0 0 {name=p25 sig_type=std_logic lab=vc1}
C {devices/gnd.sym} -1100 -4390 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} -1170 -4460 0 0 {name=p29 sig_type=std_logic lab=vpres2}
C {devices/ammeter.sym} -1040 -4390 0 0 {name=Vmeas20 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -4320 0 0 {name=M20
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -4320 3 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} -1040 -4280 2 0 {name=p34 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1350 -4610 2 0 {name=p35 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1630 -4760 2 0 {name=p37 sig_type=std_logic lab=vpre1}
C {devices/ammeter.sym} -2130 -4760 1 0 {name=Vmeas201 savecurrent=true}
C {devices/gnd.sym} -1410 -4560 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -1350 -4760 2 0 {name=p39 sig_type=std_logic lab=vpres1}
C {devices/lab_pin.sym} -1470 -4760 0 0 {name=p41 sig_type=std_logic lab=vpre1}
C {devices/lab_pin.sym} -1470 -4790 0 0 {name=p42 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -4710 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} -1780 -4850 2 0 {name=p43 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -1410 -4670 0 0 {name=p47 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -4820 0 0 {name=p48 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -2020 -4840 1 0 {name=p50 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1090 -4320 0 0 {name=p76 sig_type=std_logic lab=ctrl_pos}
C {devices/lab_pin.sym} -1090 -4620 0 0 {name=p78 sig_type=std_logic lab=ctrl_pos}
C {devices/vsource.sym} 170 -2370 0 0 {name=V16 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 170 -2320 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 170 -2420 2 0 {name=p71 sig_type=std_logic lab=ctrl_inf}
C {devices/vsource.sym} 520 -2650 0 0 {name=V17 value=1.8}
C {devices/gnd.sym} 520 -2600 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 520 -2700 2 0 {name=p80 sig_type=std_logic lab=vdd_inh}
C {devices/gnd.sym} 120 -4290 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 120 -4590 2 0 {name=p81 sig_type=std_logic lab=vdd_inh}
C {devices/vsource.sym} 330 -2370 0 0 {name=V18 value=1.8}
C {devices/gnd.sym} 330 -2320 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} 330 -2420 2 0 {name=p88 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 310 -4440 2 0 {name=p91 sig_type=std_logic lab=inh_d}
C {devices/vsource.sym} 20 -2510 0 0 {name=V19 value=0.55}
C {devices/gnd.sym} 20 -2460 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 20 -2560 2 0 {name=p95 sig_type=std_logic lab=vlky_pre}
C {devices/vsource.sym} 20 -2790 0 0 {name=V10 value=1.8
*"PWL(0 1.8 119.9u 1.8 120u 0 124.9u 0 125u 1.8)"}
C {devices/gnd.sym} 20 -2740 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 20 -2840 2 0 {name=p7 sig_type=std_logic lab=vdd_syn0}
C {devices/gnd.sym} -1100 -4090 0 0 {name=l105 lab=GND}
C {devices/ammeter.sym} -1040 -4090 0 0 {name=Vmeas30 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -4020 0 0 {name=M30
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -4020 3 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -1040 -3980 2 0 {name=p313 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -4020 0 0 {name=p315 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -3790 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} -1170 -3860 0 0 {name=p361 sig_type=std_logic lab=vpres4}
C {devices/ammeter.sym} -1040 -3790 0 0 {name=Vmeas40 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -3720 0 0 {name=M40
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -3720 3 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -1040 -3680 2 0 {name=p363 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -3720 0 0 {name=p365 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -3490 0 0 {name=l145 lab=GND}
C {devices/lab_pin.sym} -1170 -3560 0 0 {name=p411 sig_type=std_logic lab=vpres5}
C {devices/ammeter.sym} -1040 -3490 0 0 {name=Vmeas50 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -3420 0 0 {name=M50
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -3420 3 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} -1040 -3380 2 0 {name=p413 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -3420 0 0 {name=p415 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -3190 0 0 {name=l165 lab=GND}
C {devices/ammeter.sym} -1040 -3190 0 0 {name=Vmeas60 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -3120 0 0 {name=M60
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -3120 3 0 {name=l166 lab=GND}
C {devices/lab_pin.sym} -1040 -3080 2 0 {name=p463 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -3120 0 0 {name=p465 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -2890 0 0 {name=l185 lab=GND}
C {devices/ammeter.sym} -1040 -2890 0 0 {name=Vmeas70 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -2820 0 0 {name=M70
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -2820 3 0 {name=l186 lab=GND}
C {devices/lab_pin.sym} -1040 -2780 2 0 {name=p513 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -2820 0 0 {name=p515 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -2590 0 0 {name=l205 lab=GND}
C {devices/ammeter.sym} -1040 -2590 0 0 {name=Vmeas80 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -2520 0 0 {name=M80
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -2520 3 0 {name=l206 lab=GND}
C {devices/lab_pin.sym} -1040 -2480 2 0 {name=p563 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -2520 0 0 {name=p565 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -2290 0 0 {name=l225 lab=GND}
C {devices/lab_pin.sym} -1170 -2360 0 0 {name=p611 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -1040 -2290 0 0 {name=Vmeas90 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -2220 0 0 {name=M90
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -2220 3 0 {name=l226 lab=GND}
C {devices/lab_pin.sym} -1040 -2180 2 0 {name=p613 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -2220 0 0 {name=p615 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1780 -3770 0 0 {name=l245 lab=GND}
C {devices/lab_pin.sym} -1880 -3820 0 0 {name=p661 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -3810 0 0 {name=I4 value="PWL(0 0 44.99u 0 45u 4u)"
*"PWL(0 0 99.9u 0 100u 5u 109.9u 5u 110u 0 119.9u 0 120u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -2160 -3760 0 0 {name=l246 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -3910 0 0 {name=M177
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -3910 0 1 {name=M176
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -3860 0 0 {name=p662 sig_type=std_logic lab=vc4}
C {devices/ammeter.sym} -2130 -3860 1 0 {name=Vmeas204 savecurrent=true}
C {devices/lab_pin.sym} -1780 -3950 2 0 {name=p664 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -3940 1 0 {name=p665 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -4070 0 0 {name=l247 lab=GND}
C {devices/lab_pin.sym} -1880 -4120 0 0 {name=p666 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -4110 0 0 {name=I3 value="PWL(0 0 99.99u 0 100u 4u 149.99u 4u 150u 0)"
*"PWL(0 0 119.9u 0 120u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -2160 -4060 0 0 {name=l248 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -4210 0 0 {name=M175
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -4210 0 1 {name=M174
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -4160 0 0 {name=p667 sig_type=std_logic lab=vc3}
C {devices/ammeter.sym} -2130 -4160 1 0 {name=Vmeas203 savecurrent=true}
C {devices/lab_pin.sym} -1780 -4250 2 0 {name=p669 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -4240 1 0 {name=p670 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -3170 0 0 {name=l249 lab=GND}
C {devices/lab_pin.sym} -1880 -3220 0 0 {name=p673 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -3210 0 0 {name=I6 value="PWL(0 0 44.99u 0 45u 4u 99.99u 4u 100u 0 149.99u 0 150u 4u)"}
C {devices/gnd.sym} -2160 -3160 0 0 {name=l250 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -3310 0 0 {name=M181
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -3310 0 1 {name=M180
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -3260 0 0 {name=p674 sig_type=std_logic lab=vc6}
C {devices/ammeter.sym} -2130 -3260 1 0 {name=Vmeas206 savecurrent=true}
C {devices/lab_pin.sym} -1780 -3350 2 0 {name=p676 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -3340 1 0 {name=p677 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -3470 0 0 {name=l251 lab=GND}
C {devices/lab_pin.sym} -1880 -3520 0 0 {name=p678 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -3510 0 0 {name=I5 value=0
*"PWL(0 0 104.9u 0 105u 5u 109.9u 5u 110u 0)"}
C {devices/gnd.sym} -2160 -3460 0 0 {name=l252 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -3610 0 0 {name=M179
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -3610 0 1 {name=M178
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -3560 0 0 {name=p679 sig_type=std_logic lab=vc5}
C {devices/ammeter.sym} -2130 -3560 1 0 {name=Vmeas205 savecurrent=true}
C {devices/lab_pin.sym} -1780 -3650 2 0 {name=p681 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -3640 1 0 {name=p682 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -2570 0 0 {name=l253 lab=GND}
C {devices/lab_pin.sym} -1880 -2620 0 0 {name=p685 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -2610 0 0 {name=I8 value="PWL(0 0 99.99u 0 100u 4u)"
*"PWL(0 0 104.9u 0 105u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -2160 -2560 0 0 {name=l254 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -2710 0 0 {name=M185
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -2710 0 1 {name=M184
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -2660 0 0 {name=p686 sig_type=std_logic lab=vc8}
C {devices/ammeter.sym} -2130 -2660 1 0 {name=Vmeas208 savecurrent=true}
C {devices/lab_pin.sym} -1780 -2750 2 0 {name=p688 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -2740 1 0 {name=p689 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -2870 0 0 {name=l255 lab=GND}
C {devices/lab_pin.sym} -1880 -2920 0 0 {name=p690 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -2910 0 0 {name=I7 value="PWL(0 0 44.99u 0 45u 4u 149.99u 4u 150u 0)"}
C {devices/gnd.sym} -2160 -2860 0 0 {name=l256 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -3010 0 0 {name=M183
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -3010 0 1 {name=M182
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -2960 0 0 {name=p691 sig_type=std_logic lab=vc7}
C {devices/ammeter.sym} -2130 -2960 1 0 {name=Vmeas207 savecurrent=true}
C {devices/lab_pin.sym} -1780 -3050 2 0 {name=p693 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -3040 1 0 {name=p694 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -2270 0 0 {name=l257 lab=GND}
C {devices/lab_pin.sym} -1880 -2320 0 0 {name=p697 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -2310 0 0 {name=I9 value="PWL(0 0 44.99u 0 45u 4u 99.99u 4u 100u 0)"
*"PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 119.9u 0 120u 5u 124.9u 5u 125u 0 134.9u 0 135u 5u 139.9u 5u 140u 0 144.9u 0 145u 5u)"}
C {devices/gnd.sym} -2160 -2260 0 0 {name=l258 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -2410 0 0 {name=M187
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -2410 0 1 {name=M186
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -2360 0 0 {name=p698 sig_type=std_logic lab=vc9}
C {devices/ammeter.sym} -2130 -2360 1 0 {name=Vmeas209 savecurrent=true}
C {devices/lab_pin.sym} -1780 -2450 2 0 {name=p700 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -2440 1 0 {name=p701 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1630 -4460 2 0 {name=p5 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -1630 -4160 2 0 {name=p106 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1170 -4160 0 0 {name=p108 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1630 -2360 2 0 {name=p110 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1170 -2660 0 0 {name=p115 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1630 -2660 2 0 {name=p117 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1170 -2960 0 0 {name=p119 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1630 -2960 2 0 {name=p120 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1170 -3260 0 0 {name=p123 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1630 -3260 2 0 {name=p124 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -1630 -3560 2 0 {name=p128 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -1630 -3860 2 0 {name=p130 sig_type=std_logic lab=vpre4}
C {devices/launcher.sym} 90 -1975 0 0 {name=h2
descr="no lag" 
tclcommand="xschem raw_read $netlist_dir/SNN_2x2_tb.raw tran"
}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -2360 0 0 {name=x2090}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -2660 0 0 {name=x2080}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -2960 0 0 {name=x2070}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -3260 0 0 {name=x2060}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -3560 0 0 {name=x2050}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -3860 0 0 {name=x2040}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -4160 0 0 {name=x2030}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -4460 0 0 {name=x2020}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -4760 0 0 {name=x2010}
C {devices/gnd.sym} -1100 -1990 0 0 {name=l58 lab=GND}
C {devices/ammeter.sym} -1040 -1990 0 0 {name=Vmeas100 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -1920 0 0 {name=M100
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -1920 3 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} -1040 -1880 2 0 {name=p217 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -1920 0 0 {name=p219 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -1690 0 0 {name=l62 lab=GND}
C {devices/ammeter.sym} -1040 -1690 0 0 {name=Vmeas110 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -1620 0 0 {name=M110
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -1620 3 0 {name=l64 lab=GND}
C {devices/lab_pin.sym} -1040 -1580 2 0 {name=p223 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -1620 0 0 {name=p225 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -1390 0 0 {name=l70 lab=GND}
C {devices/ammeter.sym} -1040 -1390 0 0 {name=Vmeas120 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -1320 0 0 {name=M120
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -1320 3 0 {name=l71 lab=GND}
C {devices/lab_pin.sym} -1040 -1280 2 0 {name=p233 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -1320 0 0 {name=p252 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -1090 0 0 {name=l76 lab=GND}
C {devices/ammeter.sym} -1040 -1090 0 0 {name=Vmeas130 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -1020 0 0 {name=M130
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -1020 3 0 {name=l77 lab=GND}
C {devices/lab_pin.sym} -1040 -980 2 0 {name=p264 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -1020 0 0 {name=p276 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -790 0 0 {name=l80 lab=GND}
C {devices/ammeter.sym} -1040 -790 0 0 {name=Vmeas140 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -720 0 0 {name=M140
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -720 3 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} -1040 -680 2 0 {name=p293 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -720 0 0 {name=p304 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1100 -490 0 0 {name=l109 lab=GND}
C {devices/ammeter.sym} -1040 -490 0 0 {name=Vmeas150 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -1060 -420 0 0 {name=M150
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -1030 -420 3 0 {name=l110 lab=GND}
C {devices/lab_pin.sym} -1040 -380 2 0 {name=p317 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1090 -420 0 0 {name=p321 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1780 -1970 0 0 {name=l113 lab=GND}
C {devices/lab_pin.sym} -1880 -2020 0 0 {name=p324 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -2010 0 0 {name=I10 value="PWL(0 0 44.99u 0 45u 4u)"
*"PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 109.9u 0 110u 5u 114.9u 5u 115u 0 129.9u 0 130u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u 144.9u 5u 145u 0)"}
C {devices/gnd.sym} -2160 -1960 0 0 {name=l114 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -2110 0 0 {name=M189
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -2110 0 1 {name=M188
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -2060 0 0 {name=p325 sig_type=std_logic lab=vc10}
C {devices/ammeter.sym} -2130 -2060 1 0 {name=Vmeas210 savecurrent=true}
C {devices/lab_pin.sym} -1780 -2150 2 0 {name=p326 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -2140 1 0 {name=p327 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -1370 0 0 {name=l115 lab=GND}
C {devices/lab_pin.sym} -1880 -1420 0 0 {name=p329 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -1410 0 0 {name=I12 value="PWL(0 0 44.99u 0 45u 4u)"
*"PWL(0 0 99.9u 0 100u 5u 104.9u 5u 105u 0 114.9u 0 115u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u)"}
C {devices/gnd.sym} -2160 -1360 0 0 {name=l116 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -1510 0 0 {name=M193
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -1510 0 1 {name=M192
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -1460 0 0 {name=p330 sig_type=std_logic lab=vc12}
C {devices/ammeter.sym} -2130 -1460 1 0 {name=Vmeas212 savecurrent=true}
C {devices/lab_pin.sym} -1780 -1550 2 0 {name=p331 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -1540 1 0 {name=p332 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -1670 0 0 {name=l117 lab=GND}
C {devices/lab_pin.sym} -1880 -1720 0 0 {name=p333 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -1710 0 0 {name=I11 value=0
*"PWL(0 0 104.9u 0 105u 5u 109.9u 5u 110u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -2160 -1660 0 0 {name=l118 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -1810 0 0 {name=M191
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -1810 0 1 {name=M190
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -1760 0 0 {name=p334 sig_type=std_logic lab=vc11}
C {devices/ammeter.sym} -2130 -1760 1 0 {name=Vmeas211 savecurrent=true}
C {devices/lab_pin.sym} -1780 -1850 2 0 {name=p335 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -1840 1 0 {name=p336 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -770 0 0 {name=l119 lab=GND}
C {devices/lab_pin.sym} -1880 -820 0 0 {name=p339 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -810 0 0 {name=I14 value="PWL(0 0 44.99u 0 45u 4u)"
*"PWL(0 0 99.9u 0 100u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u 134.9u 5u 135u 0 139.9u 0 140u 5u 144.9u 5u 145u 0)"}
C {devices/gnd.sym} -2160 -760 0 0 {name=l120 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -910 0 0 {name=M197
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -910 0 1 {name=M196
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -860 0 0 {name=p340 sig_type=std_logic lab=vc14}
C {devices/ammeter.sym} -2130 -860 1 0 {name=Vmeas214 savecurrent=true}
C {devices/lab_pin.sym} -1780 -950 2 0 {name=p341 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -940 1 0 {name=p342 sig_type=std_logic lab=vdd_in}
C {devices/gnd.sym} -1780 -1070 0 0 {name=l121 lab=GND}
C {devices/lab_pin.sym} -1880 -1120 0 0 {name=p343 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -1110 0 0 {name=I13 value=0
*"PWL(0 0 104.9u 0 105u 5u 119.9u 5u 120u 0 124.9u 0 125u 5u 129.9u 5u 130u 0 134.9u 0 135u 5u 139.9u 5u 140u 0)"}
C {devices/gnd.sym} -2160 -1060 0 0 {name=l122 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -1210 0 0 {name=M195
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -1210 0 1 {name=M194
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -1160 0 0 {name=p344 sig_type=std_logic lab=vc13}
C {devices/ammeter.sym} -2130 -1160 1 0 {name=Vmeas213 savecurrent=true}
C {devices/lab_pin.sym} -1780 -1250 2 0 {name=p345 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -1240 1 0 {name=p346 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1880 -900 1 0 {name=p348 sig_type=std_logic lab=vlky_pre}
C {devices/gnd.sym} -1780 -470 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} -1880 -520 0 0 {name=p349 sig_type=std_logic lab=vb_pre}
C {devices/isource.sym} -2160 -510 0 0 {name=I15 value=0
*"PWL(0 0 104.9u 0 105u 5u 114.9u 5u 115u 0 119.9u 0 120u 5u 124.9u 5u 125u 0 144.9u 0 145u 5u)"}
C {devices/gnd.sym} -2160 -460 0 0 {name=l124 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -1980 -610 0 0 {name=M199
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -2060 -610 0 1 {name=M198
L=\{L_in\}
W=\{W_in\}
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -1960 -560 0 0 {name=p350 sig_type=std_logic lab=vc15}
C {devices/ammeter.sym} -2130 -560 1 0 {name=Vmeas215 savecurrent=true}
C {devices/lab_pin.sym} -1780 -650 2 0 {name=p351 sig_type=std_logic lab=vdd_pre}
C {devices/lab_pin.sym} -2020 -640 1 0 {name=p352 sig_type=std_logic lab=vdd_in}
C {devices/lab_pin.sym} -1630 -560 2 0 {name=p354 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -1630 -860 2 0 {name=p362 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -1630 -1160 2 0 {name=p369 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -1630 -1760 2 0 {name=p378 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -1630 -2060 2 0 {name=p380 sig_type=std_logic lab=vpre10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -560 0 0 {name=x2150}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -860 0 0 {name=x2140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -1160 0 0 {name=x2130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -1460 0 0 {name=x2120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -1760 0 0 {name=x2110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Input_LIF.sym} -1780 -2060 0 0 {name=x2100}
C {devices/lab_pin.sym} -1170 -560 0 0 {name=p312 sig_type=std_logic lab=vpres15}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -4580 0 0 {name=x10}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -4280 0 0 {name=x20}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -3980 0 0 {name=x30}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -3680 0 0 {name=x40}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -3380 0 0 {name=x50}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -3080 0 0 {name=x60}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -2780 0 0 {name=x70}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -2480 0 0 {name=x80}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -2180 0 0 {name=x90}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -1880 0 0 {name=x100}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -1580 0 0 {name=x110}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -1280 0 0 {name=x120}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -980 0 0 {name=x130}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -680 0 0 {name=x140}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -1040 -380 0 0 {name=x150}
C {devices/lab_pin.sym} -1170 -860 0 0 {name=p359 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1170 -1160 0 0 {name=p367 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1170 -2060 0 0 {name=p216 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1170 -1760 0 0 {name=p376 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1630 -1460 2 0 {name=p159 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1170 -1460 0 0 {name=p373 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1100 -4810 0 0 {name=p63 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -4510 0 0 {name=p70 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -3310 0 0 {name=p140 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -2110 0 0 {name=p385 sig_type=std_logic lab=vdd_syn0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -4760 0 0 {name=x2012}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -4610 0 0 {name=x2013}
C {devices/lab_pin.sym} -1470 -4640 0 0 {name=p36 sig_type=std_logic lab=ctrl_wu}
C {devices/vsource.sym} 250 -2370 0 0 {name=V20 value="PWL(0 0 44.9u 0 45u 1.8)"}
C {devices/gnd.sym} 250 -2320 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 250 -2420 2 0 {name=p38 sig_type=std_logic lab=ctrl_pos}
C {devices/gnd.sym} -1410 -4260 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} -1470 -4490 0 0 {name=p22 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -4410 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} -1410 -4370 0 0 {name=p28 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -4520 0 0 {name=p33 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -4460 0 0 {name=x2022}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -4310 0 0 {name=x2023}
C {devices/lab_pin.sym} -1470 -4340 0 0 {name=p51 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -3960 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -1470 -4190 0 0 {name=p58 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -4110 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -1410 -4070 0 0 {name=p64 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -4220 0 0 {name=p67 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -4160 0 0 {name=x2032}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -4010 0 0 {name=x2033}
C {devices/lab_pin.sym} -1470 -4040 0 0 {name=p74 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -3660 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -1470 -3890 0 0 {name=p89 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -3810 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} -1410 -3770 0 0 {name=p92 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -3920 0 0 {name=p93 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -3860 0 0 {name=x2042}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -3710 0 0 {name=x2043}
C {devices/lab_pin.sym} -1470 -3740 0 0 {name=p101 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -3360 0 0 {name=l40 lab=GND}
C {devices/lab_pin.sym} -1470 -3590 0 0 {name=p111 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -3510 0 0 {name=l41 lab=GND}
C {devices/lab_pin.sym} -1410 -3470 0 0 {name=p113 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -3620 0 0 {name=p114 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -3560 0 0 {name=x2052}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -3410 0 0 {name=x2053}
C {devices/lab_pin.sym} -1470 -3440 0 0 {name=p121 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -3060 0 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} -1470 -3290 0 0 {name=p131 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -3210 0 0 {name=l44 lab=GND}
C {devices/lab_pin.sym} -1410 -3170 0 0 {name=p133 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -3320 0 0 {name=p134 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -3260 0 0 {name=x2062}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -3110 0 0 {name=x2063}
C {devices/lab_pin.sym} -1470 -3140 0 0 {name=p144 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -2760 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} -1470 -2990 0 0 {name=p150 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -2910 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} -1410 -2870 0 0 {name=p152 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -3020 0 0 {name=p153 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -2960 0 0 {name=x2072}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -2810 0 0 {name=x2073}
C {devices/lab_pin.sym} -1470 -2840 0 0 {name=p156 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -2460 0 0 {name=l49 lab=GND}
C {devices/lab_pin.sym} -1470 -2690 0 0 {name=p164 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -2610 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -1410 -2570 0 0 {name=p167 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -2720 0 0 {name=p168 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -2660 0 0 {name=x2082}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -2510 0 0 {name=x2083}
C {devices/lab_pin.sym} -1470 -2540 0 0 {name=p172 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -2160 0 0 {name=l52 lab=GND}
C {devices/lab_pin.sym} -1470 -2390 0 0 {name=p179 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -2310 0 0 {name=l53 lab=GND}
C {devices/lab_pin.sym} -1410 -2270 0 0 {name=p182 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -2420 0 0 {name=p183 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -2360 0 0 {name=x2092}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -2210 0 0 {name=x2093}
C {devices/lab_pin.sym} -1470 -2240 0 0 {name=p187 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -1860 0 0 {name=l55 lab=GND}
C {devices/lab_pin.sym} -1470 -2090 0 0 {name=p193 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -2010 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} -1410 -1970 0 0 {name=p195 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -2120 0 0 {name=p196 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -2060 0 0 {name=x2102}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -1910 0 0 {name=x2103}
C {devices/lab_pin.sym} -1470 -1940 0 0 {name=p199 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -1560 0 0 {name=l60 lab=GND}
C {devices/lab_pin.sym} -1470 -1790 0 0 {name=p205 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -1710 0 0 {name=l61 lab=GND}
C {devices/lab_pin.sym} -1410 -1670 0 0 {name=p207 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -1820 0 0 {name=p208 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -1760 0 0 {name=x2112}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -1610 0 0 {name=x2113}
C {devices/lab_pin.sym} -1470 -1640 0 0 {name=p211 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -1260 0 0 {name=l66 lab=GND}
C {devices/lab_pin.sym} -1470 -1490 0 0 {name=p220 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -1410 0 0 {name=l73 lab=GND}
C {devices/lab_pin.sym} -1410 -1370 0 0 {name=p222 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -1520 0 0 {name=p224 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -1460 0 0 {name=x2122}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -1310 0 0 {name=x2123}
C {devices/lab_pin.sym} -1470 -1340 0 0 {name=p228 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -960 0 0 {name=l78 lab=GND}
C {devices/lab_pin.sym} -1470 -1190 0 0 {name=p235 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -1110 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} -1410 -1070 0 0 {name=p237 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -1220 0 0 {name=p238 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -1160 0 0 {name=x2132}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -1010 0 0 {name=x2133}
C {devices/lab_pin.sym} -1470 -1040 0 0 {name=p241 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -660 0 0 {name=l83 lab=GND}
C {devices/lab_pin.sym} -1470 -890 0 0 {name=p247 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -810 0 0 {name=l84 lab=GND}
C {devices/lab_pin.sym} -1410 -770 0 0 {name=p249 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -920 0 0 {name=p250 sig_type=std_logic lab=vdd_inf}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -860 0 0 {name=x2142}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -710 0 0 {name=x2143}
C {devices/lab_pin.sym} -1470 -740 0 0 {name=p254 sig_type=std_logic lab=ctrl_wu}
C {devices/gnd.sym} -1410 -360 0 0 {name=l86 lab=GND}
C {devices/lab_pin.sym} -1470 -590 0 0 {name=p260 sig_type=std_logic lab=ctrl_inf}
C {devices/gnd.sym} -1410 -510 0 0 {name=l87 lab=GND}
C {devices/lab_pin.sym} -1410 -470 0 0 {name=p262 sig_type=std_logic lab=vdd_wu}
C {devices/lab_pin.sym} -1410 -620 0 0 {name=p263 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -1470 -380 0 0 {name=p265 sig_type=std_logic lab=vb_wu}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Inf_circuit.sym} -1410 -560 0 0 {name=x2152}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WU_Circuit.sym} -1410 -410 0 0 {name=x2153}
C {devices/lab_pin.sym} -1470 -440 0 0 {name=p267 sig_type=std_logic lab=ctrl_wu}
C {devices/lab_pin.sym} -1350 -4460 2 0 {name=p18 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1350 -4310 2 0 {name=p19 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -1470 -4460 0 0 {name=p14 sig_type=std_logic lab=vpre2}
C {devices/lab_pin.sym} -1470 -4160 0 0 {name=p53 sig_type=std_logic lab=vpre3}
C {devices/lab_pin.sym} -1350 -4160 2 0 {name=p55 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1350 -4010 2 0 {name=p57 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -1470 -3860 0 0 {name=p79 sig_type=std_logic lab=vpre4}
C {devices/lab_pin.sym} -1350 -3860 2 0 {name=p84 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1350 -3710 2 0 {name=p86 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -1350 -3560 2 0 {name=p103 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1350 -3410 2 0 {name=p104 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -1470 -3560 0 0 {name=p107 sig_type=std_logic lab=vpre5}
C {devices/lab_pin.sym} -1470 -3260 0 0 {name=p125 sig_type=std_logic lab=vpre6}
C {devices/lab_pin.sym} -1350 -3260 2 0 {name=p127 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1350 -3110 2 0 {name=p129 sig_type=std_logic lab=vpres6}
C {devices/lab_pin.sym} -1470 -560 0 0 {name=p146 sig_type=std_logic lab=vpre15}
C {devices/lab_pin.sym} -1350 -560 2 0 {name=p148 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1350 -410 2 0 {name=p149 sig_type=std_logic lab=vpres15}
C {devices/lab_pin.sym} -1470 -860 0 0 {name=p243 sig_type=std_logic lab=vpre14}
C {devices/lab_pin.sym} -1350 -860 2 0 {name=p245 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1350 -710 2 0 {name=p246 sig_type=std_logic lab=vpres14}
C {devices/lab_pin.sym} -1470 -1160 0 0 {name=p230 sig_type=std_logic lab=vpre13}
C {devices/lab_pin.sym} -1350 -1160 2 0 {name=p232 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1350 -1010 2 0 {name=p234 sig_type=std_logic lab=vpres13}
C {devices/lab_pin.sym} -1470 -1460 0 0 {name=p213 sig_type=std_logic lab=vpre12}
C {devices/lab_pin.sym} -1350 -1460 2 0 {name=p215 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1350 -1310 2 0 {name=p218 sig_type=std_logic lab=vpres12}
C {devices/lab_pin.sym} -1350 -1760 2 0 {name=p201 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1350 -1610 2 0 {name=p202 sig_type=std_logic lab=vpres11}
C {devices/lab_pin.sym} -1470 -1760 0 0 {name=p203 sig_type=std_logic lab=vpre11}
C {devices/lab_pin.sym} -1470 -2060 0 0 {name=p189 sig_type=std_logic lab=vpre10}
C {devices/lab_pin.sym} -1350 -2060 2 0 {name=p191 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1350 -1910 2 0 {name=p192 sig_type=std_logic lab=vpres10}
C {devices/lab_pin.sym} -1470 -2360 0 0 {name=p174 sig_type=std_logic lab=vpre9}
C {devices/lab_pin.sym} -1350 -2360 2 0 {name=p176 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1350 -2210 2 0 {name=p178 sig_type=std_logic lab=vpres9}
C {devices/lab_pin.sym} -1470 -2660 0 0 {name=p158 sig_type=std_logic lab=vpre8}
C {devices/lab_pin.sym} -1350 -2660 2 0 {name=p162 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1350 -2510 2 0 {name=p163 sig_type=std_logic lab=vpres8}
C {devices/lab_pin.sym} -1470 -2960 0 0 {name=p256 sig_type=std_logic lab=vpre7}
C {devices/lab_pin.sym} -1350 -2960 2 0 {name=p258 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1350 -2810 2 0 {name=p259 sig_type=std_logic lab=vpres7}
C {devices/lab_pin.sym} -1470 -680 0 0 {name=p44 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -980 0 0 {name=p98 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -1280 0 0 {name=p116 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -1580 0 0 {name=p154 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -1880 0 0 {name=p184 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -2180 0 0 {name=p209 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -2480 0 0 {name=p239 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -2780 0 0 {name=p270 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -3080 0 0 {name=p272 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -3380 0 0 {name=p274 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -3680 0 0 {name=p277 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -3980 0 0 {name=p279 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -4280 0 0 {name=p281 sig_type=std_logic lab=vb_wu}
C {devices/lab_pin.sym} -1470 -4580 0 0 {name=p283 sig_type=std_logic lab=vb_wu}
C {devices/vsource.sym} 440 -2650 0 0 {name=V22 value=1.8}
C {devices/gnd.sym} 440 -2600 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 440 -2700 2 0 {name=p285 sig_type=std_logic lab=vdd_inf}
C {devices/lab_pin.sym} -790 -260 1 0 {name=p355 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -820 -140 0 0 {name=l95 lab=GND}
C {devices/ammeter.sym} -750 -300 0 0 {name=Vmeas6 savecurrent=true}
C {devices/lab_pin.sym} -750 -340 2 0 {name=p356 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -750 -10 2 0 {name=p357 sig_type=std_logic lab=N6}
C {devices/lab_pin.sym} -680 -140 3 0 {name=p358 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -820 -260 1 0 {name=p360 sig_type=std_logic lab=inh6}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -750 -160 1 0 {name=x6}
C {devices/lab_pin.sym} -500 -260 1 0 {name=p375 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -530 -140 0 0 {name=l97 lab=GND}
C {devices/ammeter.sym} -460 -300 0 0 {name=Vmeas8 savecurrent=true}
C {devices/lab_pin.sym} -460 -340 2 0 {name=p377 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -460 -10 2 0 {name=p379 sig_type=std_logic lab=N8}
C {devices/lab_pin.sym} -390 -140 3 0 {name=p381 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -530 -260 1 0 {name=p383 sig_type=std_logic lab=inh8}
C {devices/lab_pin.sym} -420 -260 1 0 {name=p384 sig_type=std_logic lab=vlky_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -460 -160 1 0 {name=x8}
C {devices/lab_pin.sym} -1100 -4210 0 0 {name=p136 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -3910 0 0 {name=p138 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -3610 0 0 {name=p139 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -3010 0 0 {name=p406 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -2710 0 0 {name=p141 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -2410 0 0 {name=p142 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -1810 0 0 {name=p143 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -1510 0 0 {name=p386 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -1210 0 0 {name=p387 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -910 0 0 {name=p388 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} -1100 -610 0 0 {name=p389 sig_type=std_logic lab=vdd_syn0}
C {devices/lab_pin.sym} 160 -3170 2 0 {name=p421 sig_type=std_logic lab=inh6}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3150 3 0 {name=M6
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3180 2 0 {name=l107 lab=GND}
C {devices/lab_pin.sym} 120 -3120 2 0 {name=p422 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3170 0 0 {name=p423 sig_type=std_logic lab=ctrl_vinh}
C {devices/lab_pin.sym} 160 -3060 2 0 {name=p427 sig_type=std_logic lab=inh8}
C {sky130_fd_pr/nfet_01v8.sym} 120 -3040 3 0 {name=M8
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -3070 2 0 {name=l111 lab=GND}
C {devices/lab_pin.sym} 120 -3010 2 0 {name=p428 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -3060 0 0 {name=p429 sig_type=std_logic lab=ctrl_vinh}
C {devices/gnd.sym} -810 -4690 0 0 {name=l136 lab=GND}
C {devices/lab_pin.sym} -880 -4760 0 0 {name=p456 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -750 -4690 0 0 {name=Vmeas16 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -4620 0 0 {name=M16
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -4620 3 0 {name=l137 lab=GND}
C {devices/lab_pin.sym} -750 -4580 2 0 {name=p458 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -4620 0 0 {name=p459 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -4580 0 0 {name=x16}
C {devices/lab_pin.sym} -810 -4810 0 0 {name=p460 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -4690 0 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -590 -4760 0 0 {name=p468 sig_type=std_logic lab=vpres1}
C {devices/ammeter.sym} -460 -4690 0 0 {name=Vmeas18 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4620 0 0 {name=M18
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4620 3 0 {name=l141 lab=GND}
C {devices/lab_pin.sym} -460 -4580 2 0 {name=p470 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4620 0 0 {name=p471 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4580 0 0 {name=x18}
C {devices/lab_pin.sym} -520 -4810 0 0 {name=p472 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -4390 0 0 {name=l156 lab=GND}
C {devices/ammeter.sym} -750 -4390 0 0 {name=Vmeas26 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -4320 0 0 {name=M26
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -4320 3 0 {name=l157 lab=GND}
C {devices/lab_pin.sym} -750 -4280 2 0 {name=p505 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -4320 0 0 {name=p506 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -4280 0 0 {name=x26}
C {devices/lab_pin.sym} -810 -4510 0 0 {name=p507 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -4390 0 0 {name=l160 lab=GND}
C {devices/ammeter.sym} -460 -4390 0 0 {name=Vmeas28 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4320 0 0 {name=M28
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4320 3 0 {name=l161 lab=GND}
C {devices/lab_pin.sym} -460 -4280 2 0 {name=p517 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4320 0 0 {name=p518 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -4280 0 0 {name=x28}
C {devices/lab_pin.sym} -520 -4510 0 0 {name=p519 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -4090 0 0 {name=l176 lab=GND}
C {devices/ammeter.sym} -750 -4090 0 0 {name=Vmeas36 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -4020 0 0 {name=M36
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -4020 3 0 {name=l177 lab=GND}
C {devices/lab_pin.sym} -750 -3980 2 0 {name=p552 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -4020 0 0 {name=p553 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -3980 0 0 {name=x36}
C {devices/lab_pin.sym} -810 -4210 0 0 {name=p554 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -4090 0 0 {name=l180 lab=GND}
C {devices/ammeter.sym} -460 -4090 0 0 {name=Vmeas38 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -4020 0 0 {name=M38
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -4020 3 0 {name=l181 lab=GND}
C {devices/lab_pin.sym} -460 -3980 2 0 {name=p562 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -4020 0 0 {name=p564 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3980 0 0 {name=x38}
C {devices/lab_pin.sym} -520 -4210 0 0 {name=p566 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -3790 0 0 {name=l196 lab=GND}
C {devices/ammeter.sym} -750 -3790 0 0 {name=Vmeas46 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -3720 0 0 {name=M46
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -3720 3 0 {name=l197 lab=GND}
C {devices/lab_pin.sym} -750 -3680 2 0 {name=p599 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -3720 0 0 {name=p600 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -3680 0 0 {name=x46}
C {devices/lab_pin.sym} -810 -3910 0 0 {name=p601 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -3790 0 0 {name=l200 lab=GND}
C {devices/ammeter.sym} -460 -3790 0 0 {name=Vmeas48 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3720 0 0 {name=M48
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3720 3 0 {name=l201 lab=GND}
C {devices/lab_pin.sym} -460 -3680 2 0 {name=p609 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3720 0 0 {name=p610 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3680 0 0 {name=x48}
C {devices/lab_pin.sym} -520 -3910 0 0 {name=p614 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -3490 0 0 {name=l216 lab=GND}
C {devices/ammeter.sym} -750 -3490 0 0 {name=Vmeas56 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -3420 0 0 {name=M56
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -3420 3 0 {name=l217 lab=GND}
C {devices/lab_pin.sym} -750 -3380 2 0 {name=p648 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -3420 0 0 {name=p649 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -3380 0 0 {name=x56}
C {devices/lab_pin.sym} -810 -3610 0 0 {name=p650 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -3490 0 0 {name=l220 lab=GND}
C {devices/ammeter.sym} -460 -3490 0 0 {name=Vmeas58 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3420 0 0 {name=M58
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3420 3 0 {name=l221 lab=GND}
C {devices/lab_pin.sym} -460 -3380 2 0 {name=p658 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3420 0 0 {name=p659 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3380 0 0 {name=x58}
C {devices/lab_pin.sym} -520 -3610 0 0 {name=p660 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -3190 0 0 {name=l236 lab=GND}
C {devices/lab_pin.sym} -880 -3260 0 0 {name=p726 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -750 -3190 0 0 {name=Vmeas66 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -3120 0 0 {name=M66
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -3120 3 0 {name=l237 lab=GND}
C {devices/lab_pin.sym} -750 -3080 2 0 {name=p728 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -3120 0 0 {name=p729 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -3080 0 0 {name=x66}
C {devices/lab_pin.sym} -810 -3310 0 0 {name=p730 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -3190 0 0 {name=l240 lab=GND}
C {devices/lab_pin.sym} -590 -3260 0 0 {name=p736 sig_type=std_logic lab=vpres6}
C {devices/ammeter.sym} -460 -3190 0 0 {name=Vmeas68 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -3120 0 0 {name=M68
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -3120 3 0 {name=l241 lab=GND}
C {devices/lab_pin.sym} -460 -3080 2 0 {name=p738 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -3120 0 0 {name=p739 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -3080 0 0 {name=x68}
C {devices/lab_pin.sym} -520 -3310 0 0 {name=p740 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -2890 0 0 {name=l268 lab=GND}
C {devices/lab_pin.sym} -880 -2960 0 0 {name=p771 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -750 -2890 0 0 {name=Vmeas76 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -2820 0 0 {name=M76
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -2820 3 0 {name=l269 lab=GND}
C {devices/lab_pin.sym} -750 -2780 2 0 {name=p773 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -2820 0 0 {name=p774 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -2780 0 0 {name=x76}
C {devices/lab_pin.sym} -810 -3010 0 0 {name=p775 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -2890 0 0 {name=l272 lab=GND}
C {devices/lab_pin.sym} -590 -2960 0 0 {name=p781 sig_type=std_logic lab=vpres7}
C {devices/ammeter.sym} -460 -2890 0 0 {name=Vmeas78 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2820 0 0 {name=M78
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2820 3 0 {name=l273 lab=GND}
C {devices/lab_pin.sym} -460 -2780 2 0 {name=p783 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2820 0 0 {name=p784 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2780 0 0 {name=x78}
C {devices/lab_pin.sym} -520 -3010 0 0 {name=p785 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -2590 0 0 {name=l286 lab=GND}
C {devices/lab_pin.sym} -880 -2660 0 0 {name=p816 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -750 -2590 0 0 {name=Vmeas86 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -2520 0 0 {name=M86
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -2520 3 0 {name=l287 lab=GND}
C {devices/lab_pin.sym} -750 -2480 2 0 {name=p818 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -2520 0 0 {name=p819 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -2480 0 0 {name=x86}
C {devices/lab_pin.sym} -810 -2710 0 0 {name=p820 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -2590 0 0 {name=l290 lab=GND}
C {devices/lab_pin.sym} -590 -2660 0 0 {name=p826 sig_type=std_logic lab=vpres8}
C {devices/ammeter.sym} -460 -2590 0 0 {name=Vmeas88 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2520 0 0 {name=M88
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2520 3 0 {name=l291 lab=GND}
C {devices/lab_pin.sym} -460 -2480 2 0 {name=p828 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2520 0 0 {name=p829 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2480 0 0 {name=x88}
C {devices/lab_pin.sym} -520 -2710 0 0 {name=p830 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -2290 0 0 {name=l304 lab=GND}
C {devices/lab_pin.sym} -880 -2360 0 0 {name=p861 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -750 -2290 0 0 {name=Vmeas96 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -2220 0 0 {name=M96
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -2220 3 0 {name=l305 lab=GND}
C {devices/lab_pin.sym} -750 -2180 2 0 {name=p863 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -2220 0 0 {name=p864 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -2180 0 0 {name=x96}
C {devices/lab_pin.sym} -810 -2410 0 0 {name=p865 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -2290 0 0 {name=l308 lab=GND}
C {devices/lab_pin.sym} -590 -2360 0 0 {name=p871 sig_type=std_logic lab=vpres9}
C {devices/ammeter.sym} -460 -2290 0 0 {name=Vmeas98 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -2220 0 0 {name=M98
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -2220 3 0 {name=l309 lab=GND}
C {devices/lab_pin.sym} -460 -2180 2 0 {name=p873 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -2220 0 0 {name=p874 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -2180 0 0 {name=x98}
C {devices/lab_pin.sym} -520 -2410 0 0 {name=p875 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -1990 0 0 {name=l322 lab=GND}
C {devices/lab_pin.sym} -880 -2060 0 0 {name=p906 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -750 -1990 0 0 {name=Vmeas106 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -1920 0 0 {name=M106
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -1920 3 0 {name=l323 lab=GND}
C {devices/lab_pin.sym} -750 -1880 2 0 {name=p908 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -1920 0 0 {name=p909 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -1880 0 0 {name=x106}
C {devices/lab_pin.sym} -810 -2110 0 0 {name=p910 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -1990 0 0 {name=l326 lab=GND}
C {devices/lab_pin.sym} -590 -2060 0 0 {name=p916 sig_type=std_logic lab=vpres10}
C {devices/ammeter.sym} -460 -1990 0 0 {name=Vmeas108 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1920 0 0 {name=M108
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1920 3 0 {name=l327 lab=GND}
C {devices/lab_pin.sym} -460 -1880 2 0 {name=p918 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1920 0 0 {name=p919 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1880 0 0 {name=x108}
C {devices/lab_pin.sym} -520 -2110 0 0 {name=p920 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -1690 0 0 {name=l340 lab=GND}
C {devices/lab_pin.sym} -880 -1760 0 0 {name=p951 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -750 -1690 0 0 {name=Vmeas116 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -1620 0 0 {name=M116
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -1620 3 0 {name=l341 lab=GND}
C {devices/lab_pin.sym} -750 -1580 2 0 {name=p953 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -1620 0 0 {name=p954 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -1580 0 0 {name=x116}
C {devices/lab_pin.sym} -810 -1810 0 0 {name=p955 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -1690 0 0 {name=l344 lab=GND}
C {devices/lab_pin.sym} -590 -1760 0 0 {name=p961 sig_type=std_logic lab=vpres11}
C {devices/ammeter.sym} -460 -1690 0 0 {name=Vmeas118 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1620 0 0 {name=M118
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1620 3 0 {name=l345 lab=GND}
C {devices/lab_pin.sym} -460 -1580 2 0 {name=p963 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1620 0 0 {name=p964 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1580 0 0 {name=x118}
C {devices/lab_pin.sym} -520 -1810 0 0 {name=p965 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -1390 0 0 {name=l358 lab=GND}
C {devices/lab_pin.sym} -880 -1460 0 0 {name=p996 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -750 -1390 0 0 {name=Vmeas126 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -1320 0 0 {name=M126
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -1320 3 0 {name=l359 lab=GND}
C {devices/lab_pin.sym} -750 -1280 2 0 {name=p998 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -1320 0 0 {name=p999 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -1280 0 0 {name=x126}
C {devices/lab_pin.sym} -810 -1510 0 0 {name=p1000 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -1390 0 0 {name=l362 lab=GND}
C {devices/lab_pin.sym} -590 -1460 0 0 {name=p1006 sig_type=std_logic lab=vpres12}
C {devices/ammeter.sym} -460 -1390 0 0 {name=Vmeas128 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1320 0 0 {name=M128
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1320 3 0 {name=l363 lab=GND}
C {devices/lab_pin.sym} -460 -1280 2 0 {name=p1008 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1320 0 0 {name=p1009 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -1280 0 0 {name=x128}
C {devices/lab_pin.sym} -520 -1510 0 0 {name=p1010 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -1090 0 0 {name=l376 lab=GND}
C {devices/lab_pin.sym} -880 -1160 0 0 {name=p1041 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -750 -1090 0 0 {name=Vmeas136 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -1020 0 0 {name=M136
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -1020 3 0 {name=l377 lab=GND}
C {devices/lab_pin.sym} -750 -980 2 0 {name=p1043 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -1020 0 0 {name=p1044 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -980 0 0 {name=x136}
C {devices/lab_pin.sym} -810 -1210 0 0 {name=p1045 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -1090 0 0 {name=l380 lab=GND}
C {devices/lab_pin.sym} -590 -1160 0 0 {name=p1051 sig_type=std_logic lab=vpres13}
C {devices/ammeter.sym} -460 -1090 0 0 {name=Vmeas138 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -1020 0 0 {name=M138
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -1020 3 0 {name=l381 lab=GND}
C {devices/lab_pin.sym} -460 -980 2 0 {name=p1053 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -1020 0 0 {name=p1054 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -980 0 0 {name=x138}
C {devices/lab_pin.sym} -520 -1210 0 0 {name=p1055 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -790 0 0 {name=l394 lab=GND}
C {devices/lab_pin.sym} -880 -860 0 0 {name=p1086 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -750 -790 0 0 {name=Vmeas146 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -720 0 0 {name=M146
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -720 3 0 {name=l395 lab=GND}
C {devices/lab_pin.sym} -750 -680 2 0 {name=p1088 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -720 0 0 {name=p1089 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -680 0 0 {name=x146}
C {devices/lab_pin.sym} -810 -910 0 0 {name=p1090 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -790 0 0 {name=l398 lab=GND}
C {devices/lab_pin.sym} -590 -860 0 0 {name=p1096 sig_type=std_logic lab=vpres14}
C {devices/ammeter.sym} -460 -790 0 0 {name=Vmeas148 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -720 0 0 {name=M148
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -720 3 0 {name=l399 lab=GND}
C {devices/lab_pin.sym} -460 -680 2 0 {name=p1098 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -720 0 0 {name=p1099 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -680 0 0 {name=x148}
C {devices/lab_pin.sym} -520 -910 0 0 {name=p1100 sig_type=std_logic lab=vdd_syn8}
C {devices/gnd.sym} -810 -490 0 0 {name=l412 lab=GND}
C {devices/lab_pin.sym} -880 -560 0 0 {name=p1131 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -750 -490 0 0 {name=Vmeas156 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -770 -420 0 0 {name=M156
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -740 -420 3 0 {name=l413 lab=GND}
C {devices/lab_pin.sym} -750 -380 2 0 {name=p1133 sig_type=std_logic lab=p6}
C {devices/lab_pin.sym} -800 -420 0 0 {name=p1134 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -750 -380 0 0 {name=x156}
C {devices/lab_pin.sym} -810 -610 0 0 {name=p1135 sig_type=std_logic lab=vdd_syn6}
C {devices/gnd.sym} -520 -490 0 0 {name=l416 lab=GND}
C {devices/lab_pin.sym} -590 -560 0 0 {name=p1141 sig_type=std_logic lab=vpres15}
C {devices/ammeter.sym} -460 -490 0 0 {name=Vmeas158 savecurrent=true}
C {sky130_fd_pr/nfet_01v8.sym} -480 -420 0 0 {name=M158
L=\{L_out\}
W=\{W_out\}
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -450 -420 3 0 {name=l417 lab=GND}
C {devices/lab_pin.sym} -460 -380 2 0 {name=p1143 sig_type=std_logic lab=p8}
C {devices/lab_pin.sym} -510 -420 0 0 {name=p1144 sig_type=std_logic lab=ctrl_pos}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Syn_6T1R.sym} -460 -380 0 0 {name=x158}
C {devices/lab_pin.sym} -520 -610 0 0 {name=p1145 sig_type=std_logic lab=vdd_syn8}
C {devices/lab_pin.sym} -880 -3560 0 0 {name=p636 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -590 -3560 0 0 {name=p641 sig_type=std_logic lab=vpres5}
C {devices/lab_pin.sym} -880 -3860 0 0 {name=p489 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -590 -3860 0 0 {name=p494 sig_type=std_logic lab=vpres4}
C {devices/lab_pin.sym} -880 -4160 0 0 {name=p536 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -590 -4160 0 0 {name=p541 sig_type=std_logic lab=vpres3}
C {devices/lab_pin.sym} -880 -4460 0 0 {name=p583 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} -590 -4460 0 0 {name=p588 sig_type=std_logic lab=vpres2}
C {devices/lab_pin.sym} 30 -4380 0 0 {name=p1156 sig_type=std_logic lab=N6}
C {devices/lab_pin.sym} 30 -4400 0 0 {name=p1158 sig_type=std_logic lab=N8}
C {devices/vsource.sym} 620 -2790 0 0 {name=V28 value=1.8}
C {devices/gnd.sym} 620 -2740 0 0 {name=l424 lab=GND}
C {devices/lab_pin.sym} 620 -2840 2 0 {name=p1165 sig_type=std_logic lab=vdd_syn6}
C {devices/vsource.sym} 820 -2790 0 0 {name=V30 value=1.8}
C {devices/gnd.sym} 820 -2740 0 0 {name=l426 lab=GND}
C {devices/lab_pin.sym} 820 -2840 2 0 {name=p1167 sig_type=std_logic lab=vdd_syn8}
C {devices/vsource.sym} 700 -2650 0 0 {name=V32 value="PWL(0 0 9.9u 0 10u 1.8 39.9u 1.8 40u 0)"}
C {devices/gnd.sym} 700 -2600 0 0 {name=l428 lab=GND}
C {devices/lab_pin.sym} 700 -2700 2 0 {name=p1169 sig_type=std_logic lab=b_px}
C {devices/vsource.sym} 620 -2650 0 0 {name=V33 value=0}
C {devices/gnd.sym} 620 -2600 0 0 {name=l429 lab=GND}
C {devices/lab_pin.sym} 620 -2700 2 0 {name=p1170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -560 2 0 {name=p27 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -860 2 0 {name=p30 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -1160 2 0 {name=p160 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -1460 2 0 {name=p165 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -1760 2 0 {name=p170 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -2060 2 0 {name=p177 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -2360 2 0 {name=p180 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -2660 2 0 {name=p185 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -2960 2 0 {name=p382 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -3260 2 0 {name=p392 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -3560 2 0 {name=p394 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -3860 2 0 {name=p396 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -4160 2 0 {name=p400 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -1030 -4460 2 0 {name=p401 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1030 -4760 2 0 {name=p405 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -4760 2 0 {name=p551 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -4760 2 0 {name=p556 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -560 2 0 {name=p597 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -560 2 0 {name=p602 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -860 2 0 {name=p607 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -860 2 0 {name=p608 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -1160 2 0 {name=p663 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1160 2 0 {name=p668 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -1460 2 0 {name=p732 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -1460 2 0 {name=p742 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -1760 2 0 {name=p772 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -1760 2 0 {name=p782 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -2060 2 0 {name=p797 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -2060 2 0 {name=p817 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -2360 2 0 {name=p852 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -2360 2 0 {name=p862 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -2660 2 0 {name=p892 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -2660 2 0 {name=p902 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -2960 2 0 {name=p932 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -2960 2 0 {name=p942 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -3260 2 0 {name=p972 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -3260 2 0 {name=p982 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -3560 2 0 {name=p1012 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -450 -3560 2 0 {name=p1022 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -3860 2 0 {name=p1052 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -3860 2 0 {name=p1057 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -740 -4160 2 0 {name=p1092 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4160 2 0 {name=p1102 sig_type=std_logic lab=w_px}
C {devices/lab_pin.sym} -740 -4460 2 0 {name=p1132 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -450 -4460 2 0 {name=p1142 sig_type=std_logic lab=b_px}
C {devices/lab_pin.sym} -1080 -260 1 0 {name=p2 sig_type=std_logic lab=vb_pos}
C {devices/gnd.sym} -1110 -140 0 0 {name=l16 lab=GND}
C {devices/ammeter.sym} -1040 -300 0 0 {name=Vmeas160 savecurrent=true}
C {devices/lab_pin.sym} -1040 -340 2 0 {name=p12 sig_type=std_logic lab=p0}
C {devices/lab_pin.sym} -1040 -10 2 0 {name=p15 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} -970 -140 3 0 {name=p16 sig_type=std_logic lab=vdd_pos}
C {devices/lab_pin.sym} -1110 -260 1 0 {name=p17 sig_type=std_logic lab=inh0}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/Output_LIF.sym} -1040 -160 1 0 {name=x200}
C {devices/lab_pin.sym} 30 -4360 0 0 {name=p24 sig_type=std_logic lab=N0}
C {devices/lab_pin.sym} 160 -4180 2 0 {name=p31 sig_type=std_logic lab=inh0}
C {sky130_fd_pr/nfet_01v8.sym} 120 -4160 3 0 {name=M160
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 120 -4190 2 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} 120 -4130 2 0 {name=p32 sig_type=std_logic lab=inh_d}
C {devices/lab_pin.sym} 80 -4180 0 0 {name=p45 sig_type=std_logic lab=ctrl_vinh}
C {devices/vsource.sym} 270 -2510 0 0 {name=V4 savecurrent=false value=0.5}
C {devices/lab_pin.sym} 270 -2560 2 0 {name=p49 sig_type=std_logic lab=vb_tr}
C {devices/gnd.sym} 270 -2460 0 0 {name=l24 lab=GND}
C {devices/vsource.sym} 100 -2370 0 0 {name=V12 savecurrent=false value="PWL(0 0 9.9u 0 10u 1.8 79.9u 1.8 80u 0)"}
C {devices/lab_pin.sym} 100 -2420 2 0 {name=p52 sig_type=std_logic lab=ctrl_tr}
C {devices/gnd.sym} 100 -2320 0 0 {name=l29 lab=GND}
C {devices/launcher.sym} 90 -1915 0 0 {name=h3
descr="inference between 0_6_8"
tclcommand="xschem raw_read $netlist_dir/SNN_15x3_InfStage_068_tb.raw tran"
}
C {devices/gnd.sym} 30 -4540 1 0 {name=l33 lab=GND}
C {devices/vsource.sym} 420 -2510 0 0 {name=V21 value=0}
C {devices/gnd.sym} 420 -2460 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 420 -2560 2 0 {name=p54 sig_type=std_logic lab=vlky_pos}
C {devices/lab_pin.sym} -710 -260 1 0 {name=p56 sig_type=std_logic lab=vlky_pos}
C {devices/lab_pin.sym} -1000 -260 1 0 {name=p59 sig_type=std_logic lab=vlky_pos}
C {devices/lab_pin.sym} -1880 -600 1 0 {name=p20 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -1500 1 0 {name=p60 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -1200 1 0 {name=p61 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -1800 1 0 {name=p62 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -2100 1 0 {name=p68 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -2400 1 0 {name=p69 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -2700 1 0 {name=p72 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -3000 1 0 {name=p77 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -3300 1 0 {name=p83 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -3600 1 0 {name=p85 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -3900 1 0 {name=p87 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -4200 1 0 {name=p90 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -4500 1 0 {name=p94 sig_type=std_logic lab=vlky_pre}
C {devices/lab_pin.sym} -1880 -4800 1 0 {name=p96 sig_type=std_logic lab=vlky_pre}
C {/home/ricardo/RATT_repos/Proyectos_xschem/SNN/WTA_circuit.sym} 150 -4440 0 0 {name=x1}
C {devices/vsource.sym} 420 -2370 0 0 {name=V23 value="PWL(0 0 98.99u 0 99u 1.8 99.99u 1.8 100u 0 148.99u 0 149u 1.8 149.99u 1.8 150u 0 198.99u 0 199u 1.8 199.99u 1.8 200u)"}
C {devices/gnd.sym} 420 -2320 0 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 420 -2420 2 0 {name=p97 sig_type=std_logic lab=ctrl_newp}
C {devices/lab_pin.sym} 20 -4340 3 0 {name=p99 sig_type=std_logic lab=ctrl_newp}
C {devices/launcher.sym} 90 -1885 0 0 {name=h4
descr="inference between 3 patterns"
tclcommand="xschem raw_read $netlist_dir/SNN_15x3_InfStage_3p_tb.raw tran"
}
C {devices/lab_pin.sym} 30 -4360 0 0 {name=p100 sig_type=std_logic lab=N0}
